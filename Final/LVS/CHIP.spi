$ Spice netlist generated by v2lvs
$ v2022.3_33.19    Tue Sep 6 12:09:54 PDT 2022
.INCLUDE "core.spi"
.INCLUDE "umc18_io_lvs.spi"
*.BUSDELIMITER [

.SUBCKT Adder_relu i_data_0[24] i_data_0[23] i_data_0[22] i_data_0[21]
+ i_data_0[20] i_data_0[19] i_data_0[18] i_data_0[17] i_data_0[16] i_data_0[15]
+ i_data_0[14] i_data_0[13] i_data_0[12] i_data_0[11] i_data_0[10] i_data_0[9]
+ i_data_0[8] i_data_0[7] i_data_0[6] i_data_0[5] i_data_0[4] i_data_0[3]
+ i_data_0[2] i_data_0[1] i_data_0[0] i_data_1[24] i_data_1[23] i_data_1[22]
+ i_data_1[21] i_data_1[20] i_data_1[19] i_data_1[18] i_data_1[17] i_data_1[16]
+ i_data_1[15] i_data_1[14] i_data_1[13] i_data_1[12] i_data_1[11] i_data_1[10]
+ i_data_1[9] i_data_1[8] i_data_1[7] i_data_1[6] i_data_1[5] i_data_1[4]
+ i_data_1[3] i_data_1[2] i_data_1[1] i_data_1[0] i_data_2[24] i_data_2[23]
+ i_data_2[22] i_data_2[21] i_data_2[20] i_data_2[19] i_data_2[18] i_data_2[17]
+ i_data_2[16] i_data_2[15] i_data_2[14] i_data_2[13] i_data_2[12] i_data_2[11]
+ i_data_2[10] i_data_2[9] i_data_2[8] i_data_2[7] i_data_2[6] i_data_2[5]
+ i_data_2[4] i_data_2[3] i_data_2[2] i_data_2[1] i_data_2[0] o_data[20]
+ o_data[19] o_data[18] o_data[17] o_data[16] o_data[15] o_data[14] o_data[13]
+ o_data[12] o_data[11] o_data[10] o_data[9] o_data[8] o_data[7] o_data[6]
+ o_data[5] o_data[4] o_data[3] o_data[2] o_data[1] o_data[0]
XFE_OFC2038_n508 INV2 $PINS O=FE_OFN1423_FE_DBTN50_n508 I=n508
XFE_RC_52_0 MOAI1 $PINS O=o_data[5] A1=FE_OFN1415_n25 A2=n349 B1=n16 B2=n348
XFE_OFC1796_n508 INV2 $PINS O=FE_OFN1691_n508 I=n508
XFE_OFC1794_n508 INV1S $PINS O=FE_OFN1422_FE_DBTN50_n508 I=n508
XFE_OFC1768_pconv_2_r_23 INV1S $PINS O=n137 I=i_data_2[24]
XFE_OFC1713_pconv_0_r_23 INV1S $PINS O=n136 I=i_data_0[24]
XFE_OFC1675_n25 BUF2 $PINS O=FE_OFN1415_n25 I=n25
XFE_OFC1416_n432 BUF1S $PINS O=FE_OFN1416_n432 I=n432
XFE_OFC1127_FE_DBTN51_n212 BUF1S $PINS O=FE_OFN1127_FE_DBTN51_n212
+ I=FE_DBTN51_n212
XFE_OFC1126_FE_DBTN52_n262 BUF1CK $PINS O=FE_OFN1126_FE_DBTN52_n262
+ I=FE_DBTN52_n262
XFE_OFC1125_FE_DBTN53_n372 BUF1 $PINS O=FE_OFN1125_FE_DBTN53_n372
+ I=FE_DBTN53_n372
XFE_DBTC53_n372 INV1S $PINS O=FE_DBTN53_n372 I=n372
XFE_DBTC52_n262 INV2CK $PINS O=FE_DBTN52_n262 I=n262
XFE_DBTC51_n212 INV1S $PINS O=FE_DBTN51_n212 I=n212
XU3 NR2 $PINS O=n17 I1=n260 I2=FE_DBTN52_n262
XU5 INV1S $PINS O=n432 I=n276
XU6 INV1S $PINS O=n270 I=n269
XU7 XOR2HS $PINS O=n259 I1=n49 I2=n90
XU8 ND2 $PINS O=n276 I1=n155 I2=n154
XU9 NR2 $PINS O=n135 I1=n133 I2=n475
XU10 NR2 $PINS O=n221 I1=n143 I2=n144
XU11 INV1S $PINS O=n70 I=n69
XU12 INV1S $PINS O=n6 I=n77
XU13 INV1S $PINS O=n202 I=i_data_1[24]
XU14 NR2 $PINS O=n412 I1=n116 I2=n117
XU15 NR2 $PINS O=n50 I1=n45 I2=n46
XU16 NR2 $PINS O=n44 I1=n74 I2=n77
XU18 FA1S $PINS S=n184 CO=n186 A=i_data_1[18] B=i_data_2[18] CI=i_data_0[18]
XU19 OAI12HS $PINS O=n441 A1=n485 B1=n484 B2=n488
XU20 ND2 $PINS O=n488 I1=n123 I2=n122
XU21 OAI12H $PINS O=n98 A1=n266 B1=n269 B2=n265
XU22 FA1S $PINS S=n163 CO=n166 A=i_data_1[12] B=i_data_2[12] CI=i_data_0[12]
XU23 AOI12HS $PINS O=n269 A1=n95 B1=n294 B2=n295
XU24 OR2 $PINS O=n294 I1=n151 I2=n94
XU25 FA1S $PINS S=n171 CO=n172 A=i_data_1[15] B=i_data_2[15] CI=i_data_0[15]
XU26 FA1S $PINS S=n173 CO=n181 A=i_data_1[16] B=i_data_2[16] CI=i_data_0[16]
XU27 ND2 $PINS O=n402 I1=n113 I2=n112
XU28 AOI12HP $PINS O=n281 A1=n98 B1=n297 B2=n99
XU29 INV2 $PINS O=n297 I=n90
XU30 FA1S $PINS S=n161 CO=n162 A=i_data_1[11] B=i_data_2[11] CI=i_data_0[11]
XU31 FA1 $PINS S=n38 CO=n39 A=i_data_1[2] B=i_data_2[2] CI=i_data_0[2]
XU32 NR2 $PINS O=n454 I1=n193 I2=n499
XU34 INV1S $PINS O=n146 I=n240
XU35 OA12 $PINS O=n25 A1=n145 B1=n148 B2=n146
XU36 NR2 $PINS O=n507 I1=FE_OFN1126_FE_DBTN52_n262 I2=n260
XU37 XOR2HS $PINS O=n1 I1=n496 I2=n495
XU38 XOR2HS $PINS O=n2 I1=n391 I2=n390
XU39 XOR2HS $PINS O=n3 I1=n450 I2=n449
XU40 XOR2HS $PINS O=n4 I1=n149 I2=n247
XU41 XNR2HS $PINS O=n5 I1=n249 I2=n248
XU44 ND2S $PINS O=n211 I1=n197 I2=n196
XU46 ND2S $PINS O=n349 I1=n338 I2=FE_OFN1126_FE_DBTN52_n262
XU47 ND2S $PINS O=n330 I1=n325 I2=FE_OFN1126_FE_DBTN52_n262
XU48 ND2S $PINS O=n370 I1=n360 I2=FE_OFN1126_FE_DBTN52_n262
XU49 ND2S $PINS O=n315 I1=FE_DBTN52_n262 I2=n300
XU50 ND3 $PINS O=n89 I1=n20 I2=n79 I3=n19
XU51 ND2S $PINS O=n408 I1=n422 I2=n420
XU52 ND2S $PINS O=n431 I1=n428 I2=n422
XU53 ND2S $PINS O=n383 I1=n422 I2=n381
XU54 ND2S $PINS O=n229 I1=n223 I2=n222
XU55 ND2S $PINS O=n467 I1=n461 I2=n464
XU56 ND2S $PINS O=n391 I1=n387 I2=n442
XU57 ND2S $PINS O=n337 I1=n333 I2=n332
XU58 ND2S $PINS O=n477 I1=n490 I2=n488
XU59 ND2S $PINS O=n469 I1=n460 I2=n459
XU60 ND2S $PINS O=n496 I1=n486 I2=n485
XU61 ND2S $PINS O=n358 I1=n352 I2=n351
XU62 OR2 $PINS O=n67 I1=n66 I2=n65
XU63 ND2S $PINS O=n249 I1=n244 I2=n243
XU64 ND2S $PINS O=n273 I1=n267 I2=n266
XU65 ND2S $PINS O=n257 I1=n251 I2=n250
XU66 ND2S $PINS O=n450 I1=n438 I2=n437
XU67 ND2S $PINS O=n282 I1=n355 I2=n353
XU68 ND2S $PINS O=n416 I1=n464 I2=n462
XU69 ND2S $PINS O=n373 I1=n371 I2=n402
XU70 ND2S $PINS O=n405 I1=n401 I2=n400
XU71 ND2S $PINS O=n324 I1=n318 I2=n317
XU72 ND2S $PINS O=n345 I1=n363 I2=n362
XU73 ND2S $PINS O=n385 I1=n376 I2=n375
XU74 ND2S $PINS O=n328 I1=n381 I2=n379
XU75 ND2S $PINS O=n299 I1=n294 I2=n293
XU76 ND2S $PINS O=n368 I1=n362 I2=n361
XU77 ND2S $PINS O=n456 I1=n452 I2=n451
XU78 ND2S $PINS O=n78 I1=n76 I2=n75
XU79 ND2S $PINS O=n51 I1=n85 I2=n83
XU80 ND2S $PINS O=n410 I1=n406 I2=n424
XU81 ND2S $PINS O=n505 I1=n498 I2=n497
XU82 ND2S $PINS O=n219 I1=n180 I2=n211
XU83 ND2S $PINS O=n149 I1=n246 I2=n147
XU84 ND2S $PINS O=n471 I1=n480 I2=n470
XU85 ND2S $PINS O=n482 I1=n29 I2=n478
XU86 ND2S $PINS O=n397 I1=n28 I2=n392
XU87 ND2S $PINS O=n60 I1=n59 I2=n58
XU88 OR2 $PINS O=n180 I1=n196 I2=n197
XU92 NR2P $PINS O=n508 I1=n262 I2=FE_OFN1415_n25
XU95 NR2 $PINS O=n16 I1=n260 I2=FE_DBTN52_n262
XU96 OR2 $PINS O=n18 I1=n202 I2=n203
XU97 XOR2HS $PINS O=n19 I1=n78 I2=n6
XU98 XOR2HS $PINS O=n20 I1=n51 I2=n26
XU99 XNR2HS $PINS O=n21 I1=n373 I2=FE_DBTN53_n372
XU100 XOR2HS $PINS O=n22 I1=n416 I2=n415
XU101 XOR2HS $PINS O=n23 I1=n469 I2=n468
XU102 XNR2HS $PINS O=n24 I1=n229 I2=n228
XU103 AO12P $PINS O=n26 A1=n43 B1=n44 B2=n69
XU104 AN2 $PINS O=n27 I1=n203 I2=n202
XU105 OR2 $PINS O=n28 I1=n188 I2=n189
XU106 OR2 $PINS O=n29 I1=n183 I2=n184
XU107 XOR2HS $PINS O=n30 I1=n477 I2=n476
XU108 XOR2HS $PINS O=n31 I1=n405 I2=n404
XU109 XNR2HS $PINS O=n32 I1=n242 I2=n241
XU110 OAI12HS $PINS O=n306 A1=n81 B1=n80 B2=n83
XU111 OAI12HS $PINS O=n134 A1=n132 B1=n474 B2=n133
XU112 NR3 $PINS O=n79 I1=n73 I2=n67 I3=n72
XU113 NR2 $PINS O=n145 I1=n242 I2=n239
XU115 NR2 $PINS O=n308 I1=n91 I2=n93
XU116 INV1S $PINS O=n33 I=n308
XU117 ND2 $PINS O=n307 I1=n93 I2=n91
XU118 ND2 $PINS O=n49 I1=n33 I2=n307
XU119 NR2 $PINS O=n74 I1=n41 I2=n42
XU120 FA1 $PINS S=n40 CO=n41 A=i_data_1[3] B=i_data_2[3] CI=i_data_0[3]
XU121 NR2 $PINS O=n77 I1=n39 I2=n40
XU122 NR2 $PINS O=n52 I1=n37 I2=n38
XU123 HA1 $PINS S=n35 C=n37 A=i_data_1[1] B=i_data_0[1]
XU124 OR2 $PINS O=n62 I1=i_data_2[1] I2=n35
XU125 NR2 $PINS O=n57 I1=i_data_1[0] I2=i_data_0[0]
XU126 INV1S $PINS O=n34 I=i_data_2[0]
XU127 ND2 $PINS O=n58 I1=i_data_0[0] I2=i_data_1[0]
XU128 OAI12HS $PINS O=n64 A1=n58 B1=n57 B2=n34
XU129 ND2 $PINS O=n61 I1=n35 I2=i_data_2[1]
XU130 INV1S $PINS O=n36 I=n61
XU131 AOI12HS $PINS O=n56 A1=n36 B1=n62 B2=n64
XU132 ND2 $PINS O=n53 I1=n38 I2=n37
XU133 OAI12HS $PINS O=n69 A1=n53 B1=n52 B2=n56
XU134 ND2 $PINS O=n68 I1=n40 I2=n39
XU135 ND2 $PINS O=n75 I1=n42 I2=n41
XU136 OAI12HS $PINS O=n43 A1=n75 B1=n74 B2=n68
XU137 FA1 $PINS S=n48 CO=n91 A=i_data_1[6] B=i_data_2[6] CI=i_data_0[6]
XU138 NR2 $PINS O=n80 I1=n47 I2=n48
XU139 FA1 $PINS S=n42 CO=n45 A=i_data_1[4] B=i_data_2[4] CI=i_data_0[4]
XU140 FA1S $PINS S=n46 CO=n47 A=i_data_1[5] B=i_data_2[5] CI=i_data_0[5]
XU141 NR2 $PINS O=n304 I1=n80 I2=n50
XU142 ND2 $PINS O=n83 I1=n46 I2=n45
XU143 ND2 $PINS O=n81 I1=n48 I2=n47
XU144 AOI12HP $PINS O=n90 A1=n306 B1=n26 B2=n304
XU145 INV1S $PINS O=n85 I=n50
XU146 INV1S $PINS O=n54 I=n52
XU147 ND2 $PINS O=n55 I1=n54 I2=n53
XU148 XOR2HS $PINS O=n73 I1=n56 I2=n55
XU149 INV1S $PINS O=n59 I=n57
XU150 XNR2HS $PINS O=n66 I1=i_data_2[0] I2=n60
XU151 ND2 $PINS O=n63 I1=n62 I2=n61
XU152 XNR2HS $PINS O=n65 I1=n64 I2=n63
XU153 ND2 $PINS O=n71 I1=n6 I2=n68
XU154 XOR2HS $PINS O=n72 I1=n71 I2=n70
XU155 INV1S $PINS O=n76 I=n74
XU156 INV1S $PINS O=n82 I=n80
XU157 ND2 $PINS O=n87 I1=n82 I2=n81
XU158 INV1S $PINS O=n84 I=n83
XU159 AOI12HS $PINS O=n86 A1=n84 B1=n26 B2=n85
XU160 XOR2HS $PINS O=n88 I1=n87 I2=n86
XU161 OAI12H $PINS O=n262 A1=n88 B1=n259 B2=n89
XU162 FA1S $PINS S=n93 CO=n150 A=i_data_1[7] B=i_data_2[7] CI=i_data_0[7]
XU163 INV1S $PINS O=n92 I=n91
XU164 OR2 $PINS O=n296 I1=n92 I2=n93
XU165 ND2 $PINS O=n268 I1=n294 I2=n296
XU166 HA1 $PINS S=n94 C=n96 A=n150 B=n91
XU167 FA1S $PINS S=n151 CO=n156 A=i_data_1[8] B=i_data_2[8] CI=i_data_0[8]
XU168 NR2 $PINS O=n265 I1=n96 I2=n97
XU169 NR2P $PINS O=n99 I1=n268 I2=n265
XU170 AN2 $PINS O=n295 I1=n93 I2=n92
XU171 ND2 $PINS O=n293 I1=n94 I2=n151
XU172 INV1S $PINS O=n95 I=n293
XU173 ND2 $PINS O=n266 I1=n97 I2=n96
XU174 FA1S $PINS S=n157 CO=n158 A=i_data_1[9] B=i_data_2[9] CI=i_data_0[9]
XU175 FA1S $PINS S=n159 CO=n160 A=i_data_1[10] B=i_data_2[10] CI=i_data_0[10]
XU176 NR2 $PINS O=n350 I1=n102 I2=n103
XU177 HA1 $PINS S=n97 C=n100 A=n156 B=n157
XU178 HA1 $PINS S=n101 C=n102 A=n158 B=n159
XU179 NR2 $PINS O=n280 I1=n100 I2=n101
XU180 NR2 $PINS O=n335 I1=n350 I2=n280
XU181 NR2 $PINS O=n316 I1=n106 I2=n107
XU182 HA1 $PINS S=n103 C=n104 A=n160 B=n161
XU183 HA1 $PINS S=n105 C=n106 A=n162 B=n163
XU184 NR2 $PINS O=n331 I1=n104 I2=n105
XU185 NR2 $PINS O=n109 I1=n316 I2=n331
XU186 ND2 $PINS O=n111 I1=n335 I2=n109
XU187 ND2 $PINS O=n353 I1=n101 I2=n100
XU188 ND2 $PINS O=n351 I1=n103 I2=n102
XU189 OAI12HS $PINS O=n334 A1=n351 B1=n350 B2=n353
XU190 ND2 $PINS O=n332 I1=n105 I2=n104
XU191 ND2 $PINS O=n317 I1=n107 I2=n106
XU192 OAI12HS $PINS O=n108 A1=n317 B1=n316 B2=n332
XU193 AOI12HS $PINS O=n110 A1=n108 B1=n109 B2=n334
XU194 OAI12H $PINS O=n372 A1=n110 B1=n281 B2=n111
XU195 NR2 $PINS O=n484 I1=n124 I2=n125
XU196 FA1S $PINS S=n182 CO=n183 A=i_data_1[17] B=i_data_2[17] CI=i_data_0[17]
XU197 HA1 $PINS S=n123 C=n124 A=n183 B=n184
XU198 NR2 $PINS O=n473 I1=n122 I2=n123
XU199 NR2 $PINS O=n439 I1=n484 I2=n473
XU200 FA1S $PINS S=n187 CO=n188 A=i_data_1[19] B=i_data_2[19] CI=i_data_0[19]
XU201 FA1S $PINS S=n189 CO=n194 A=i_data_1[20] B=i_data_2[20] CI=i_data_0[20]
XU202 NR2 $PINS O=n436 I1=n128 I2=n129
XU203 HA1 $PINS S=n125 C=n126 A=n186 B=n187
XU204 HA1 $PINS S=n127 C=n128 A=n188 B=n189
XU205 NR2 $PINS O=n443 I1=n126 I2=n127
XU206 NR2 $PINS O=n131 I1=n436 I2=n443
XU207 ND2 $PINS O=n133 I1=n439 I2=n131
XU208 FA1S $PINS S=n167 CO=n168 A=i_data_1[13] B=i_data_2[13] CI=i_data_0[13]
XU209 FA1S $PINS S=n169 CO=n170 A=i_data_1[14] B=i_data_2[14] CI=i_data_0[14]
XU210 NR2 $PINS O=n399 I1=n114 I2=n115
XU211 HA1 $PINS S=n107 C=n112 A=n166 B=n167
XU212 HA1 $PINS S=n113 C=n114 A=n168 B=n169
XU213 NR2 $PINS O=n403 I1=n112 I2=n113
XU214 NR2 $PINS O=n461 I1=n399 I2=n403
XU215 HA1 $PINS S=n119 C=n122 A=n181 B=n182
XU216 NR2 $PINS O=n458 I1=n118 I2=n119
XU217 HA1 $PINS S=n115 C=n116 A=n170 B=n171
XU218 HA1 $PINS S=n117 C=n118 A=n172 B=n173
XU219 NR2 $PINS O=n121 I1=n458 I2=n412
XU220 ND2 $PINS O=n475 I1=n461 I2=n121
XU221 ND2 $PINS O=n400 I1=n115 I2=n114
XU222 OAI12H $PINS O=n465 A1=n400 B1=n399 B2=n402
XU223 ND2 $PINS O=n462 I1=n117 I2=n116
XU224 ND2 $PINS O=n459 I1=n119 I2=n118
XU225 OAI12HS $PINS O=n120 A1=n459 B1=n458 B2=n462
XU226 AOI12HS $PINS O=n474 A1=n120 B1=n121 B2=n465
XU227 ND2 $PINS O=n485 I1=n125 I2=n124
XU228 ND2 $PINS O=n442 I1=n127 I2=n126
XU229 ND2 $PINS O=n437 I1=n129 I2=n128
XU230 OAI12HS $PINS O=n130 A1=n437 B1=n436 B2=n442
XU231 AOI12HS $PINS O=n132 A1=n130 B1=n131 B2=n441
XU232 AOI12HS $PINS O=n148 A1=n134 B1=n372 B2=n135
XU235 FA1S $PINS S=n201 CO=n203 A=i_data_1[23] B=n137 CI=n136
XU236 HA1 $PINS S=n129 C=n138 A=n194 B=n195
XU237 FA1S $PINS S=n195 CO=n196 A=i_data_1[21] B=i_data_2[21] CI=i_data_0[21]
XU238 FA1S $PINS S=n197 CO=n200 A=i_data_1[22] B=i_data_2[22] CI=i_data_0[22]
XU239 OR2 $PINS O=n246 I1=n138 I2=n139
XU240 HA1 $PINS S=n139 C=n140 A=n196 B=n197
XU241 HA1 $PINS S=n141 C=n144 A=n200 B=n201
XU242 OR2 $PINS O=n244 I1=n140 I2=n141
XU243 ND2 $PINS O=n224 I1=n246 I2=n244
XU244 NR2 $PINS O=n240 I1=n221 I2=n224
XU245 HA1 $PINS S=n143 C=n242 A=n202 B=n203
XU246 ND2 $PINS O=n147 I1=n139 I2=n138
XU247 INV1S $PINS O=n245 I=n147
XU248 ND2 $PINS O=n243 I1=n141 I2=n140
XU249 INV1S $PINS O=n142 I=n243
XU250 AOI12HS $PINS O=n225 A1=n142 B1=n244 B2=n245
XU251 ND2 $PINS O=n222 I1=n144 I2=n143
XU252 OAI12HS $PINS O=n239 A1=n222 B1=n225 B2=n221
XU253 INV1S $PINS O=n247 I=n148
XU254 NR2 $PINS O=n301 I1=n150 I2=n151
XU255 NR2 $PINS O=n153 I1=n301 I2=n308
XU256 ND2 $PINS O=n302 I1=n151 I2=n150
XU257 OAI12HS $PINS O=n152 A1=n302 B1=n301 B2=n307
XU258 AOI12HS $PINS O=n155 A1=n152 B1=n153 B2=n306
XU259 ND2 $PINS O=n154 I1=n304 I2=n153
XU260 NR2 $PINS O=n374 I1=n168 I2=n169
XU261 NR2 $PINS O=n326 I1=n166 I2=n167
XU262 NR2 $PINS O=n420 I1=n374 I2=n326
XU263 NR2 $PINS O=n417 I1=n172 I2=n173
XU264 NR2 $PINS O=n425 I1=n170 I2=n171
XU265 NR2 $PINS O=n175 I1=n417 I2=n425
XU266 ND2 $PINS O=n177 I1=n420 I2=n175
XU267 NR2 $PINS O=n284 I1=n158 I2=n159
XU268 NR2 $PINS O=n288 I1=n156 I2=n157
XU269 NR2 $PINS O=n363 I1=n284 I2=n288
XU270 NR2 $PINS O=n339 I1=n162 I2=n163
XU271 NR2 $PINS O=n342 I1=n160 I2=n161
XU272 NR2 $PINS O=n165 I1=n339 I2=n342
XU273 ND2 $PINS O=n377 I1=n363 I2=n165
XU274 NR2 $PINS O=n179 I1=n177 I2=n377
XU275 ND2 $PINS O=n287 I1=n157 I2=n156
XU276 ND2 $PINS O=n285 I1=n159 I2=n158
XU277 OAI12HS $PINS O=n364 A1=n285 B1=n284 B2=n287
XU278 ND2 $PINS O=n361 I1=n161 I2=n160
XU279 ND2 $PINS O=n340 I1=n163 I2=n162
XU280 OAI12HS $PINS O=n164 A1=n340 B1=n339 B2=n361
XU281 AOI12HS $PINS O=n378 A1=n164 B1=n165 B2=n364
XU282 ND2 $PINS O=n379 I1=n167 I2=n166
XU283 ND2 $PINS O=n375 I1=n169 I2=n168
XU284 OAI12HS $PINS O=n423 A1=n375 B1=n374 B2=n379
XU285 ND2 $PINS O=n424 I1=n171 I2=n170
XU286 ND2 $PINS O=n418 I1=n173 I2=n172
XU287 OAI12HS $PINS O=n174 A1=n418 B1=n417 B2=n424
XU288 AOI12HS $PINS O=n176 A1=n174 B1=n175 B2=n423
XU289 OAI12HS $PINS O=n178 A1=n176 B1=n378 B2=n177
XU290 AOI12HS $PINS O=n212 A1=n178 B1=n276 B2=n179
XU291 NR2 $PINS O=n393 I1=n186 I2=n187
XU292 INV1S $PINS O=n498 I=n393
XU293 ND2 $PINS O=n193 I1=n498 I2=n28
XU294 OR2 $PINS O=n480 I1=n181 I2=n182
XU295 ND2 $PINS O=n499 I1=n480 I2=n29
XU296 NR2 $PINS O=n234 I1=n200 I2=n201
XU297 INV1S $PINS O=n251 I=n234
XU298 ND2 $PINS O=n206 I1=n251 I2=n18
XU299 NR2 $PINS O=n214 I1=n194 I2=n195
XU300 INV1S $PINS O=n452 I=n214
XU301 ND2 $PINS O=n230 I1=n452 I2=n180
XU302 NR2 $PINS O=n208 I1=n206 I2=n230
XU303 ND2 $PINS O=n210 I1=n454 I2=n208
XU304 ND2 $PINS O=n470 I1=n182 I2=n181
XU305 INV1S $PINS O=n479 I=n470
XU306 ND2 $PINS O=n478 I1=n184 I2=n183
XU307 INV1S $PINS O=n185 I=n478
XU308 AOI12HS $PINS O=n500 A1=n185 B1=n29 B2=n479
XU309 ND2 $PINS O=n497 I1=n187 I2=n186
XU310 INV1S $PINS O=n191 I=n497
XU311 ND2 $PINS O=n392 I1=n189 I2=n188
XU312 INV1S $PINS O=n190 I=n392
XU313 AOI12HS $PINS O=n192 A1=n190 B1=n28 B2=n191
XU314 OAI12HS $PINS O=n453 A1=n192 B1=n500 B2=n193
XU315 ND2 $PINS O=n451 I1=n195 I2=n194
XU316 INV1S $PINS O=n199 I=n451
XU317 INV1S $PINS O=n198 I=n211
XU318 AOI12HS $PINS O=n231 A1=n198 B1=n180 B2=n199
XU319 ND2 $PINS O=n250 I1=n201 I2=n200
XU320 INV1S $PINS O=n204 I=n250
XU321 AOI12HS $PINS O=n205 A1=n27 B1=n204 B2=n18
XU322 OAI12HS $PINS O=n207 A1=n205 B1=n231 B2=n206
XU323 AOI12HS $PINS O=n209 A1=n207 B1=n453 B2=n208
XU324 OA12 $PINS O=n260 A1=n209 B1=n212 B2=n210
XU325 INV1S $PINS O=n213 I=n454
XU326 NR2 $PINS O=n217 I1=n214 I2=n213
XU327 INV1S $PINS O=n215 I=n453
XU328 OAI12HS $PINS O=n216 A1=n451 B1=n215 B2=n214
XU329 AOI12HS $PINS O=n218 A1=n216 B1=FE_DBTN51_n212 B2=n217
XU330 XOR2HS $PINS O=n220 I1=n219 I2=n218
XU331 MOAI1S $PINS O=o_data[15] A1=FE_OFN1422_FE_DBTN50_n508 A2=n4 B1=n16
+ B2=n220
XU332 INV1S $PINS O=n223 I=n221
XU333 INV1S $PINS O=n227 I=n224
XU334 INV1S $PINS O=n226 I=n225
XU335 AOI12HS $PINS O=n228 A1=n226 B1=n247 B2=n227
XU336 INV1S $PINS O=n233 I=n230
XU337 ND2 $PINS O=n252 I1=n454 I2=n233
XU338 NR2 $PINS O=n236 I1=n234 I2=n252
XU339 INV1S $PINS O=n232 I=n231
XU340 AOI12HS $PINS O=n253 A1=n232 B1=n453 B2=n233
XU341 OAI12HS $PINS O=n235 A1=n250 B1=n253 B2=n234
XU342 AOI12HS $PINS O=n237 A1=n235 B1=FE_DBTN51_n212 B2=n236
XU343 XOR2HS $PINS O=n238 I1=n27 I2=n237
XU344 MOAI1S $PINS O=o_data[17] A1=n24 A2=FE_OFN1691_n508 B1=n17 B2=n238
XU345 AOI12HS $PINS O=n241 A1=n239 B1=n247 B2=n240
XU346 NR2 $PINS O=o_data[18] I1=n32 I2=FE_OFN1691_n508
XU347 AOI12HS $PINS O=n248 A1=n245 B1=n247 B2=n246
XU348 INV1S $PINS O=n255 I=n252
XU349 INV1S $PINS O=n254 I=n253
XU350 AOI12HS $PINS O=n256 A1=n254 B1=FE_DBTN51_n212 B2=n255
XU351 XOR2HS $PINS O=n258 I1=n257 I2=n256
XU352 MOAI1S $PINS O=o_data[16] A1=n5 A2=FE_OFN1422_FE_DBTN50_n508 B1=n16
+ B2=n258
XU353 OR2 $PINS O=n264 I1=n259 I2=n262
XU354 INV1S $PINS O=n261 I=n259
XU355 NR2 $PINS O=n263 I1=n261 I2=n260
XU356 MOAI1S $PINS O=o_data[0] A1=FE_OFN1415_n25 A2=n264 B1=n263 B2=n262
XU357 INV1S $PINS O=n267 I=n265
XU358 INV1S $PINS O=n271 I=n268
XU359 AOI12HS $PINS O=n272 A1=n270 B1=n297 B2=n271
XU360 XOR2HS $PINS O=n274 I1=n273 I2=n272
XU361 ND2 $PINS O=n279 I1=FE_DBTN52_n262 I2=n274
XU362 INV1S $PINS O=n275 I=n288
XU363 ND2S $PINS O=n277 I1=n275 I2=n287
XU364 XOR2HS $PINS O=n278 I1=n277 I2=FE_OFN1416_n432
XU365 MOAI1S $PINS O=o_data[2] A1=FE_OFN1415_n25 A2=n279 B1=n278 B2=n16
XU366 INV1S $PINS O=n355 I=n280
XU367 INV2 $PINS O=n356 I=n281
XU368 XNR2HS $PINS O=n283 I1=n282 I2=n356
XU369 ND2 $PINS O=n292 I1=n283 I2=FE_OFN1126_FE_DBTN52_n262
XU370 INV1S $PINS O=n286 I=n284
XU371 ND2S $PINS O=n290 I1=n286 I2=n285
XU372 OAI12HS $PINS O=n289 A1=n287 B1=FE_OFN1416_n432 B2=n288
XU373 XNR2HS $PINS O=n291 I1=n290 I2=n289
XU374 MOAI1S $PINS O=o_data[3] A1=n25 A2=n292 B1=n291 B2=n17
XU375 AOI12HS $PINS O=n298 A1=n295 B1=n297 B2=n296
XU376 XOR2HS $PINS O=n300 I1=n299 I2=n298
XU377 INV1S $PINS O=n303 I=n301
XU378 ND2S $PINS O=n313 I1=n303 I2=n302
XU379 INV1S $PINS O=n305 I=n304
XU380 NR2 $PINS O=n311 I1=n308 I2=n305
XU381 INV1S $PINS O=n309 I=n306
XU382 OAI12HS $PINS O=n310 A1=n307 B1=n309 B2=n308
XU383 NR2 $PINS O=n312 I1=n311 I2=n310
XU384 XOR2HS $PINS O=n314 I1=n313 I2=n312
XU385 MOAI1S $PINS O=o_data[1] A1=FE_OFN1415_n25 A2=n315 B1=n314 B2=n16
XU386 INV1S $PINS O=n318 I=n316
XU387 INV1S $PINS O=n319 I=n335
XU388 NR2 $PINS O=n322 I1=n331 I2=n319
XU389 INV1S $PINS O=n320 I=n334
XU390 OAI12HS $PINS O=n321 A1=n332 B1=n320 B2=n331
XU391 AOI12HS $PINS O=n323 A1=n321 B1=n356 B2=n322
XU392 XOR2HS $PINS O=n325 I1=n324 I2=n323
XU393 INV1S $PINS O=n381 I=n326
XU394 OAI12HS $PINS O=n327 A1=n378 B1=FE_OFN1416_n432 B2=n377
XU395 XNR2HS $PINS O=n329 I1=n328 I2=n327
XU396 MOAI1S $PINS O=o_data[6] A1=n330 A2=FE_OFN1415_n25 B1=n329 B2=n17
XU397 INV1S $PINS O=n333 I=n331
XU398 AOI12HS $PINS O=n336 A1=n334 B1=n356 B2=n335
XU399 XOR2HS $PINS O=n338 I1=n337 I2=n336
XU400 INV1S $PINS O=n341 I=n339
XU401 ND2S $PINS O=n347 I1=n341 I2=n340
XU402 INV1S $PINS O=n362 I=n342
XU403 INV1S $PINS O=n343 I=n361
XU404 AOI12HS $PINS O=n344 A1=n343 B1=n364 B2=n362
XU405 OAI12HS $PINS O=n346 A1=n344 B1=FE_OFN1416_n432 B2=n345
XU406 XNR2HS $PINS O=n348 I1=n347 I2=n346
XU408 INV1S $PINS O=n352 I=n350
XU409 INV1S $PINS O=n354 I=n353
XU410 AOI12HS $PINS O=n357 A1=n354 B1=n356 B2=n355
XU411 XOR2HS $PINS O=n360 I1=n358 I2=n357
XU412 INV1S $PINS O=n366 I=n363
XU413 INV1S $PINS O=n365 I=n364
XU414 OAI12HS $PINS O=n367 A1=n365 B1=FE_OFN1416_n432 B2=n366
XU415 XNR2HS $PINS O=n369 I1=n368 I2=n367
XU416 MOAI1S $PINS O=o_data[4] A1=n370 A2=n25 B1=n369 B2=n17
XU417 INV1S $PINS O=n371 I=n403
XU418 INV1S $PINS O=n376 I=n374
XU419 INV1S $PINS O=n422 I=n377
XU420 INV1S $PINS O=n429 I=n378
XU421 INV1S $PINS O=n380 I=n379
XU422 AOI12HS $PINS O=n382 A1=n380 B1=n429 B2=n381
XU423 OAI12HS $PINS O=n384 A1=n382 B1=n432 B2=n383
XU424 XNR2HS $PINS O=n386 I1=n385 I2=n384
XU425 MOAI1 $PINS O=o_data[7] A1=FE_OFN1423_FE_DBTN50_n508 A2=n21 B1=n507
+ B2=n386
XU426 INV1S $PINS O=n387 I=n443
XU427 INV1S $PINS O=n487 I=n475
XU428 ND2 $PINS O=n389 I1=n487 I2=n439
XU429 INV1S $PINS O=n491 I=n474
XU430 AOI12HS $PINS O=n388 A1=n441 B1=n491 B2=n439
XU431 OAI12HS $PINS O=n390 A1=n388 B1=FE_OFN1125_FE_DBTN53_n372 B2=n389
XU432 NR2 $PINS O=n395 I1=n393 I2=n499
XU433 OAI12HS $PINS O=n394 A1=n497 B1=n500 B2=n393
XU434 AOI12HS $PINS O=n396 A1=n394 B1=FE_OFN1127_FE_DBTN51_n212 B2=n395
XU435 XOR2HS $PINS O=n398 I1=n397 I2=n396
XU436 MOAI1 $PINS O=o_data[13] A1=n2 A2=FE_OFN1423_FE_DBTN50_n508 B1=n507
+ B2=n398
XU437 INV1S $PINS O=n401 I=n399
XU438 OAI12HS $PINS O=n404 A1=n402 B1=FE_DBTN53_n372 B2=n403
XU439 INV1S $PINS O=n406 I=n425
XU440 AOI12HS $PINS O=n407 A1=n423 B1=n429 B2=n420
XU441 OAI12HS $PINS O=n409 A1=n407 B1=n432 B2=n408
XU442 XNR2HS $PINS O=n411 I1=n410 I2=n409
XU443 MOAI1 $PINS O=o_data[8] A1=FE_OFN1691_n508 A2=n31 B1=n507 B2=n411
XU444 INV1S $PINS O=n464 I=n412
XU445 INV1S $PINS O=n414 I=n461
XU446 INV1S $PINS O=n413 I=n465
XU447 OAI12HS $PINS O=n415 A1=n413 B1=FE_OFN1125_FE_DBTN53_n372 B2=n414
XU448 INV1S $PINS O=n419 I=n417
XU449 ND2S $PINS O=n434 I1=n419 I2=n418
XU450 INV1S $PINS O=n421 I=n420
XU451 NR2 $PINS O=n428 I1=n425 I2=n421
XU452 INV1S $PINS O=n426 I=n423
XU453 OAI12HS $PINS O=n427 A1=n424 B1=n426 B2=n425
XU454 AOI12HS $PINS O=n430 A1=n427 B1=n429 B2=n428
XU455 OAI12HS $PINS O=n433 A1=n430 B1=n432 B2=n431
XU456 XNR2HS $PINS O=n435 I1=n434 I2=n433
XU457 MOAI1 $PINS O=o_data[9] A1=n22 A2=FE_OFN1691_n508 B1=n507 B2=n435
XU458 INV1S $PINS O=n438 I=n436
XU459 INV1S $PINS O=n440 I=n439
XU460 NR2 $PINS O=n446 I1=n443 I2=n440
XU461 ND2 $PINS O=n448 I1=n446 I2=n487
XU462 INV1S $PINS O=n444 I=n441
XU463 OAI12HS $PINS O=n445 A1=n442 B1=n444 B2=n443
XU464 AOI12HS $PINS O=n447 A1=n445 B1=n491 B2=n446
XU465 OAI12HS $PINS O=n449 A1=n447 B1=FE_OFN1125_FE_DBTN53_n372 B2=n448
XU466 AOI12HS $PINS O=n455 A1=n453 B1=FE_DBTN51_n212 B2=n454
XU467 XOR2HS $PINS O=n457 I1=n456 I2=n455
XU468 MOAI1 $PINS O=o_data[14] A1=n3 A2=FE_OFN1422_FE_DBTN50_n508 B1=n16
+ B2=n457
XU469 INV1S $PINS O=n460 I=n458
XU470 INV1S $PINS O=n463 I=n462
XU471 AOI12HS $PINS O=n466 A1=n463 B1=n465 B2=n464
XU472 OAI12HS $PINS O=n468 A1=n466 B1=FE_OFN1125_FE_DBTN53_n372 B2=n467
XU473 XNR2HS $PINS O=n472 I1=n471 I2=FE_OFN1127_FE_DBTN51_n212
XU474 MOAI1 $PINS O=o_data[10] A1=n23 A2=FE_OFN1423_FE_DBTN50_n508 B1=n507
+ B2=n472
XU475 INV1S $PINS O=n490 I=n473
XU476 OAI12HS $PINS O=n476 A1=n474 B1=FE_OFN1125_FE_DBTN53_n372 B2=n475
XU477 AOI12HS $PINS O=n481 A1=n479 B1=FE_OFN1127_FE_DBTN51_n212 B2=n480
XU478 XOR2HS $PINS O=n483 I1=n482 I2=n481
XU479 MOAI1 $PINS O=o_data[11] A1=n30 A2=FE_OFN1423_FE_DBTN50_n508 B1=n507
+ B2=n483
XU480 INV1S $PINS O=n486 I=n484
XU481 ND2 $PINS O=n493 I1=n487 I2=n490
XU482 INV1S $PINS O=n489 I=n488
XU483 AOI12HS $PINS O=n492 A1=n489 B1=n491 B2=n490
XU484 OAI12HS $PINS O=n495 A1=n492 B1=FE_OFN1125_FE_DBTN53_n372 B2=n493
XU485 INV1S $PINS O=n502 I=n499
XU486 INV1S $PINS O=n501 I=n500
XU487 AOI12HS $PINS O=n504 A1=n501 B1=FE_OFN1127_FE_DBTN51_n212 B2=n502
XU488 XOR2HS $PINS O=n506 I1=n505 I2=n504
XU489 MOAI1 $PINS O=o_data[12] A1=n1 A2=FE_OFN1423_FE_DBTN50_n508 B1=n17
+ B2=n506
.ENDS

.SUBCKT pMaxPool_1 i_data_0[20] i_data_0[19] i_data_0[18] i_data_0[17]
+ i_data_0[16] i_data_0[15] i_data_0[14] i_data_0[13] i_data_0[12] i_data_0[11]
+ i_data_0[10] i_data_0[9] i_data_0[8] i_data_0[7] i_data_0[6] i_data_0[5]
+ i_data_0[4] i_data_0[3] i_data_0[2] i_data_0[1] i_data_0[0] i_data_1[20]
+ i_data_1[19] i_data_1[18] i_data_1[17] i_data_1[16] i_data_1[15] i_data_1[14]
+ i_data_1[13] i_data_1[12] i_data_1[11] i_data_1[10] i_data_1[9] i_data_1[8]
+ i_data_1[7] i_data_1[6] i_data_1[5] i_data_1[4] i_data_1[3] i_data_1[2]
+ i_data_1[1] i_data_1[0] o_data[20] o_data[19] o_data[18] o_data[17]
+ o_data[16] o_data[15] o_data[14] o_data[13] o_data[12] o_data[11] o_data[10]
+ o_data[9] o_data[8] o_data[7] o_data[6] o_data[5] o_data[4] o_data[3]
+ o_data[2] o_data[1] o_data[0]
XU1 OA12 $PINS O=n4 A1=n86 B1=n88 B2=n87
XU2 INV1S $PINS O=n85 I=i_data_1[18]
XU3 OA12 $PINS O=n3 A1=n4 B1=n89 B2=n5
XU4 OA12 $PINS O=n2 A1=n4 B1=n89 B2=n5
XU5 OA12 $PINS O=n1 A1=n4 B1=n89 B2=n5
XU6 ND2S $PINS O=n45 I1=n44 I2=n58
XU7 ND2S $PINS O=n37 I1=n22 I2=n35
XU8 NR2 $PINS O=n71 I1=n68 I2=n40
XU9 ND2S $PINS O=n30 I1=n29 I2=i_data_0[7]
XU10 ND2S $PINS O=n53 I1=n52 I2=i_data_0[11]
XU11 ND2S $PINS O=n61 I1=n60 I2=i_data_0[13]
XU12 ND2S $PINS O=n67 I1=n64 I2=i_data_0[14]
XU13 ND2S $PINS O=n66 I1=n65 I2=i_data_0[15]
XU14 INV1S $PINS O=n65 I=i_data_1[15]
XU15 OA12 $PINS O=n90 A1=n4 B1=n89 B2=n5
XU16 AOI12HS $PINS O=n89 A1=n75 B1=n77 B2=n76
XU17 OR2 $PINS O=n5 I1=n87 I2=n79
XU18 NR2 $PINS O=n68 I1=i_data_0[15] I2=n65
XU19 INV1S $PINS O=n13 I=i_data_1[3]
XU20 NR2 $PINS O=n16 I1=i_data_0[3] I2=n13
XU21 INV1S $PINS O=n12 I=i_data_1[2]
XU22 NR2 $PINS O=n6 I1=i_data_0[2] I2=n12
XU23 NR2 $PINS O=n19 I1=n16 I2=n6
XU24 INV1S $PINS O=n8 I=i_data_1[1]
XU25 NR2 $PINS O=n11 I1=i_data_0[1] I2=n8
XU26 INV1S $PINS O=n7 I=i_data_1[0]
XU27 NR2 $PINS O=n10 I1=i_data_0[0] I2=n7
XU28 ND2S $PINS O=n9 I1=n8 I2=i_data_0[1]
XU29 OAI12HS $PINS O=n18 A1=n9 B1=n11 B2=n10
XU30 ND2S $PINS O=n15 I1=n12 I2=i_data_0[2]
XU31 ND2S $PINS O=n14 I1=n13 I2=i_data_0[3]
XU32 OAI12HS $PINS O=n17 A1=n14 B1=n16 B2=n15
XU33 AOI12HS $PINS O=n38 A1=n17 B1=n19 B2=n18
XU34 INV1S $PINS O=n24 I=i_data_1[5]
XU35 NR2 $PINS O=n27 I1=i_data_0[5] I2=n24
XU36 INV1S $PINS O=n23 I=i_data_1[4]
XU37 NR2 $PINS O=n20 I1=i_data_0[4] I2=n23
XU38 NR2 $PINS O=n22 I1=n27 I2=n20
XU39 INV1S $PINS O=n29 I=i_data_1[7]
XU40 NR2 $PINS O=n32 I1=i_data_0[7] I2=n29
XU41 INV1S $PINS O=n28 I=i_data_1[6]
XU42 NR2 $PINS O=n21 I1=i_data_0[6] I2=n28
XU43 NR2 $PINS O=n35 I1=n32 I2=n21
XU44 ND2S $PINS O=n26 I1=n23 I2=i_data_0[4]
XU45 ND2S $PINS O=n25 I1=n24 I2=i_data_0[5]
XU46 OAI12HS $PINS O=n34 A1=n25 B1=n27 B2=n26
XU47 ND2S $PINS O=n31 I1=n28 I2=i_data_0[6]
XU48 OAI12HS $PINS O=n33 A1=n30 B1=n32 B2=n31
XU49 AOI12HS $PINS O=n36 A1=n33 B1=n35 B2=n34
XU50 OAI12HS $PINS O=n77 A1=n36 B1=n38 B2=n37
XU51 INV1S $PINS O=n60 I=i_data_1[13]
XU52 NR2 $PINS O=n63 I1=i_data_0[13] I2=n60
XU53 INV1S $PINS O=n59 I=i_data_1[12]
XU54 NR2 $PINS O=n39 I1=i_data_0[12] I2=n59
XU55 NR2 $PINS O=n41 I1=n63 I2=n39
XU56 INV1S $PINS O=n64 I=i_data_1[14]
XU57 NR2 $PINS O=n40 I1=i_data_0[14] I2=n64
XU58 ND2 $PINS O=n73 I1=n41 I2=n71
XU59 INV1S $PINS O=n47 I=i_data_1[9]
XU60 NR2 $PINS O=n50 I1=i_data_0[9] I2=n47
XU61 INV1S $PINS O=n46 I=i_data_1[8]
XU62 NR2 $PINS O=n42 I1=i_data_0[8] I2=n46
XU63 NR2 $PINS O=n44 I1=n50 I2=n42
XU64 INV1S $PINS O=n52 I=i_data_1[11]
XU65 NR2 $PINS O=n55 I1=i_data_0[11] I2=n52
XU66 INV1S $PINS O=n51 I=i_data_1[10]
XU67 NR2 $PINS O=n43 I1=i_data_0[10] I2=n51
XU68 NR2 $PINS O=n58 I1=n55 I2=n43
XU69 NR2 $PINS O=n76 I1=n73 I2=n45
XU70 ND2S $PINS O=n49 I1=n46 I2=i_data_0[8]
XU71 ND2S $PINS O=n48 I1=n47 I2=i_data_0[9]
XU72 OAI12HS $PINS O=n57 A1=n48 B1=n50 B2=n49
XU73 ND2S $PINS O=n54 I1=n51 I2=i_data_0[10]
XU74 OAI12HS $PINS O=n56 A1=n53 B1=n55 B2=n54
XU75 AOI12HS $PINS O=n74 A1=n56 B1=n58 B2=n57
XU76 ND2S $PINS O=n62 I1=n59 I2=i_data_0[12]
XU77 OAI12HS $PINS O=n70 A1=n61 B1=n63 B2=n62
XU78 OAI12HS $PINS O=n69 A1=n66 B1=n68 B2=n67
XU79 AOI12HS $PINS O=n72 A1=n69 B1=n71 B2=n70
XU80 OAI12HS $PINS O=n75 A1=n72 B1=n74 B2=n73
XU81 NR2 $PINS O=n87 I1=i_data_0[18] I2=n85
XU82 INV1S $PINS O=n80 I=i_data_1[16]
XU83 OR2 $PINS O=n78 I1=i_data_0[16] I2=n80
XU84 INV1S $PINS O=n81 I=i_data_1[17]
XU85 OR2 $PINS O=n84 I1=i_data_0[17] I2=n81
XU86 ND2 $PINS O=n79 I1=n78 I2=n84
XU87 AN2 $PINS O=n83 I1=n80 I2=i_data_0[16]
XU88 AN2 $PINS O=n82 I1=n81 I2=i_data_0[17]
XU89 AOI12HS $PINS O=n88 A1=n82 B1=n84 B2=n83
XU90 ND2 $PINS O=n86 I1=n85 I2=i_data_0[18]
XU91 MUX2 $PINS O=o_data[0] S=n90 A=i_data_0[0] B=i_data_1[0]
XU92 MUX2 $PINS O=o_data[1] S=n2 A=i_data_0[1] B=i_data_1[1]
XU93 MUX2 $PINS O=o_data[2] S=n1 A=i_data_0[2] B=i_data_1[2]
XU94 MUX2 $PINS O=o_data[3] S=n90 A=i_data_0[3] B=i_data_1[3]
XU95 MUX2 $PINS O=o_data[4] S=n3 A=i_data_0[4] B=i_data_1[4]
XU96 MUX2 $PINS O=o_data[5] S=n2 A=i_data_0[5] B=i_data_1[5]
XU97 MUX2 $PINS O=o_data[6] S=n90 A=i_data_0[6] B=i_data_1[6]
XU98 MUX2 $PINS O=o_data[7] S=n1 A=i_data_0[7] B=i_data_1[7]
XU99 MUX2 $PINS O=o_data[8] S=n3 A=i_data_0[8] B=i_data_1[8]
XU100 MUX2 $PINS O=o_data[9] S=n90 A=i_data_0[9] B=i_data_1[9]
XU101 MUX2 $PINS O=o_data[10] S=n2 A=i_data_0[10] B=i_data_1[10]
XU102 MUX2 $PINS O=o_data[11] S=n1 A=i_data_0[11] B=i_data_1[11]
XU103 MUX2 $PINS O=o_data[12] S=n2 A=i_data_0[12] B=i_data_1[12]
XU104 MUX2 $PINS O=o_data[13] S=n3 A=i_data_0[13] B=i_data_1[13]
XU105 MUX2 $PINS O=o_data[14] S=n2 A=i_data_0[14] B=i_data_1[14]
XU106 MUX2 $PINS O=o_data[15] S=n1 A=i_data_0[15] B=i_data_1[15]
XU107 MUX2 $PINS O=o_data[16] S=n1 A=i_data_0[16] B=i_data_1[16]
XU108 MUX2 $PINS O=o_data[17] S=n3 A=i_data_0[17] B=i_data_1[17]
XU109 MUX2 $PINS O=o_data[18] S=n3 A=i_data_0[18] B=i_data_1[18]
.ENDS

.SUBCKT pMaxPool_0 i_data_0[20] i_data_0[19] i_data_0[18] i_data_0[17]
+ i_data_0[16] i_data_0[15] i_data_0[14] i_data_0[13] i_data_0[12] i_data_0[11]
+ i_data_0[10] i_data_0[9] i_data_0[8] i_data_0[7] i_data_0[6] i_data_0[5]
+ i_data_0[4] i_data_0[3] i_data_0[2] i_data_0[1] i_data_0[0] i_data_1[20]
+ i_data_1[19] i_data_1[18] i_data_1[17] i_data_1[16] i_data_1[15] i_data_1[14]
+ i_data_1[13] i_data_1[12] i_data_1[11] i_data_1[10] i_data_1[9] i_data_1[8]
+ i_data_1[7] i_data_1[6] i_data_1[5] i_data_1[4] i_data_1[3] i_data_1[2]
+ i_data_1[1] i_data_1[0] o_data[20] o_data[19] o_data[18] o_data[17]
+ o_data[16] o_data[15] o_data[14] o_data[13] o_data[12] o_data[11] o_data[10]
+ o_data[9] o_data[8] o_data[7] o_data[6] o_data[5] o_data[4] o_data[3]
+ o_data[2] o_data[1] o_data[0]
XFE_OFC1421_n23 BUF1S $PINS O=FE_OFN1421_n23 I=FE_OFN1420_n23
XFE_OFC1420_n23 BUF1S $PINS O=FE_OFN1420_n23 I=FE_OFN1419_n23
XFE_OFC1419_n23 BUF1S $PINS O=FE_OFN1419_n23 I=FE_OFN1417_n23
XFE_OFC1418_n23 BUF1S $PINS O=FE_OFN1418_n23 I=n23
XFE_OFC1417_n23 BUF1S $PINS O=FE_OFN1417_n23 I=n23
XU1 MOAI1S $PINS O=n23 A1=n22 A2=i_data_1[18] B1=n21 B2=i_data_0[18]
XU2 INV1S $PINS O=n41 I=i_data_1[14]
XU3 INV1S $PINS O=n38 I=i_data_1[13]
XU4 INV1S $PINS O=n37 I=i_data_1[12]
XU5 INV1S $PINS O=n36 I=i_data_1[11]
XU6 INV1S $PINS O=n34 I=i_data_1[10]
XU7 INV1S $PINS O=n33 I=i_data_1[9]
XU8 INV1S $PINS O=n32 I=i_data_1[8]
XU9 INV1S $PINS O=n30 I=i_data_1[7]
XU10 INV1S $PINS O=n29 I=i_data_1[6]
XU11 INV1S $PINS O=n28 I=i_data_1[5]
XU12 INV1S $PINS O=n27 I=i_data_1[4]
XU13 INV1S $PINS O=n26 I=i_data_1[3]
XU14 INV1S $PINS O=n25 I=i_data_1[2]
XU15 INV1S $PINS O=n24 I=i_data_1[1]
XU16 OR2B1S $PINS O=n1 I1=i_data_0[0] B1=i_data_1[0]
XU17 FA1S $PINS CO=n2 A=n24 B=i_data_0[1] CI=n1
XU18 FA1S $PINS CO=n3 A=n25 B=i_data_0[2] CI=n2
XU19 FA1S $PINS CO=n4 A=n26 B=i_data_0[3] CI=n3
XU20 FA1S $PINS CO=n5 A=n27 B=i_data_0[4] CI=n4
XU21 FA1S $PINS CO=n6 A=n28 B=i_data_0[5] CI=n5
XU22 FA1S $PINS CO=n7 A=n29 B=i_data_0[6] CI=n6
XU23 FA1S $PINS CO=n8 A=n30 B=i_data_0[7] CI=n7
XU24 FA1S $PINS CO=n9 A=n32 B=i_data_0[8] CI=n8
XU25 FA1S $PINS CO=n10 A=n33 B=i_data_0[9] CI=n9
XU26 FA1S $PINS CO=n11 A=n34 B=i_data_0[10] CI=n10
XU27 FA1S $PINS CO=n12 A=n36 B=i_data_0[11] CI=n11
XU28 FA1S $PINS CO=n13 A=n37 B=i_data_0[12] CI=n12
XU29 FA1S $PINS CO=n14 A=n38 B=i_data_0[13] CI=n13
XU30 MAO222 $PINS O=n15 A1=n41 B1=i_data_0[14] C1=n14
XU31 NR2 $PINS O=n16 I1=n15 I2=i_data_0[15]
XU32 MOAI1S $PINS O=n17 A1=n16 A2=i_data_1[15] B1=n15 B2=i_data_0[15]
XU33 NR2 $PINS O=n18 I1=n17 I2=i_data_0[16]
XU34 MOAI1S $PINS O=n19 A1=n18 A2=i_data_1[16] B1=n17 B2=i_data_0[16]
XU35 NR2 $PINS O=n20 I1=n19 I2=i_data_0[17]
XU36 MOAI1S $PINS O=n21 A1=n20 A2=i_data_1[17] B1=n19 B2=i_data_0[17]
XU37 NR2 $PINS O=n22 I1=n21 I2=i_data_0[18]
XU39 MUX2 $PINS O=o_data[0] S=FE_OFN1418_n23 A=i_data_1[0] B=i_data_0[0]
XU42 MOAI1S $PINS O=o_data[1] A1=FE_OFN1418_n23 A2=n24 B1=FE_OFN1418_n23
+ B2=i_data_0[1]
XU44 MOAI1S $PINS O=o_data[2] A1=FE_OFN1418_n23 A2=n25 B1=FE_OFN1418_n23
+ B2=i_data_0[2]
XU46 MOAI1S $PINS O=o_data[3] A1=FE_OFN1418_n23 A2=n26 B1=n23 B2=i_data_0[3]
XU47 MOAI1S $PINS O=o_data[4] A1=n23 A2=n27 B1=FE_OFN1417_n23 B2=i_data_0[4]
XU48 MOAI1S $PINS O=o_data[5] A1=FE_OFN1417_n23 A2=n28 B1=FE_OFN1417_n23
+ B2=i_data_0[5]
XU49 MOAI1S $PINS O=o_data[6] A1=FE_OFN1419_n23 A2=n29 B1=FE_OFN1419_n23
+ B2=i_data_0[6]
XU50 MOAI1S $PINS O=o_data[7] A1=FE_OFN1419_n23 A2=n30 B1=FE_OFN1420_n23
+ B2=i_data_0[7]
XU51 MOAI1S $PINS O=o_data[8] A1=FE_OFN1417_n23 A2=n32 B1=FE_OFN1417_n23
+ B2=i_data_0[8]
XU52 MOAI1S $PINS O=o_data[9] A1=FE_OFN1419_n23 A2=n33 B1=FE_OFN1419_n23
+ B2=i_data_0[9]
XU53 MOAI1S $PINS O=o_data[10] A1=FE_OFN1420_n23 A2=n34 B1=FE_OFN1420_n23
+ B2=i_data_0[10]
XU54 MOAI1S $PINS O=o_data[11] A1=FE_OFN1420_n23 A2=n36 B1=FE_OFN1420_n23
+ B2=i_data_0[11]
XU55 MOAI1S $PINS O=o_data[12] A1=FE_OFN1421_n23 A2=n37 B1=FE_OFN1421_n23
+ B2=i_data_0[12]
XU56 MOAI1S $PINS O=o_data[13] A1=FE_OFN1421_n23 A2=n38 B1=FE_OFN1421_n23
+ B2=i_data_0[13]
XU57 MOAI1S $PINS O=o_data[14] A1=FE_OFN1421_n23 A2=n41 B1=FE_OFN1421_n23
+ B2=i_data_0[14]
.ENDS

.SUBCKT Top clk rst_n layer_num[1] layer_num[0] i_data[7] i_data[6] i_data[5]
+ i_data[4] i_data[3] i_data[2] i_data[1] i_data[0] o_data[14] o_data[13]
+ o_data[12] o_data[11] o_data[10] o_data[9] o_data[8] o_data[7] o_data[6]
+ o_data[5] o_data[4] o_data[3] o_data[2] o_data[1] o_data[0]
XFE_RC_201_0 OAI222H $PINS O=n1731 A1=n7364 A2=FE_OFN1508_n5424
+ B1=FE_OFN1231_n5429 B2=n7314 C1=n7330 C2=FE_OFN1199_n5413
XFE_OCPC2091_FE_OFN350_i_reset_n_i BUF6 $PINS
+ O=FE_OCPN9786_FE_OFN350_i_reset_n_i I=FE_OFN350_i_reset_n_i
XFE_OCPC2090_FE_RN_3 BUF1 $PINS O=FE_OCPN9785_FE_RN_3 I=FE_RN_3
XFE_OCPC2089_FE_OFN385_i_reset_n_i BUF1 $PINS
+ O=FE_OCPN9784_FE_OFN385_i_reset_n_i I=FE_OFN385_i_reset_n_i
XFE_RC_200_0 OAI222H $PINS O=n1787 A1=n7805 A2=FE_OFN1513_n5424
+ B1=FE_OFN1239_n5429 B2=n7705 C1=n7738 C2=FE_OFN1194_n5413
XFE_OCPC2088_FE_OFN1215_n5429 BUF1 $PINS O=FE_OCPN9783_FE_OFN1215_n5429
+ I=FE_OFN1215_n5429
XFE_RC_199_0 OAI222S $PINS O=n1719 A1=n8118 A2=FE_OFN1510_n5424
+ B1=FE_OFN1195_n5413 B2=n8087 C1=n8068 C2=FE_OFN1236_n5429
XFE_RC_198_0 OAI222S $PINS O=n1807 A1=n7573 A2=FE_OFN2028_FE_OCPN9743_n5413
+ B1=FE_OCPN9747_n5429 B2=n7523 C1=n8823 C2=FE_OFN1482_n5424
XFE_RC_197_0 OAI222H $PINS O=n1799 A1=n7429 A2=FE_OFN1512_n5424
+ B1=FE_OFN1238_n5429 B2=n7329 C1=n7363 C2=FE_OFN1196_n5413
XFE_OCPC2087_n5424 BUF1 $PINS O=FE_OCPN9782_n5424 I=n5424
XFE_OCPC2086_FE_OFN9714_n BUF1 $PINS O=FE_OCPN9781_FE_OFN9714_n I=FE_OFN9714_n
XFE_OCPC2084_FE_OFN515_i_reset_n_i BUF1 $PINS
+ O=FE_OCPN9779_FE_OFN515_i_reset_n_i I=FE_OFN515_i_reset_n_i
XFE_OCPC2083_FE_OFN346_i_reset_n_i BUF1 $PINS
+ O=FE_OCPN9778_FE_OFN346_i_reset_n_i I=FE_OFN346_i_reset_n_i
XFE_OCPC2082_FE_OFN377_i_reset_n_i BUF2 $PINS
+ O=FE_OCPN9777_FE_OFN377_i_reset_n_i I=FE_OFN377_i_reset_n_i
XFE_OCPC2081_FE_OFN514_i_reset_n_i BUF1 $PINS
+ O=FE_OCPN9776_FE_OFN514_i_reset_n_i I=FE_OFN514_i_reset_n_i
XFE_OCPC2079_FE_OFN516_i_reset_n_i BUF1 $PINS
+ O=FE_OCPN9774_FE_OFN516_i_reset_n_i I=FE_OFN516_i_reset_n_i
XFE_RC_196_0 INV2CK $PINS O=FE_RN_63_0 I=n3871
XFE_RC_195_0 MXL2HS $PINS OB=n6637 S=n3870 A=n3871 B=FE_RN_63_0
XFE_RC_194_0 MOAI1H $PINS O=n4077 A1=n3918 A2=FE_DBTN44_weight_1_r_11 B1=n3916
+ B2=FE_DBTN44_weight_1_r_11
XFE_RC_193_0 AOI12H $PINS O=n9334 A1=n9337 B1=n9339 B2=n9335
XFE_RC_192_0 ND2S $PINS O=FE_RN_62_0 I1=FE_OFN1571_FE_DBTN22_n3850 I2=n6534
XFE_RC_191_0 OAI12HS $PINS O=n6547 A1=FE_RN_62_0 B1=n6548 B2=FE_OFN1543_n7067
XFE_RC_190_0 XOR2H $PINS O=n4495 I1=weight_2_r[10] I2=weight_2_r[9]
XFE_RC_189_0 AOI12H $PINS O=n7247 A1=n9628 B1=n2031 B2=n9626
XFE_RC_188_0 NR3H $PINS O=n3441 I1=weight_2_r[15] I2=n3440 I3=FE_OFN1472_n4404
XFE_RC_187_0 ND3HT $PINS O=n2031 I1=n6648 I2=n6650 I3=n6649
XFE_RC_186_0 INV1S $PINS O=FE_RN_61_0 I=n6349
XFE_RC_185_0 MXL2HS $PINS OB=n3140 S=n6348 A=n6349 B=FE_RN_61_0
XFE_RC_184_0 ND3HT $PINS O=n3426 I1=n2184 I2=n9559 I3=n9557
XFE_RC_183_0 INV1S $PINS O=FE_RN_60_0 I=n6638
XFE_RC_182_0 MXL2HS $PINS OB=n2450 S=n3103 A=n6638 B=FE_RN_60_0
XFE_RC_181_0 INV1S $PINS O=FE_RN_59_0 I=n3946
XFE_RC_180_0 MXL2HS $PINS OB=n3688 S=n2586 A=n3946 B=FE_RN_59_0
XFE_RC_179_0 AOI22H $PINS O=n4081 A1=n4053 A2=FE_OFN1338_weight_1_r_8 B1=n4001
+ B2=FE_OFN1461_n3961
XFE_RC_178_0 OAI12HS $PINS O=n4465 A1=n3460 B1=n3461 B2=n3462
XFE_RC_177_0 OAI22H $PINS O=n6343 A1=n6337 A2=FE_OFN1681_n3135 B1=n6315
+ B2=FE_OFN1447_n1875
XFE_RC_176_0 ND3P $PINS O=n9356 I1=FE_OFN1240_n6309 I2=n9353 I3=n9362
XFE_RC_175_0 OAI12HS $PINS O=n4640 A1=n3260 B1=n3261 B2=n3262
XFE_RC_174_0 ND2 $PINS O=FE_RN_58_0 I1=FE_OFN1460_n3961 I2=n3951
XFE_RC_173_0 OAI12HS $PINS O=n3975 A1=FE_RN_58_0 B1=n3948 B2=n9349
XFE_RC_172_0 XOR2HS $PINS O=n3990 I1=n1970 I2=n3984
XFE_OCPC2078_n4570 BUF1 $PINS O=FE_OCPN9773_n4570 I=n4570
XFE_OCPC2077_n6407 BUF1 $PINS O=FE_OCPN9772_n6407 I=n6407
XFE_RC_171_0 ND2 $PINS O=FE_RN_57_0 I1=FE_OFN1429_FE_DBTN32_weight_1_r_7
+ I2=n5686
XFE_RC_170_0 OAI12H $PINS O=n5691 A1=FE_RN_57_0 B1=n5687
+ B2=FE_OFN1429_FE_DBTN32_weight_1_r_7
XFE_RC_169_0 MOAI1H $PINS O=n4195 A1=n4127 A2=FE_OFN1535_n6821 B1=n4126
+ B2=FE_OFN1535_n6821
XFE_RC_168_0 OAI12H $PINS O=n9547 A1=n6859 B1=n6862 B2=n6861
XFE_OCPC2076_n3747 BUF1 $PINS O=FE_OCPN9771_n3747 I=n3747
XFE_RC_167_0 MXL2H $PINS OB=n3378 S=n5573 A=n3377 B=n5937
XFE_RC_166_0 OA12P $PINS O=n2003 A1=n8943 B1=n8947 B2=n8941
XFE_RC_165_0 MOAI1 $PINS O=n2380 A1=n2382 A2=n2381 B1=n9726 B2=n9727
XFE_RC_164_0 MOAI1 $PINS O=n7062 A1=FE_OFN1544_n7067 A2=n6550 B1=n6549
+ B2=FE_OFN1570_FE_DBTN22_n3850
XFE_RC_163_0 XOR3 $PINS O=n4659 I1=n4425 I2=n4423 I3=n4424
XFE_OCPC2075_FE_OFN1244_n7298 BUF1 $PINS O=FE_OCPN9770_FE_OFN1244_n7298
+ I=FE_OFN1244_n7298
XFE_OCPC2074_FE_OFN1335_weight_1_r_9 BUF2 $PINS
+ O=FE_OCPN9769_FE_OFN1335_weight_1_r_9 I=FE_OFN1335_weight_1_r_9
XFE_RC_161_0 OAI12HS $PINS O=n2609 A1=n3628 B1=n3630 B2=n3629
XFE_RC_160_0 OAI12HP $PINS O=n9216 A1=FE_RN_5_0 B1=FE_OFN1327_weight_1_r_11
+ B2=weight_1_r[12]
XFE_OCPC2073_weight_1_r_13 BUF2CK $PINS O=FE_OCPN9768_weight_1_r_13
+ I=weight_1_r[13]
XFE_RC_159_0 OAI12H $PINS O=n3649 A1=n3650 B1=FE_OFN1590_n3135 B2=n6257
XFE_OCPC2072_weight_2_r_19 BUF1 $PINS O=FE_OCPN9767_weight_2_r_19
+ I=weight_2_r[19]
XFE_RC_158_0 INV1S $PINS O=FE_RN_56_0 I=n2826
XFE_RC_157_0 MXL2HS $PINS OB=pConv_0/product_1_w[20] S=n3189 A=n2826
+ B=FE_RN_56_0
XFE_RC_156_0 ND3HT $PINS O=n2084 I1=n9182 I2=n3830 I3=n9178
XFE_RC_155_0 INV1S $PINS O=FE_RN_55_0 I=n6964
XFE_RC_154_0 MXL2H $PINS OB=n2159 S=n2150 A=FE_RN_55_0 B=n6964
XFE_RC_153_0 MAO222 $PINS O=n6130 A1=n6115 B1=n6114 C1=n6113
XFE_RC_152_0 XOR3 $PINS O=n6134 I1=n6115 I2=n6114 I3=n6113
XFE_RC_151_0 XOR2H $PINS O=n4329 I1=weight_2_r[18] I2=n3475
XFE_RC_150_0 INV1S $PINS O=FE_RN_54_0 I=n6994
XFE_RC_149_0 MXL2HS $PINS OB=pConv_0/product_2_w[18] S=n6993 A=n6994
+ B=FE_RN_54_0
XFE_RC_148_0 OAI12H $PINS O=n4268 A1=n3151 B1=n3153 B2=n3152
XFE_RC_147_0 OAI12HS $PINS O=n3546 A1=n2296 B1=n3548 B2=n3547
XFE_RC_146_0 INV1S $PINS O=FE_RN_53_0 I=n2756
XFE_RC_145_0 MXL2H $PINS OB=pConv_1/product_2_w[14] S=n2757 A=FE_RN_53_0
+ B=n2756
XFE_OCPC2071_n6788 BUF1 $PINS O=FE_OCPN9766_n6788 I=n6788
XFE_OCPC2070_n6986 BUF2 $PINS O=FE_OCPN9765_n6986 I=n6986
XFE_OCPC2069_weight_0_r_19 BUF1 $PINS O=FE_OCPN9764_weight_0_r_19
+ I=weight_0_r[19]
XFE_OCPC2068_n6804 BUF1 $PINS O=FE_OCPN9763_n6804 I=n6804
XFE_RC_144_0 ND2S $PINS O=FE_RN_52_0 I1=FE_OFN1439_FE_DBTN16_n5612 I2=n5779
XFE_RC_143_0 OAI12HS $PINS O=n5798 A1=FE_RN_52_0 B1=FE_OFN1585_FE_DBTN6_n7135
+ B2=n5780
XFE_RC_142_0 OR2 $PINS O=FE_RN_50_0 I1=n3063 I2=n3102
XFE_RC_141_0 ND2 $PINS O=FE_RN_51_0 I1=FE_OFN1518_n5608 I2=n5834
XFE_RC_140_0 ND2 $PINS O=n5846 I1=FE_RN_51_0 I2=FE_RN_50_0
XFE_RC_139_0 OAI12HT $PINS O=n9755 A1=n3621 B1=n9766 B2=n3627
XFE_RC_138_0 ND2 $PINS O=FE_RN_49_0 I1=n6672 I2=FE_OFN1545_n7188
XFE_RC_137_0 OAI12HS $PINS O=n2355 A1=FE_RN_49_0 B1=FE_OFN1647_n9466 B2=n6748
XFE_RC_136_0 MOAI1 $PINS O=n6192 A1=FE_OFN1568_FE_DBTN31_n6225 A2=n6180
+ B1=n6179 B2=FE_OFN9125_n3656
XFE_RC_135_0 INV2 $PINS O=FE_RN_48_0 I=n1917
XFE_RC_134_0 MXL2H $PINS OB=pConv_1/product_2_w[20] S=n6878 A=n1917
+ B=FE_RN_48_0
XFE_RC_133_0 OAI12H $PINS O=n5855 A1=n3828 B1=FE_OFN9136_weight_1_r_3 B2=n3357
XFE_RC_132_0 ND3HT $PINS O=n3554 I1=n6390 I2=n9165 I3=n3556
XFE_RC_131_0 INV1S $PINS O=FE_RN_47_0 I=n1989
XFE_RC_130_0 MXL2HS $PINS OB=pConv_1/product_0_w[19] S=n2085 A=n1989
+ B=FE_RN_47_0
XFE_RC_129_0 MOAI1HP $PINS O=n6658 A1=n6654 A2=FE_OFN1446_FE_DBTN0_weight_0_r_7
+ B1=n6653 B2=FE_OFN1446_FE_DBTN0_weight_0_r_7
XFE_RC_127_0 ND3HT $PINS O=n2029 I1=n4586 I2=n4585 I3=n4587
XFE_RC_126_0 INV2 $PINS O=FE_RN_46_0 I=n3892
XFE_RC_125_0 MXL2H $PINS OB=n3897 S=FE_OFN1431_FE_DBTN26_weight_1_r_15 A=n3893
+ B=FE_RN_46_0
XFE_RC_124_0 AOI22H $PINS O=n4006 A1=n4001 A2=FE_OFN1338_weight_1_r_8
+ B1=FE_OFN1461_n3961 B2=n4000
XFE_RC_123_0 OR2T $PINS O=FE_RN_45_0 I1=n6687 I2=FE_OFN9129_weight_0_r_3
XFE_RC_122_0 ND2T $PINS O=n9466 I1=FE_RN_45_0 I2=FE_RN_20_0
XFE_OCPC2067_FE_OFN9133_weight_1_r_3 BUF4CK $PINS
+ O=FE_OCPN9762_FE_OFN9133_weight_1_r_3 I=FE_OFN9133_weight_1_r_3
XFE_OCPC2066_n4404 BUF1 $PINS O=FE_OCPN9761_n4404 I=n4404
XFE_OCPC2065_n6309 BUF2 $PINS O=FE_OCPN9760_n6309 I=n6309
XFE_OCPC2064_FE_DBTN19_n4371 BUF1CK $PINS O=FE_OCPN9759_FE_DBTN19_n4371
+ I=FE_DBTN19_n4371
XFE_OCPC2063_weight_2_r_11 BUF1 $PINS O=FE_OCPN9758_weight_2_r_11
+ I=weight_2_r[11]
XFE_OCPC2062_weight_0_r_5 BUF1 $PINS O=FE_OCPN9757_weight_0_r_5 I=weight_0_r[5]
XFE_RC_121_0 MOAI1S $PINS O=n6480 A1=n5916 A2=n5915 B1=n9707 B2=n6449
XFE_RC_120_0 INV1S $PINS O=FE_RN_44_0 I=n7278
XFE_RC_119_0 MXL2HS $PINS OB=pConv_1/product_0_w[16] S=n3198 A=n7278
+ B=FE_RN_44_0
XFE_RC_118_0 INV1S $PINS O=FE_RN_43_0 I=n9358
XFE_RC_117_0 MXL2H $PINS OB=pConv_1/product_2_w[19] S=n9357 A=FE_RN_43_0
+ B=n9358
XFE_RC_116_0 INV1S $PINS O=FE_RN_42_0 I=n2597
XFE_RC_115_0 MXL2HS $PINS OB=pConv_1/product_1_w[20] S=n9270 A=FE_RN_42_0
+ B=n2597
XFE_RC_114_0 INV1S $PINS O=FE_RN_41_0 I=n9763
XFE_RC_113_0 MXL2HS $PINS OB=pConv_0/product_2_w[19] S=n9762 A=FE_RN_41_0
+ B=n9763
XFE_RC_112_0 INV1S $PINS O=FE_RN_40_0 I=n8933
XFE_RC_111_0 MXL2HS $PINS OB=pConv_2/product_1_w[19] S=n8932 A=FE_RN_40_0
+ B=n8933
XFE_RC_110_0 INV1S $PINS O=FE_RN_39_0 I=n9644
XFE_RC_109_0 MXL2HS $PINS OB=pConv_0/product_1_w[15] S=n9643 A=FE_RN_39_0
+ B=n9644
XFE_RC_108_0 INV1S $PINS O=FE_RN_38_0 I=n9280
XFE_RC_107_0 MXL2HS $PINS OB=pConv_1/product_1_w[19] S=n9279 A=FE_RN_38_0
+ B=n9280
XFE_RC_106_0 INV1S $PINS O=FE_RN_37_0 I=n1993
XFE_RC_105_0 MXL2HS $PINS OB=pConv_1/product_1_w[18] S=n4125 A=FE_RN_37_0
+ B=n1993
XFE_RC_104_0 INV1S $PINS O=FE_RN_36_0 I=n5930
XFE_RC_103_0 MXL2HS $PINS OB=pConv_2/product_2_w[18] S=n5929 A=n5930
+ B=FE_RN_36_0
XFE_RC_102_0 INV1S $PINS O=FE_RN_35_0 I=n2027
XFE_RC_101_0 MXL2H $PINS OB=pConv_2/product_1_w[21] S=n4663 A=FE_RN_35_0
+ B=n2027
XFE_RC_100_0 INV1S $PINS O=FE_RN_34_0 I=n9623
XFE_RC_99_0 MXL2HS $PINS OB=pConv_0/product_1_w[19] S=n9622 A=FE_RN_34_0
+ B=n9623
XFE_RC_98_0 INV1S $PINS O=FE_RN_33_0 I=n1996
XFE_RC_97_0 MXL2H $PINS OB=pConv_0/product_2_w[20] S=n3109 A=n1996 B=FE_RN_33_0
XFE_RC_95_0 MXL2HS $PINS OB=n2235 S=n6329 A=n6330 B=n2237
XFE_RC_94_0 INV1S $PINS O=FE_RN_31_0 I=n1925
XFE_RC_93_0 MXL2HS $PINS OB=pConv_0/product_1_w[18] S=n9632 A=n1925
+ B=FE_RN_31_0
XFE_RC_92_0 AOI12H $PINS O=n3186 A1=n7286 B1=FE_OFN1692_n4047 B2=n7287
XFE_RC_91_0 XOR2H $PINS O=n9707 I1=n5914 I2=FE_OFN1516_n5494
XFE_OCPC2061_n6842 BUF1 $PINS O=FE_OCPN9756_n6842 I=n6842
XFE_RC_90_0 ND3HT $PINS O=n2975 I1=n3347 I2=n3346 I3=n3343
XFE_OCPC2060_FE_OFN1289_weight_0_r_5 BUF4CK $PINS
+ O=FE_OCPN9755_FE_OFN1289_weight_0_r_5 I=FE_OFN1289_weight_0_r_5
XFE_RC_89_0 OAI12H $PINS O=n2573 A1=n2626 B1=n9332 B2=n9334
XFE_RC_88_0 MOAI1H $PINS O=n4024 A1=n4009 A2=FE_OFN1637_n9221
+ B1=FE_OFN1558_FE_DBTN42_n3886 B2=n4008
XFE_OCPC2059_n6785 BUF1 $PINS O=FE_OCPN9754_n6785 I=n6785
XFE_OCPC2058_n6521 BUF1 $PINS O=FE_OCPN9753_n6521 I=n6521
XFE_RC_87_0 XOR2HS $PINS O=n4064 I1=data_1_r[31] I2=FE_OFN1336_weight_1_r_9
XFE_OCPC2057_n4554 BUF1 $PINS O=FE_OCPN9752_n4554 I=n4554
XFE_OCPC2056_weight_0_r_23 BUF1 $PINS O=FE_OCPN9751_weight_0_r_23
+ I=weight_0_r[23]
XFE_OCPC2055_weight_1_r_5 BUF1 $PINS O=FE_OCPN9750_weight_1_r_5 I=weight_1_r[5]
XFE_RC_86_0 ND3HT $PINS O=n3389 I1=n3267 I2=n3268 I3=n3266
XFE_RC_85_0 XOR2HS $PINS O=n3369 I1=n4265 I2=n3370
XFE_RC_84_0 INV1S $PINS O=FE_RN_30_0 I=n5952
XFE_RC_83_0 MXL2H $PINS OB=n5980 S=FE_DBTN12_weight_2_r_7 A=n5953 B=FE_RN_30_0
XFE_RC_82_0 OAI12HT $PINS O=n9144 A1=n3811 B1=n9148 B2=n5886
XFE_RC_81_0 INV1S $PINS O=FE_RN_29_0 I=n6529
XFE_RC_80_0 MXL2HS $PINS OB=n6531 S=FE_OFN1430_FE_DBTN28_weight_0_r_15 A=n6530
+ B=FE_RN_29_0
XFE_OFC2054_weight_1_r_7 INV1S $PINS O=FE_OFN1341_weight_1_r_7
+ I=FE_OFN1339_weight_1_r_7
XFE_OFC2053_weight_1_r_7 BUF4CK $PINS O=FE_OFN1429_FE_DBTN32_weight_1_r_7
+ I=FE_OFN1339_weight_1_r_7
XFE_OFC2052_n9120 INV2 $PINS O=FE_DBTN10_n9120 I=FE_OFN1547_n9120
XFE_OFC2051_n9466 INV1S $PINS O=FE_OFN1648_n9466 I=FE_OFN1642_n9466
XFE_OFC2050_n6822 INV2 $PINS O=FE_DBTN45_n6822 I=FE_OFN1536_n6822
XFE_OFC2049_n6822 INV2 $PINS O=FE_OFN1536_n6822 I=FE_OFN1537_n6822
XFE_OFC2048_n6322 INV2 $PINS O=FE_OFN1656_n6322 I=FE_OFN1657_n6322
XFE_OFC2047_n6322 INV2 $PINS O=FE_OFN1657_n6322 I=FE_DBTN3_n6322
XFE_OFC2046_n6322 INV2 $PINS O=FE_DBTN3_n6322 I=n6322
XFE_OFC2045_weight_2_r_9 INV1S $PINS O=FE_OFN9749_n I=FE_OFN1660_weight_2_r_9
XFE_OFC2044_weight_2_r_9 INV2 $PINS O=FE_OFN1660_weight_2_r_9
+ I=FE_OFN1393_weight_2_r_9
XFE_OFC2043_weight_2_r_9 INV1S $PINS O=FE_OFN1661_weight_2_r_9
+ I=FE_OFN1393_weight_2_r_9
XFE_OFC2041_n3162 INV1S $PINS O=FE_OFN1652_n3162 I=FE_OFN1458_n3162
XFE_OFC2040_n3162 INV2 $PINS O=FE_OFN1458_n3162 I=FE_OFN1651_n3162
XFE_OFC2039_n3162 INV2 $PINS O=FE_OFN1651_n3162 I=n3162
XFE_OFC2037_data_1_r_35 INV1S $PINS O=n2343 I=data_1_r[35]
XFE_OFC2036_weight_0_r_13 INV2 $PINS O=FE_OFN9748_weight_0_r_13
+ I=FE_OFN1270_weight_0_r_13
XFE_OFC2035_weight_0_r_13 INV1S $PINS O=FE_OFN1272_weight_0_r_13
+ I=FE_OFN1270_weight_0_r_13
XFE_OFC2034_weight_0_r_13 INV1S $PINS O=FE_OFN1270_weight_0_r_13
+ I=weight_0_r[13]
XFE_OFC2033_weight_0_r_13 INV2 $PINS O=FE_DBTN33_weight_0_r_13 I=weight_0_r[13]
XFE_OFC2032_weight_0_r_13 BUF2 $PINS O=FE_OFN1271_weight_0_r_13
+ I=weight_0_r[13]
XCTS_ccl_a_inv_00045 INV12CK $PINS O=CTS_66 I=CTS_67
XCTS_ccl_a_inv_00035 INV12CK $PINS O=CTS_69 I=CTS_67
XCTS_ccl_a_inv_00034 INV12CK $PINS O=CTS_68 I=CTS_67
XCTS_ccl_a_inv_00061 INV12CK $PINS O=CTS_67 I=CTS_70
XCTS_ccl_a_inv_00040 INV12CK $PINS O=CTS_62 I=CTS_63
XCTS_ccl_a_inv_00039 INV12CK $PINS O=CTS_65 I=CTS_63
XCTS_ccl_a_inv_00038 INV12CK $PINS O=CTS_64 I=CTS_63
XCTS_ccl_a_inv_00057 INV12CK $PINS O=CTS_63 I=CTS_70
XCTS_ccl_a_inv_00037 INV12CK $PINS O=CTS_58 I=CTS_59
XCTS_ccl_a_inv_00036 INV12CK $PINS O=CTS_61 I=CTS_59
XCTS_ccl_a_inv_00033 INV12CK $PINS O=CTS_60 I=CTS_59
XCTS_ccl_a_inv_00056 INV12CK $PINS O=CTS_59 I=CTS_70
XCTS_ccl_a_inv_00068 INV12CK $PINS O=CTS_70 I=CTS_71
XCTS_ccl_a_inv_00044 INV12CK $PINS O=CTS_53 I=CTS_54
XCTS_ccl_a_inv_00018 INV12CK $PINS O=CTS_56 I=CTS_54
XCTS_ccl_a_inv_00001 INV12CK $PINS O=CTS_55 I=CTS_54
XCTS_ccl_a_inv_00060 INV12CK $PINS O=CTS_54 I=CTS_57
XCTS_ccl_a_inv_00017 INV12CK $PINS O=CTS_49 I=CTS_50
XCTS_ccl_a_inv_00008 INV12CK $PINS O=CTS_52 I=CTS_50
XCTS_ccl_a_inv_00007 INV12CK $PINS O=CTS_51 I=CTS_50
XCTS_ccl_a_inv_00049 INV12CK $PINS O=CTS_50 I=CTS_57
XCTS_ccl_a_inv_00067 INV8CK $PINS O=CTS_57 I=CTS_71
XCTS_ccl_a_inv_00043 INV12CK $PINS O=CTS_47 I=CTS_45
XCTS_ccl_a_inv_00009 INV12CK $PINS O=CTS_46 I=CTS_45
XCTS_ccl_a_inv_00059 INV6CK $PINS O=CTS_45 I=CTS_48
XCTS_ccl_a_inv_00042 INV12CK $PINS O=CTS_44 I=CTS_42
XCTS_ccl_a_inv_00041 INV12CK $PINS O=CTS_43 I=CTS_42
XCTS_ccl_a_inv_00058 INV6CK $PINS O=CTS_42 I=CTS_48
XCTS_ccl_a_inv_00066 INV4CK $PINS O=CTS_48 I=CTS_71
XCTS_ccl_inv_00071 INV12CK $PINS O=CTS_71 I=CTS_72
XCTS_ccl_a_inv_00032 INV12CK $PINS O=CTS_36 I=CTS_37
XCTS_ccl_a_inv_00022 INV12CK $PINS O=CTS_39 I=CTS_37
XCTS_ccl_a_inv_00013 INV12CK $PINS O=CTS_38 I=CTS_37
XCTS_ccl_a_inv_00055 INV8CK $PINS O=CTS_37 I=CTS_40
XCTS_ccl_a_inv_00065 INV6CK $PINS O=CTS_40 I=CTS_41
XCTS_ccl_a_inv_00031 INV12CK $PINS O=CTS_31 I=CTS_32
XCTS_ccl_a_inv_00019 INV12CK $PINS O=CTS_30 I=CTS_32
XCTS_ccl_a_inv_00016 INV12CK $PINS O=CTS_34 I=CTS_32
XCTS_ccl_a_inv_00005 INV12CK $PINS O=CTS_33 I=CTS_32
XCTS_ccl_a_inv_00054 INV12CK $PINS O=CTS_32 I=CTS_35
XCTS_ccl_a_inv_00014 INV12CK $PINS O=CTS_26 I=CTS_27
XCTS_ccl_a_inv_00006 INV12CK $PINS O=CTS_29 I=CTS_27
XCTS_ccl_a_inv_00003 INV12CK $PINS O=CTS_28 I=CTS_27
XCTS_ccl_a_inv_00048 INV12CK $PINS O=CTS_27 I=CTS_35
XCTS_ccl_a_inv_00012 INV12CK $PINS O=CTS_25 I=CTS_23
XCTS_ccl_a_inv_00002 INV12CK $PINS O=CTS_24 I=CTS_23
XCTS_ccl_a_inv_00047 INV6CK $PINS O=CTS_23 I=CTS_35
XCTS_ccl_a_inv_00064 INV12CK $PINS O=CTS_35 I=CTS_41
XCTS_ccl_a_inv_00030 INV12CK $PINS O=CTS_18 I=CTS_19
XCTS_ccl_a_inv_00029 INV12CK $PINS O=CTS_21 I=CTS_19
XCTS_ccl_a_inv_00010 INV12CK $PINS O=CTS_20 I=CTS_19
XCTS_ccl_a_inv_00053 INV12CK $PINS O=CTS_19 I=CTS_22
XCTS_ccl_a_inv_00028 INV12CK $PINS O=CTS_14 I=CTS_15
XCTS_ccl_a_inv_00027 INV12CK $PINS O=CTS_17 I=CTS_15
XCTS_ccl_a_inv_00021 INV12CK $PINS O=CTS_16 I=CTS_15
XCTS_ccl_a_inv_00052 INV12CK $PINS O=CTS_15 I=CTS_22
XCTS_ccl_a_inv_00023 INV12CK $PINS O=CTS_10 I=CTS_11
XCTS_ccl_a_inv_00020 INV12CK $PINS O=CTS_13 I=CTS_11
XCTS_ccl_a_inv_00015 INV12CK $PINS O=CTS_12 I=CTS_11
XCTS_ccl_a_inv_00050 INV12CK $PINS O=CTS_11 I=CTS_22
XCTS_ccl_a_inv_00063 INV12CK $PINS O=CTS_22 I=CTS_41
XCTS_ccl_inv_00070 INV12CK $PINS O=CTS_41 I=CTS_72
XCTS_ccl_a_inv_00026 INV12CK $PINS O=CTS_4 I=CTS_5
XCTS_ccl_a_inv_00025 INV12CK $PINS O=CTS_7 I=CTS_5
XCTS_ccl_a_inv_00024 INV12CK $PINS O=CTS_6 I=CTS_5
XCTS_ccl_a_inv_00051 INV8CK $PINS O=CTS_5 I=CTS_8
XCTS_ccl_a_inv_00011 INV12CK $PINS O=CTS_3 I=CTS_1
XCTS_ccl_a_inv_00004 INV12CK $PINS O=CTS_2 I=CTS_1
XCTS_ccl_a_inv_00046 INV6CK $PINS O=CTS_1 I=CTS_8
XCTS_ccl_a_inv_00062 INV8CK $PINS O=CTS_8 I=CTS_9
XCTS_ccl_inv_00069 INV4CK $PINS O=CTS_9 I=CTS_72
XCTS_ccl_inv_00072 INV12CK $PINS O=CTS_72 I=CTS_73
XCTS_ccl_a_inv_00073 INV12CK $PINS O=CTS_73 I=clk
XFE_RC_79_0 OAI222S $PINS O=n1748 A1=n8663 A2=FE_OFN2028_FE_OCPN9743_n5413
+ B1=FE_OCPN9785_FE_RN_3 B2=n8647 C1=n8698 C2=FE_OCPN9733_FE_OFN1481_n5424
XFE_RC_78_0 OAI222S $PINS O=n1763 A1=n8688 A2=FE_OFN2028_FE_OCPN9743_n5413
+ B1=FE_RN_3 B2=n8654 C1=n8755 C2=FE_OCPN9782_n5424
XFE_OFC2028_FE_OCPN9743_n5413 BUF2 $PINS O=FE_OFN2028_FE_OCPN9743_n5413
+ I=FE_OFN2027_FE_OCPN9743_n5413
XFE_OFC2027_FE_OCPN9743_n5413 BUF2 $PINS O=FE_OFN2027_FE_OCPN9743_n5413
+ I=FE_OCPN9743_n5413
XFE_OCPC2031_n5429 INV1S $PINS O=FE_OCPN9747_n5429 I=FE_OFN1209_n5429
XFE_OCPC2027_n5429 INV1S $PINS O=FE_OFN1209_n5429 I=n5429
XFE_OCPC2025_n5413 BUF2 $PINS O=FE_OCPN9743_n5413 I=FE_OFN1159_n5413
XFE_OCPC2024_n5413 INV1S $PINS O=FE_OCPN9742_n5413 I=FE_RN_1
XFE_OCPC2023_n5413 BUF2 $PINS O=FE_OFN1159_n5413 I=FE_OFN1160_n5413
XFE_OCPC2022_n5413 INV1S $PINS O=FE_RN_1 I=FE_OFN1170_n5413
XFE_OCPC2021_n5413 INV1S $PINS O=FE_OFN1168_n5413 I=FE_OFN1170_n5413
XFE_OCPC2020_n5413 INV2 $PINS O=FE_OFN1160_n5413 I=FE_OFN1170_n5413
XFE_OCPC2018_FE_OFN344_i_reset_n_i BUF1 $PINS
+ O=FE_OCPN9741_FE_OFN344_i_reset_n_i I=FE_OFN349_i_reset_n_i
XFE_OCPC2017_FE_OFN344_i_reset_n_i INV1S $PINS
+ O=FE_OCPN9740_FE_OFN344_i_reset_n_i I=FE_OFN352_i_reset_n_i
XFE_OCPC2016_FE_OFN344_i_reset_n_i INV2 $PINS
+ O=FE_OCPN9739_FE_OFN344_i_reset_n_i I=FE_OFN352_i_reset_n_i
XFE_OCPC2015_FE_OFN344_i_reset_n_i INV4 $PINS O=FE_OFN376_i_reset_n_i
+ I=FE_OFN352_i_reset_n_i
XFE_OCPC2014_FE_OFN344_i_reset_n_i INV3 $PINS O=FE_OFN349_i_reset_n_i
+ I=FE_OFN352_i_reset_n_i
XFE_OCPC2013_FE_OFN344_i_reset_n_i INV3 $PINS O=FE_OFN362_i_reset_n_i
+ I=FE_OFN352_i_reset_n_i
XFE_OCPC2012_FE_OFN344_i_reset_n_i INV1S $PINS O=FE_OFN364_i_reset_n_i
+ I=FE_OFN352_i_reset_n_i
XFE_OCPC2010_FE_OFN344_i_reset_n_i INV8 $PINS O=FE_OFN363_i_reset_n_i
+ I=FE_OFN353_i_reset_n_i
XFE_OCPC2009_FE_OFN344_i_reset_n_i INV3 $PINS O=FE_OFN345_i_reset_n_i
+ I=FE_OFN353_i_reset_n_i
XFE_OCPC2008_FE_OFN344_i_reset_n_i INV6 $PINS O=FE_OFN347_i_reset_n_i
+ I=FE_OFN353_i_reset_n_i
XFE_OCPC2007_FE_OFN344_i_reset_n_i INV4 $PINS O=FE_OFN375_i_reset_n_i
+ I=FE_OFN353_i_reset_n_i
XFE_OCPC2006_FE_OFN344_i_reset_n_i INV3 $PINS O=FE_OFN374_i_reset_n_i
+ I=FE_OFN353_i_reset_n_i
XFE_OCPC2004_FE_OFN344_i_reset_n_i INV2 $PINS O=FE_OFN352_i_reset_n_i
+ I=FE_OFN372_i_reset_n_i
XFE_OCPC2003_FE_OFN344_i_reset_n_i INV4 $PINS
+ O=FE_OFN1124_FE_OFN344_i_reset_n_i I=FE_OFN372_i_reset_n_i
XFE_OCPC2002_FE_OFN344_i_reset_n_i INV1S $PINS O=FE_OFN346_i_reset_n_i
+ I=FE_OFN344_i_reset_n_i
XFE_OCPC2001_FE_OFN344_i_reset_n_i INV12CK $PINS O=FE_OFN353_i_reset_n_i
+ I=FE_OFN344_i_reset_n_i
XFE_OCPC2000_FE_OFN344_i_reset_n_i INV1S $PINS O=FE_OFN350_i_reset_n_i
+ I=FE_OFN344_i_reset_n_i
XFE_OCPC1999_FE_OFN344_i_reset_n_i INV4CK $PINS
+ O=FE_OFN1123_FE_OFN344_i_reset_n_i I=FE_OFN344_i_reset_n_i
XFE_OCPC1998_FE_OFN344_i_reset_n_i INV12CK $PINS O=FE_OFN372_i_reset_n_i
+ I=FE_OFN344_i_reset_n_i
XFE_OCPC1997_n5429 INV1S $PINS O=FE_OCPN9738_n5429 I=FE_OFN1209_n5429
XFE_OCPC1994_n5429 INV1S $PINS O=FE_OCPN1987_n5429 I=FE_OFN1209_n5429
XFE_OCPC1992_n5429 BUF1 $PINS O=FE_OFN1200_n5429 I=n5429
XFE_OFC1211_n5429_dup BUF6 $PINS O=FE_RN_3 I=n5429
XFE_OCPC2022_FE_OFN1492_n5424 BUF1S $PINS O=FE_OCPN2022_FE_OFN1492_n5424
+ I=FE_OFN1492_n5424
XU8359_dup ND2T $PINS O=FE_RN_2 I1=n5429 I2=n5413
XFE_OCPC1991_FE_OFN1499_n5424 BUF1CK $PINS O=FE_OCPN1991_FE_OFN1499_n5424
+ I=FE_OFN1499_n5424
XFE_OCPC1990_FE_OFN1504_n5424 BUF1 $PINS O=FE_OCPN9736_FE_OFN1504_n5424
+ I=FE_OFN1499_n5424
XFE_RC_77_0 OAI222H $PINS O=n1712 A1=n7738 A2=FE_OFN1513_n5424
+ B1=FE_OFN1237_n5429 B2=n7688 C1=n7705 C2=FE_OFN1198_n5413
XFE_RC_76_0 OAI222S $PINS O=n1800 A1=n7550 A2=FE_OFN1194_n5413
+ B1=FE_OFN1511_n5424 B2=n7617 C1=n7517 C2=FE_OFN1237_n5429
XFE_OCPC1987_FE_OFN1481_n5424 BUF1 $PINS O=FE_OCPN9733_FE_OFN1481_n5424
+ I=FE_OCPN9782_n5424
XFE_RC_75_0 INV1S $PINS O=FE_RN_28_0 I=n1903
XFE_RC_74_0 MXL2H $PINS OB=pConv_0/product_2_w[21] S=n3167 A=FE_RN_28_0 B=n1903
XFE_RC_73_0 INV1S $PINS O=FE_RN_27_0 I=n2010
XFE_RC_72_0 MXL2HS $PINS OB=pConv_2/product_1_w[18] S=n3706 A=FE_RN_27_0
+ B=n2010
XFE_RC_71_0 XOR2HS $PINS O=n3487 I1=n4262 I2=n1911
XFE_RC_70_0 INV1S $PINS O=FE_RN_26_0 I=n2810
XFE_RC_69_0 MXL2H $PINS OB=pConv_1/product_2_w[18] S=n2311 A=FE_RN_26_0 B=n2810
XFE_RC_68_0 MOAI1 $PINS O=n6593 A1=n6562 A2=n9696 B1=FE_OFN1541_n7045 B2=n6561
XFE_RC_67_0 INV1S $PINS O=FE_RN_23_0 I=n3236
XFE_RC_66_0 INV1S $PINS O=FE_RN_24_0 I=n2668
XFE_RC_65_0 ND2 $PINS O=FE_RN_25_0 I1=FE_RN_24_0 I2=FE_RN_23_0
XFE_RC_64_0 ND2 $PINS O=n6946 I1=n2667 I2=FE_RN_25_0
XFE_RC_63_0 XNR2HS $PINS O=n6647 I1=n3079 I2=n6631
XFE_RC_62_0 INV1S $PINS O=FE_RN_21_0 I=FE_OFN1698_n5491
XFE_RC_61_0 INV1S $PINS O=FE_RN_22_0 I=n6918
XFE_RC_60_0 OAI22S $PINS O=n6906 A1=FE_RN_22_0 A2=FE_RN_21_0 B1=n6890
+ B2=FE_DBTN35_weight_0_r_17
XFE_OCPC1985_FE_OFN1327_weight_1_r_11 BUF1 $PINS
+ O=FE_OCPN9731_FE_OFN1327_weight_1_r_11 I=FE_OFN1327_weight_1_r_11
XFE_RC_58_0 ND2 $PINS O=FE_RN_20_0 I1=FE_OFN9129_weight_0_r_3 I2=n6686
XFE_RC_56_0 ND2 $PINS O=FE_RN_19_0 I1=n3998 I2=FE_OFN1452_n2589
XFE_RC_55_0 OAI12HS $PINS O=n4015 A1=FE_RN_19_0 B1=FE_OFN1672_n4077 B2=n4010
XFE_OCPC1983_n6138 BUF1 $PINS O=FE_OCPN9729_n6138 I=n6138
XFE_RC_54_0 ND3HT $PINS O=n3757 I1=n3554 I2=n3553 I3=n3555
XFE_RC_53_0 AOI12HS $PINS O=n6867 A1=n9547 B1=FE_OCPN9720_n6857 B2=n9549
XFE_RC_51_0 INV1S $PINS O=FE_RN_18_0 I=n2861
XFE_RC_50_0 MXL2H $PINS OB=pConv_1/product_0_w[21] S=n3752 A=FE_RN_18_0 B=n2861
XFE_RC_47_0 MXL2HS $PINS OB=n2333 S=n5751 A=n3841 B=n5752
XFE_RC_45_0 INV1S $PINS O=FE_RN_16_0 I=n2657
XFE_RC_44_0 MXL2HS $PINS OB=n4093 S=n3569 A=n2657 B=FE_RN_16_0
XFE_RC_43_0 INV1S $PINS O=FE_RN_15_0 I=n4215
XFE_RC_42_0 MXL2HS $PINS OB=n4222 S=n3768 A=n4215 B=FE_RN_15_0
XFE_RC_41_0 INV1S $PINS O=FE_RN_14_0 I=n1907
XFE_RC_40_0 MXL2H $PINS OB=pConv_1/product_1_w[21] S=n9261 A=FE_RN_14_0 B=n1907
XFE_RC_39_0 INV1S $PINS O=FE_RN_13_0 I=n5889
XFE_RC_38_0 MXL2H $PINS OB=pConv_1/product_0_w[18] S=n2346 A=n5889 B=FE_RN_13_0
XFE_RC_37_0 OR2 $PINS O=FE_RN_12_0 I1=n5715 I2=FE_DBTN6_n7135
XFE_RC_36_0 ND2P $PINS O=n5734 I1=n2515 I2=FE_RN_12_0
XFE_RC_35_0 ND3HT $PINS O=n2822 I1=n3625 I2=n3624 I3=n3623
XFE_RC_34_0 AOI12HS $PINS O=n9150 A1=n1919 B1=n3757 B2=n9149
XFE_OCPC1977_n3961 BUF1CK $PINS O=FE_OCPN9723_n3961 I=n3961
XFE_RC_33_0 OAI22S $PINS O=n4371 A1=FE_OFN9142_n A2=n4370 B1=n4528 B2=n4443
XFE_RC_32_0 MOAI1S $PINS O=n4616 A1=FE_OFN1443_FE_DBTN7_n4532 A2=n4603
+ B1=FE_OFN1433_FE_DBTN19_n4371 B2=n4602
XFE_RC_31_0 INV1S $PINS O=FE_RN_11_0 I=n1966
XFE_RC_30_0 MXL2HS $PINS OB=pConv_0/product_0_w[20] S=n2127 A=n1966
+ B=FE_RN_11_0
XFE_RC_29_0 INV1S $PINS O=FE_RN_10_0 I=n1913
XFE_RC_28_0 MXL2HS $PINS OB=pConv_2/product_1_w[20] S=n3794 A=n1913
+ B=FE_RN_10_0
XFE_RC_27_0 INV1S $PINS O=FE_RN_9_0 I=n9544
XFE_RC_26_0 MXL2HS $PINS OB=pConv_0/product_0_w[14] S=n9543 A=FE_RN_9_0 B=n9544
XFE_RC_25_0 INV1S $PINS O=FE_RN_8_0 I=n2902
XFE_RC_24_0 MXL2HS $PINS OB=pConv_0/product_0_w[21] S=n9500 A=FE_RN_8_0 B=n2902
XFE_RC_23_0 INV1S $PINS O=FE_RN_7_0 I=n9537
XFE_RC_22_0 MXL2HS $PINS OB=pConv_0/product_0_w[15] S=n9536 A=FE_RN_7_0 B=n9537
XFE_OCPC1974_n6857 BUF1 $PINS O=FE_OCPN9720_n6857 I=n6857
XFE_RC_21_0 MAO222 $PINS O=n4660 A1=n4425 B1=n4424 C1=n4423
XFE_RC_19_0 MOAI1 $PINS O=n2303 A1=n9221 A2=n3979 B1=FE_OFN1556_FE_DBTN42_n3886
+ B2=n3978
XFE_RC_18_0 MOAI1 $PINS O=n5876 A1=n3810 A2=FE_OFN1355_weight_1_r_1 B1=n3808
+ B2=n5862
XFE_RC_17_0 INV1S $PINS O=FE_RN_6_0 I=n7025
XFE_RC_16_0 MXL2HS $PINS OB=n3867 S=n7024 A=n7025 B=FE_RN_6_0
XFE_RC_15_0 ND2P $PINS O=FE_RN_5_0 I1=FE_OFN1327_weight_1_r_11
+ I2=weight_1_r[12]
XFE_RC_13_0 MOAI1 $PINS O=n5565 A1=FE_OFN1658_n7045 A2=n5563 B1=n5562
+ B2=weight_0_r[8]
XFE_RC_12_0 MXL2HP $PINS OB=n3656 S=FE_OFN1448_n2033 A=n6222 B=n3657
XFE_RC_11_0 INV1S $PINS O=FE_RN_4_0 I=n6564
XFE_RC_10_0 MXL2HP $PINS OB=n7070 S=FE_OFN1428_FE_DBTN34_weight_0_r_11 A=n6566
+ B=FE_RN_4_0
XFE_OCPC1970_weight_2_r_13 BUF2 $PINS O=FE_OCPN9716_weight_2_r_13
+ I=weight_2_r[13]
XFE_RC_9_0 INV1S $PINS O=FE_RN_3_0 I=n2097
XFE_RC_8_0 MXL2HP $PINS OB=n6448 S=FE_OFN1432_FE_DBTN23_weight_0_r_23 A=n5908
+ B=FE_RN_3_0
XFE_RC_7_0 NR3HP $PINS O=n3510 I1=weight_2_r[20] I2=FE_OFN1462_n4128 I3=n4145
XFE_RC_6_0 OR2 $PINS O=FE_RN_1_0 I1=n9349 I2=n4086
XFE_RC_5_0 ND2 $PINS O=FE_RN_2_0 I1=n4064 I2=FE_OCPN9723_n3961
XFE_RC_4_0 ND2P $PINS O=n4048 I1=FE_RN_2_0 I2=FE_RN_1_0
XFE_RC_3_0 OR2T $PINS O=FE_RN_0_0 I1=FE_DBTN34_weight_0_r_11 I2=n6575
XFE_RC_2_0 ND2T $PINS O=n3850 I1=n3849 I2=FE_RN_0_0
XFE_RC_1_0 MAO222 $PINS O=n7058 A1=n6547 B1=n6546 C1=n6545
XFE_RC_0_0 XOR3 $PINS O=n6631 I1=n6547 I2=n6546 I3=n6545
XFE_OFC1969_n5496 INV2 $PINS O=FE_OFN1685_n5496 I=FE_OFN1684_n5496
XFE_OFC1968_n5496 INV2 $PINS O=FE_OFN1684_n5496 I=FE_OFN1609_n5496
XFE_OFC1967_n5496 INV2 $PINS O=FE_OFN1683_n5496 I=FE_OFN1609_n5496
XFE_OFC1964_n5494 BUF6 $PINS O=FE_OFN1516_n5494 I=n5494
XFE_OFC1963_n5429 INV2 $PINS O=FE_OFN9715_n I=FE_OFN1223_n5429
XFE_OFC1962_n5429 INV1S $PINS O=FE_OFN9714_n I=FE_OFN1230_n5429
XFE_OFC1961_n5429 INV3 $PINS O=FE_OFN1229_n5429 I=FE_OFN1230_n5429
XFE_OFC1960_n5429 INV1S $PINS O=FE_OFN1227_n5429 I=FE_OFN1230_n5429
XFE_OFC1959_n5429 BUF2 $PINS O=FE_OFN1223_n5429 I=FE_OFN1230_n5429
XFE_OFC1957_n5429 INV3 $PINS O=FE_OFN1230_n5429 I=FE_OFN1215_n5429
XFE_OFC1956_weight_0_r_9 BUF1 $PINS O=FE_OFN1279_weight_0_r_9
+ I=FE_OFN1278_weight_0_r_9
XFE_OFC1955_n5605 INV1S $PINS O=n5591 I=n5605
XFE_OFC1954_n9713 INV2 $PINS O=n9697 I=FE_OFN1553_n9713
XFE_OFC1953_weight_2_r_23 INV1S $PINS O=FE_OFN9147_n I=FE_OFN1535_n6821
XFE_OFC1949_weight_1_r_3 BUF2 $PINS O=FE_OFN9136_weight_1_r_3
+ I=FE_OFN9135_weight_1_r_3
XFE_OFC1948_weight_1_r_3 INV2 $PINS O=FE_OFN9135_weight_1_r_3
+ I=FE_OFN9132_weight_1_r_3
XFE_OFC1947_n5725 BUF1 $PINS O=FE_OFN1348_weight_1_r_3 I=n5725
XFE_OFC1946_n5725 BUF1 $PINS O=FE_OFN1350_weight_1_r_3 I=n5725
XFE_OFC1945_n6448 INV2 $PINS O=FE_OFN1623_n6448 I=FE_OFN1621_n6448
XFE_OFC1944_n6448 INV2 $PINS O=FE_OFN1622_n6448 I=FE_OFN1621_n6448
XFE_OFC1943_weight_1_r_7 BUF2 $PINS O=FE_OFN1342_weight_1_r_7
+ I=FE_OFN1340_weight_1_r_7
XFE_OFC1941_n6531 INV3 $PINS O=FE_OFN1627_n6531 I=FE_OFN1625_n6531
XFE_OFC1940_n6531 INV2 $PINS O=FE_OFN1626_n6531 I=FE_OFN1625_n6531
XFE_OFC1939_weight_2_r_23 INV1S $PINS O=FE_OFN9145_n I=FE_OFN1535_n6821
XFE_OFC1938_weight_2_r_23 INV2 $PINS O=FE_OFN1535_n6821 I=weight_2_r[23]
XFE_OFC1937_FE_DBTN22_n3850 BUF3 $PINS O=FE_OFN1571_FE_DBTN22_n3850
+ I=FE_OFN1570_FE_DBTN22_n3850
XFE_OFC1936_n9457 INV1S $PINS O=FE_OFN9144_n9457 I=n9457
XFE_OFC1935_n9457 BUF1 $PINS O=n9435 I=n9457
XFE_OFC1933_n9457 BUF1 $PINS O=FE_OFN1550_n9457 I=n9457
XFE_OFC1932_weight_1_r_11 BUF2 $PINS O=FE_OFN1327_weight_1_r_11
+ I=FE_DBTN44_weight_1_r_11
XFE_OFC1931_weight_1_r_11 INV2 $PINS O=FE_OFN1426_FE_DBTN44_weight_1_r_11
+ I=FE_DBTN44_weight_1_r_11
XFE_OFC1930_weight_1_r_11 INV3 $PINS O=FE_DBTN44_weight_1_r_11 I=weight_1_r[11]
XFE_OFC1929_n2727 INV1S $PINS O=FE_OFN1628_n6532 I=FE_OFN1454_n2727
XFE_OFC1928_n2727 INV1S $PINS O=n6532 I=FE_OFN1454_n2727
XFE_OFC1923_weight_2_r_11 INV1S $PINS O=FE_OFN9143_n I=n4443
XFE_OFC1922_weight_2_r_11 INV3 $PINS O=FE_OFN9142_n I=n4443
XFE_OFC1920_weight_2_r_11 BUF1 $PINS O=FE_OFN1392_weight_2_r_11
+ I=weight_2_r[11]
XFE_OFC1919_weight_2_r_11 INV2 $PINS O=n4443 I=weight_2_r[11]
XFE_OFC1918_weight_2_r_11 BUF1 $PINS O=FE_OFN1391_weight_2_r_11
+ I=weight_2_r[11]
XFE_OFC1917_FE_DBTN6_n7135 INV2 $PINS O=FE_OFN1585_FE_DBTN6_n7135
+ I=FE_OFN1582_FE_DBTN6_n7135
XFE_OFC1916_FE_DBTN6_n7135 INV1S $PINS O=FE_OFN1582_FE_DBTN6_n7135
+ I=FE_DBTN6_n7135
XFE_OFC1915_n3387 INV2 $PINS O=FE_OFN9141_n3387 I=FE_DBTN11_n3387
XFE_OFC1914_n3387 INV2 $PINS O=FE_OFN9140_n3387 I=FE_DBTN11_n3387
XFE_OFC1913_n3387 INV1S $PINS O=FE_OFN1644_FE_DBTN11_n3387 I=FE_OFN1591_n3387
XFE_OFC1912_n3387 INV2 $PINS O=FE_DBTN11_n3387 I=FE_OFN1591_n3387
XFE_OFC1911_n3387 INV2 $PINS O=FE_OFN1591_n3387 I=n3387
XFE_OFC1910_n7070 INV2 $PINS O=FE_OFN1635_n7070 I=FE_OFN1636_n7070
XFE_OFC1909_n7070 INV3 $PINS O=FE_OFN1634_n7070 I=FE_OFN1636_n7070
XFE_OFC1908_n7070 INV3 $PINS O=FE_OFN1636_n7070 I=FE_OFN1633_n7070
XFE_OFC1907_weight_2_r_23 INV2 $PINS O=n6821 I=FE_OFN9145_n
XFE_OFC1905_weight_1_r_7 INV1S $PINS O=FE_DBTN32_weight_1_r_7
+ I=FE_OFN1341_weight_1_r_7
XFE_OFC1903_n9469 INV1S $PINS O=n9473 I=n9469
XFE_OFC1902_n5429 INV2 $PINS O=FE_OFN1233_n5429 I=FE_OFN1223_n5429
XFE_OFC1901_n5429 INV1S $PINS O=FE_OFN1232_n5429 I=FE_OFN1223_n5429
XFE_OFC1900_n3428 BUF2 $PINS O=FE_OFN1572_FE_DBTN21_n3428 I=FE_DBTN21_n3428
XFE_OFC1899_n3428 BUF1 $PINS O=FE_OFN1459_n3428 I=n3428
XFE_OFC1898_n3428 INV2 $PINS O=FE_DBTN21_n3428 I=n3428
XFE_OFC1897_weight_1_r_19 BUF1 $PINS O=FE_OFN1449_n2033 I=FE_OFN1448_n2033
XFE_OFC1896_weight_1_r_19 INV3 $PINS O=n2033 I=FE_OFN1311_weight_1_r_19
XFE_OFC1895_weight_1_r_19 INV2 $PINS O=FE_OFN1448_n2033
+ I=FE_OFN1311_weight_1_r_19
XFE_OFC1894_n5853 INV1S $PINS O=FE_OFN9139_n5853 I=FE_DBTN37_n5853
XFE_OFC1893_n5853 INV2 $PINS O=FE_OFN1562_FE_DBTN37_n5853 I=FE_DBTN37_n5853
XFE_OFC1892_n5853 BUF2 $PINS O=FE_DBTN37_n5853 I=n5853
XFE_OFC1891_weight_2_r_15 INV1S $PINS O=FE_OFN9138_n I=FE_OFN1383_weight_2_r_15
XFE_OFC1890_weight_2_r_15 INV1S $PINS O=FE_OFN9137_n I=FE_OFN1383_weight_2_r_15
XFE_OFC1889_weight_2_r_15 INV1S $PINS O=FE_OFN1384_weight_2_r_15
+ I=FE_OFN1383_weight_2_r_15
XFE_OFC1887_weight_2_r_15 INV2 $PINS O=FE_OFN1380_weight_2_r_15
+ I=FE_OFN1383_weight_2_r_15
XFE_OFC1886_weight_2_r_15 INV2 $PINS O=FE_OFN1383_weight_2_r_15
+ I=weight_2_r[15]
XFE_OFC1882_weight_1_r_3 INV1S $PINS O=FE_OFN9133_weight_1_r_3
+ I=FE_OFN1347_weight_1_r_3
XFE_OFC1881_weight_1_r_3 INV2 $PINS O=FE_OFN9132_weight_1_r_3
+ I=FE_OFN1347_weight_1_r_3
XFE_OFC1877_weight_1_r_3 INV2 $PINS O=n5725 I=FE_OFN1347_weight_1_r_3
XFE_OFC1876_weight_1_r_3 INV3 $PINS O=FE_OFN1347_weight_1_r_3 I=weight_1_r[3]
XFE_OFC1875_weight_0_r_3 INV2 $PINS O=FE_OFN9130_weight_0_r_3
+ I=FE_OFN9127_weight_0_r_3
XFE_OFC1874_weight_0_r_3 INV2 $PINS O=FE_OFN9129_weight_0_r_3
+ I=FE_OFN9127_weight_0_r_3
XFE_OFC1873_weight_0_r_3 INV2 $PINS O=FE_OFN9128_weight_0_r_3
+ I=FE_OFN1292_weight_0_r_3
XFE_OFC1872_weight_0_r_3 INV2 $PINS O=FE_OFN9127_weight_0_r_3
+ I=FE_OFN1292_weight_0_r_3
XFE_OFC1870_weight_0_r_3 INV1S $PINS O=n6702 I=FE_OFN1292_weight_0_r_3
XFE_OFC1869_weight_0_r_3 INV1S $PINS O=FE_OFN1533_n6702
+ I=FE_OFN1292_weight_0_r_3
XFE_OFC1868_weight_0_r_3 INV2 $PINS O=FE_OFN1292_weight_0_r_3 I=weight_0_r[3]
XFE_OFC1867_n3656 INV1S $PINS O=FE_OFN9126_n3656 I=FE_OFN1561_FE_DBTN40_n3656
XFE_OFC1866_n3656 INV2 $PINS O=FE_OFN9125_n3656 I=n3656
XFE_OFC1865_n3656 INV1S $PINS O=FE_OFN9124_n3656 I=n3656
XFE_OFC1864_n3656 INV2 $PINS O=FE_DBTN40_n3656 I=n3656
XFE_OFC1863_n3656 INV2 $PINS O=FE_OFN1561_FE_DBTN40_n3656 I=n3656
XFE_OFC1862_n3656 INV1S $PINS O=FE_OFN1560_FE_DBTN40_n3656 I=n3656
XFE_OFC1861_n2908 INV1S $PINS O=FE_OFN9123_n2908 I=FE_OFN9122_n2908
XFE_OFC1860_n2908 INV2 $PINS O=FE_OFN9122_n2908 I=n2908
XFE_OFC1859_n2908 INV1S $PINS O=FE_OFN9121_n2908 I=n2908
XFE_OFC1858_n2908 INV1S $PINS O=FE_OFN1575_FE_DBTN20_n2908 I=n2908
XFE_OFC1857_n2908 INV1S $PINS O=FE_OFN1574_FE_DBTN20_n2908 I=n2908
XFE_OFC1856_n2908 INV1S $PINS O=FE_OFN1573_FE_DBTN20_n2908 I=n2908
XFE_OFC1855_n2908 INV1S $PINS O=FE_DBTN20_n2908 I=n2908
XFE_OFC1854_n9120 INV2 $PINS O=FE_OFN1578_FE_DBTN10_n9120 I=FE_OFN1547_n9120
XFE_OFC1852_n2932 BUF1 $PINS O=FE_OFN1588_n2932 I=n2932
XFE_OFC1851_weight_1_r_8 BUF2 $PINS O=FE_OFN1337_weight_1_r_8 I=weight_1_r[8]
XFE_OFC1849_n3162 INV2 $PINS O=FE_OFN1457_n3162 I=FE_OFN1651_n3162
XFE_OFC1848_n3162 INV1S $PINS O=n3285 I=FE_OFN1651_n3162
XFE_OFC1845_n9443 INV2 $PINS O=FE_OFN1704_n9443 I=FE_DBTN8_n9443
XFE_OFC1844_n9443 INV2 $PINS O=FE_OFN1579_FE_DBTN8_n9443 I=FE_DBTN8_n9443
XFE_OFC1843_n9443 INV2 $PINS O=FE_DBTN8_n9443 I=FE_OFN1580_FE_DBTN8_n9443
XFE_OFC1841_n9443 INV2 $PINS O=FE_OFN1580_FE_DBTN8_n9443 I=n9443
XFE_OFC1840_i_reset_n_i BUF2 $PINS O=FE_OFN1703_n I=FE_OFN995_i_reset_n_i
XFE_OFC1839_i_reset_n_i BUF2 $PINS O=FE_OFN1059_i_reset_n_i
+ I=FE_OFN995_i_reset_n_i
XFE_OFC1838_n6822 INV1S $PINS O=FE_OFN1702_n6822 I=FE_OFN1537_n6822
XFE_OFC1837_n6822 INV1S $PINS O=FE_OFN1701_n6822 I=FE_OFN1537_n6822
XFE_OFC1834_n6822 INV2 $PINS O=FE_OFN1537_n6822 I=n6822
XFE_OFC1833_n7188 INV1S $PINS O=FE_OFN1699_n7188 I=n7188
XFE_OFC1832_n7188 INV1S $PINS O=FE_OFN1641_n9465 I=n7188
XFE_OFC1831_n7188 BUF1 $PINS O=n9465 I=n7188
XFE_OFC1830_n4079 INV1S $PINS O=n4080 I=n4079
XFE_OFC1829_n3876 INV1S $PINS O=n6541 I=n3876
XFE_OFC1828_weight_2_r_5 BUF1 $PINS O=FE_OFN1403_weight_2_r_5
+ I=FE_OFN1401_weight_2_r_5
XFE_OFC1827_weight_2_r_5 BUF2 $PINS O=FE_OFN1401_weight_2_r_5 I=weight_2_r[5]
XFE_OFC1826_n5491 INV2 $PINS O=FE_OFN1698_n5491 I=FE_OFN1514_n5491
XFE_OFC1825_n5491 INV2 $PINS O=FE_OFN1697_n5491 I=FE_OFN1514_n5491
XFE_OFC1824_n5491 INV2 $PINS O=FE_OFN1696_n5491 I=FE_OFN1514_n5491
XFE_OFC1821_n5491 INV2 $PINS O=FE_OFN1514_n5491 I=n5491
XFE_OFC1820_n6937 INV1S $PINS O=FE_DBTN25_n6937 I=n6937
XFE_OFC1819_n6937 INV1S $PINS O=FE_OFN1569_FE_DBTN25_n6937 I=n6937
XFE_OFC1817_weight_2_r_17 INV2 $PINS O=FE_OFN1695_weight_2_r_17
+ I=FE_OFN1694_weight_2_r_17
XFE_OFC1816_weight_2_r_17 INV3 $PINS O=FE_OFN1694_weight_2_r_17
+ I=FE_OFN1376_weight_2_r_17
XFE_OFC1815_weight_2_r_17 INV3 $PINS O=n3475 I=FE_OFN1373_weight_2_r_17
XFE_OFC1814_weight_2_r_17 INV2 $PINS O=FE_OFN1376_weight_2_r_17
+ I=FE_OFN1373_weight_2_r_17
XFE_OFC1812_weight_2_r_17 INV1S $PINS O=FE_OFN1374_weight_2_r_17
+ I=FE_OFN1373_weight_2_r_17
XFE_OFC1811_weight_2_r_17 INV2 $PINS O=FE_OFN1373_weight_2_r_17
+ I=weight_2_r[17]
XFE_OFC1810_weight_0_r_1 BUF2 $PINS O=FE_OFN1298_weight_0_r_1
+ I=FE_OFN1296_weight_0_r_1
XFE_OFC1809_weight_0_r_1 BUF2 $PINS O=FE_OFN1297_weight_0_r_1
+ I=FE_OFN1296_weight_0_r_1
XFE_OFC1808_weight_0_r_1 INV2 $PINS O=FE_OFN1296_weight_0_r_1
+ I=FE_DBTN47_weight_0_r_1
XFE_OFC1807_weight_0_r_1 INV2 $PINS O=FE_DBTN47_weight_0_r_1 I=weight_0_r[1]
XFE_OFC1806_n4596 BUF2 $PINS O=FE_OFN1693_n4596 I=FE_OFN1605_n4596
XFE_OFC1805_n4596 INV1S $PINS O=FE_OFN1606_n4596 I=FE_OFN1604_n4596
XFE_OFC1803_n4596 INV2 $PINS O=FE_OFN1605_n4596 I=FE_OFN1604_n4596
XFE_OFC1802_n4596 INV2 $PINS O=FE_OFN1604_n4596 I=n4596
XFE_OFC1801_n4047 BUF2 $PINS O=FE_OFN1692_n4047 I=n4047
XFE_OFC1800_n4047 BUF4CK $PINS O=FE_OFN1157_n4047 I=n4047
XFE_OFC1791_weight_1_r_23 INV2 $PINS O=FE_OFN1303_weight_1_r_23
+ I=weight_1_r[23]
XFE_OFC1790_weight_1_r_23 INV1S $PINS O=FE_OFN1302_weight_1_r_23
+ I=weight_1_r[23]
XFE_OFC1788_weight_2_r_1 BUF2 $PINS O=FE_OFN1408_weight_2_r_1 I=n3716
XFE_OFC1787_weight_2_r_1 INV2 $PINS O=n3716 I=FE_OFN1409_weight_2_r_1
XFE_OFC1786_weight_2_r_1 BUF1 $PINS O=FE_OFN1407_weight_2_r_1 I=weight_2_r[1]
XFE_OFC1785_weight_2_r_1 INV2 $PINS O=FE_OFN1409_weight_2_r_1 I=weight_2_r[1]
XFE_OFC1784_weight_2_r_19 INV2 $PINS O=FE_OFN1689_weight_2_r_19
+ I=FE_OFN1371_weight_2_r_19
XFE_OFC1783_weight_2_r_19 INV2 $PINS O=FE_OFN1462_n4128
+ I=FE_OFN1371_weight_2_r_19
XFE_OFC1781_weight_2_r_19 INV1S $PINS O=FE_OFN1372_weight_2_r_19
+ I=FE_OFN1371_weight_2_r_19
XFE_OFC1780_weight_2_r_19 INV3 $PINS O=FE_OFN1371_weight_2_r_19
+ I=weight_2_r[19]
XFE_OFC1779_n5608 INV1S $PINS O=FE_OFN1688_n5608 I=FE_OFN1520_n5608
XFE_OFC1778_n5608 INV2 $PINS O=FE_OFN1520_n5608 I=FE_OFN1517_n5608
XFE_OFC1777_n5608 INV1S $PINS O=FE_OFN1519_n5608 I=FE_OFN1517_n5608
XFE_OFC1776_n5608 INV2 $PINS O=n5628 I=FE_OFN1517_n5608
XFE_OFC1775_n5608 INV1S $PINS O=FE_OFN1518_n5608 I=FE_OFN1517_n5608
XFE_OFC1774_n5608 INV2 $PINS O=FE_OFN1517_n5608 I=n5608
XFE_OFC1773_n6225 BUF2 $PINS O=FE_OFN1568_FE_DBTN31_n6225 I=FE_DBTN31_n6225
XFE_OFC1772_n6225 BUF3 $PINS O=FE_OFN1567_FE_DBTN31_n6225 I=FE_DBTN31_n6225
XFE_OFC1771_n6225 INV2 $PINS O=FE_DBTN31_n6225 I=n6225
XFE_OFC1762_n5496 INV2 $PINS O=FE_OFN1609_n5496 I=n5496
XFE_OFC1761_n3135 BUF1 $PINS O=FE_OFN1681_n3135 I=FE_OFN1590_n3135
XFE_OFC1760_n3135 INV1S $PINS O=FE_OFN1680_n3135 I=FE_OFN1589_n3135
XFE_OFC1759_n3135 INV2 $PINS O=FE_OFN1679_n3135 I=FE_OFN1589_n3135
XFE_OFC1758_n3135 INV2 $PINS O=FE_OFN1590_n3135 I=FE_OFN1589_n3135
XFE_OFC1757_n3135 INV3 $PINS O=FE_OFN1589_n3135 I=n3135
XFE_OFC1756_n7036 INV1S $PINS O=FE_OFN1678_n7036 I=FE_OFN1675_n7036
XFE_OFC1755_n7036 INV2 $PINS O=FE_OFN1677_n7036 I=FE_OFN1675_n7036
XFE_OFC1754_n7036 INV1S $PINS O=FE_OFN1676_n7036 I=FE_OFN1540_n7036
XFE_OFC1753_n7036 INV1S $PINS O=FE_OFN1675_n7036 I=FE_OFN1540_n7036
XFE_OFC1751_n7036 INV1S $PINS O=n7069 I=FE_OFN1540_n7036
XFE_OFC1750_n7036 INV1S $PINS O=FE_OFN1632_n7069 I=FE_OFN1540_n7036
XFE_OFC1749_n7036 INV2 $PINS O=FE_OFN1540_n7036 I=n7036
XFE_OFC1748_n4077 BUF2 $PINS O=FE_OFN1673_n4077 I=FE_OFN1672_n4077
XFE_OFC1747_n4077 INV2 $PINS O=FE_OFN1672_n4077 I=FE_OFN1600_n4077
XFE_OFC1746_n4077 INV1S $PINS O=FE_OFN1671_n4077 I=FE_OFN1600_n4077
XFE_OFC1744_n4077 INV2 $PINS O=FE_OFN1600_n4077 I=n4077
XFE_OFC1742_n5855 INV2 $PINS O=FE_OFN1669_n5855 I=FE_OFN1614_n5855
XFE_OFC1741_n5855 INV3 $PINS O=FE_OFN1668_n5855 I=FE_OFN1614_n5855
XFE_OFC1740_n5855 INV3CK $PINS O=FE_OFN1614_n5855 I=n5855
XFE_OFC1738_n4591 INV1S $PINS O=FE_OFN1667_n4591 I=FE_OFN1666_n4591
XFE_OFC1737_n4591 INV2 $PINS O=FE_OFN1666_n4591 I=FE_OFN1478_n4591
XFE_OFC1736_n4591 INV1S $PINS O=n4503 I=FE_OFN1478_n4591
XFE_OFC1735_n4591 INV2 $PINS O=FE_OFN1477_n4591 I=FE_OFN1478_n4591
XFE_OFC1734_n4591 INV1S $PINS O=FE_OFN1476_n4591 I=FE_OFN1478_n4591
XFE_OFC1733_n4591 INV1S $PINS O=FE_OFN1475_n4591 I=FE_OFN1478_n4591
XFE_OFC1732_n4591 INV2 $PINS O=FE_OFN1478_n4591 I=n4591
XFE_OFC1731_data_1_r_19 INV1S $PINS O=FE_OFN1359_data_1_r_19 I=n3927
XFE_OFC1730_data_1_r_19 BUF1 $PINS O=n3927 I=data_1_r[19]
XFE_OFC1729_n5980 INV1S $PINS O=FE_OFN1665_n5980 I=FE_OFN1615_n5980
XFE_OFC1728_n5980 INV1S $PINS O=FE_OFN1664_n5980 I=FE_OFN1615_n5980
XFE_OFC1727_n5980 INV2 $PINS O=FE_OFN1663_n5980 I=FE_OFN1615_n5980
XFE_OFC1726_n5980 INV1S $PINS O=FE_OFN1662_n5980 I=FE_OFN1615_n5980
XFE_OFC1725_n5980 INV2 $PINS O=FE_OFN1615_n5980 I=n5980
XFE_OFC1719_weight_2_r_9 INV1S $PINS O=FE_OFN1394_weight_2_r_9
+ I=FE_OFN1393_weight_2_r_9
XFE_OFC1718_weight_2_r_9 INV3 $PINS O=FE_OFN1393_weight_2_r_9 I=weight_2_r[9]
XFE_OFC1717_n4594 INV1S $PINS O=n4597 I=n4594
XFE_OFC1716_n4331 BUF1 $PINS O=FE_OFN1659_n4331 I=n4331
XFE_OFC1715_n4331 BUF1 $PINS O=FE_OFN1603_n4331 I=n4331
XFE_OFC1714_n4307 INV1S $PINS O=n4308 I=n4307
XFE_OFC1712_n1875 BUF1 $PINS O=FE_OFN1447_n1875 I=n1875
XFE_OFC1711_n1875 INV2 $PINS O=FE_DBTN48_n1875 I=n1875
XFE_OFC1710_n7045 INV1S $PINS O=FE_OFN1658_n7045 I=FE_OFN1541_n7045
XFE_OFC1709_n7045 BUF1 $PINS O=n5564 I=n7045
XFE_OFC1708_n7045 BUF2 $PINS O=FE_OFN1541_n7045 I=n7045
XFE_OFC1703_data_1_r_1 INV1S $PINS O=FE_DBTN49_data_1_r_1 I=data_1_r[1]
XFE_OFC1702_data_1_r_1 INV1S $PINS O=FE_OFN1360_data_1_r_1 I=data_1_r[1]
XFE_OFC1701_data_1_r_1 BUF1 $PINS O=FE_OFN1425_FE_DBTN49_data_1_r_1
+ I=data_1_r[1]
XFE_OFC1700_n6309 BUF6CK $PINS O=FE_OFN1240_n6309 I=n6309
XFE_OFC1694_n5640 INV1S $PINS O=FE_OFN1655_n5640 I=FE_OFN1523_n5640
XFE_OFC1693_n5640 INV1S $PINS O=FE_OFN1523_n5640 I=FE_OFN1524_n5640
XFE_OFC1692_n5640 INV1S $PINS O=FE_OFN1522_n5640 I=FE_OFN1524_n5640
XFE_OFC1690_n5640 INV2 $PINS O=n5663 I=FE_OFN1524_n5640
XFE_OFC1689_n5640 INV1S $PINS O=FE_OFN1524_n5640 I=n5640
XFE_OFC1688_n3599 INV2 $PINS O=FE_OFN1654_n3599 I=FE_OFN1595_n3599
XFE_OFC1687_n3599 INV2 $PINS O=FE_OFN1594_n3599 I=FE_OFN1595_n3599
XFE_OFC1686_n3599 INV2 $PINS O=FE_OFN1593_n3599 I=FE_OFN1595_n3599
XFE_OFC1685_n3599 INV2 $PINS O=FE_OFN1592_n3599 I=FE_OFN1595_n3599
XFE_OFC1684_n3599 INV4 $PINS O=FE_OFN1595_n3599 I=n3599
XFE_OFC1683_n6819 BUF2 $PINS O=FE_OFN1577_FE_DBTN17_n6819 I=FE_DBTN17_n6819
XFE_OFC1682_n6819 BUF2 $PINS O=FE_OFN1576_FE_DBTN17_n6819 I=FE_DBTN17_n6819
XFE_OFC1681_n6819 INV2 $PINS O=FE_DBTN17_n6819 I=n6819
XFE_OFC1680_n2894 BUF6 $PINS O=FE_OFN1156_n2894 I=n3389
XFE_OFC1674_weight_1_r_16 BUF1 $PINS O=FE_DBTN2_weight_1_r_16
+ I=FE_OFN1315_weight_1_r_16
XFE_OFC1673_weight_1_r_16 INV1S $PINS O=FE_OFN1315_weight_1_r_16
+ I=FE_OFN1316_weight_1_r_16
XFE_OFC1672_weight_1_r_16 INV2 $PINS O=FE_OFN1316_weight_1_r_16
+ I=weight_1_r[16]
XFE_OFC1671_n4306 INV1S $PINS O=FE_OFN1653_n4306 I=FE_OFN1468_n4306
XFE_OFC1670_n4306 INV1S $PINS O=FE_OFN1470_n4306 I=FE_OFN1469_n4306
XFE_OFC1669_n4306 INV1S $PINS O=FE_OFN1468_n4306 I=FE_OFN1469_n4306
XFE_OFC1668_n4306 INV1S $PINS O=FE_OFN1467_n4306 I=FE_OFN1469_n4306
XFE_OFC1667_n4306 INV2 $PINS O=n4152 I=FE_OFN1469_n4306
XFE_OFC1666_n4306 INV2 $PINS O=FE_OFN1469_n4306 I=n4306
XFE_OFC1663_n3162 INV1S $PINS O=FE_OFN1650_n3162 I=FE_OFN1651_n3162
XFE_OFC1659_n9216 BUF1 $PINS O=FE_OFN1638_n9221 I=FE_OFN1639_n9221
XFE_OFC1658_n9216 INV1S $PINS O=FE_OFN1637_n9221 I=n9216
XFE_OFC1657_n9216 INV2 $PINS O=n9221 I=n9216
XFE_OFC1656_n9216 INV1S $PINS O=FE_OFN1639_n9221 I=n9216
XFE_OFC1653_n9466 INV1S $PINS O=FE_OFN1647_n9466 I=FE_OFN1642_n9466
XFE_OFC1649_n9466 INV3CK $PINS O=FE_OFN1642_n9466 I=n9466
XFE_OFC1648_n9466 BUF1 $PINS O=n2891 I=n9466
XFE_OFC1647_n3378 INV2 $PINS O=FE_OFN1128_FE_DBTN39_n3378 I=n3378
XFE_OFC1646_n3378 INV2 $PINS O=FE_DBTN39_n3378 I=n3378
XFE_OFC1645_n3378 INV2 $PINS O=FE_OFN1129_FE_DBTN39_n3378 I=n3378
XFE_OFC1633_n7070 BUF3 $PINS O=FE_OFN1633_n7070 I=n7070
XFE_OFC1631_n6658 BUF2 $PINS O=FE_OFN1631_n6658 I=FE_OFN1630_n6658
XFE_OFC1630_n6658 BUF2 $PINS O=FE_OFN1630_n6658 I=n6658
XFE_OFC1625_n6531 INV2 $PINS O=FE_OFN1625_n6531 I=n6531
XFE_OFC1621_n6448 INV4 $PINS O=FE_OFN1621_n6448 I=FE_OFN1620_n6448
XFE_OFC1620_n6448 BUF6 $PINS O=FE_OFN1620_n6448 I=n6448
XFE_OFC1619_n6414 BUF1 $PINS O=FE_OFN1619_n6414 I=n6414
XFE_OFC1618_n6138 BUF3 $PINS O=FE_OFN1618_n6138 I=FE_OFN1617_n6138
XFE_OFC1617_n6138 BUF6 $PINS O=FE_OFN1617_n6138 I=n6138
XFE_OFC1613_n5691 BUF2 $PINS O=FE_OFN1613_n5691 I=FE_OFN1611_n5691
XFE_OFC1612_n5691 INV2 $PINS O=FE_OFN1612_n5691 I=FE_OFN1610_n5691
XFE_OFC1611_n5691 INV2 $PINS O=FE_OFN1611_n5691 I=FE_OFN1610_n5691
XFE_OFC1610_n5691 INV2 $PINS O=FE_OFN1610_n5691 I=n5691
XFE_OFC1608_n4622 BUF1 $PINS O=FE_OFN1608_n4622 I=n4622
XFE_OFC1602_n4195 BUF2 $PINS O=FE_OFN1602_n4195 I=FE_OFN1601_n4195
XFE_OFC1601_n4195 BUF1 $PINS O=FE_OFN1601_n4195 I=n4195
XFE_OFC1598_n4076 BUF2 $PINS O=FE_OFN1598_n4076 I=n4076
XFE_OFC1597_n3897 BUF1 $PINS O=FE_OFN1597_n3897 I=n3897
XFE_OFC1596_n3897 BUF2 $PINS O=FE_OFN1596_n3897 I=n3897
XFE_OFC1587_n1873 BUF2 $PINS O=FE_OFN1587_n1873 I=FE_OFN1586_n1873
XFE_OFC1586_n1873 BUF2 $PINS O=FE_OFN1586_n1873 I=n1873
XFE_OFC1584_FE_DBTN6_n7135 INV1S $PINS O=FE_OFN1584_FE_DBTN6_n7135
+ I=FE_OFN1582_FE_DBTN6_n7135
XFE_OFC1583_FE_DBTN6_n7135 INV2 $PINS O=FE_OFN1583_FE_DBTN6_n7135
+ I=FE_OFN1582_FE_DBTN6_n7135
XFE_OFC1570_FE_DBTN22_n3850 BUF6 $PINS O=FE_OFN1570_FE_DBTN22_n3850
+ I=FE_DBTN22_n3850
XFE_OFC1566_FE_DBTN36_n9707 INV1S $PINS O=FE_OFN1566_FE_DBTN36_n9707
+ I=FE_OFN1563_FE_DBTN36_n9707
XFE_OFC1565_FE_DBTN36_n9707 INV2 $PINS O=FE_OFN1565_FE_DBTN36_n9707
+ I=FE_OFN1563_FE_DBTN36_n9707
XFE_OFC1564_FE_DBTN36_n9707 INV2 $PINS O=FE_OFN1564_FE_DBTN36_n9707
+ I=FE_OFN1563_FE_DBTN36_n9707
XFE_OFC1563_FE_DBTN36_n9707 INV2 $PINS O=FE_OFN1563_FE_DBTN36_n9707
+ I=FE_DBTN36_n9707
XFE_OFC1559_FE_DBTN41_n4329 BUF2 $PINS O=FE_OFN1559_FE_DBTN41_n4329
+ I=FE_DBTN41_n4329
XFE_OFC1558_FE_DBTN42_n3886 BUF2 $PINS O=FE_OFN1558_FE_DBTN42_n3886
+ I=FE_OFN1556_FE_DBTN42_n3886
XFE_OFC1557_FE_DBTN42_n3886 INV1S $PINS O=FE_OFN1557_FE_DBTN42_n3886
+ I=FE_OFN1555_FE_DBTN42_n3886
XFE_OFC1556_FE_DBTN42_n3886 INV2 $PINS O=FE_OFN1556_FE_DBTN42_n3886
+ I=FE_OFN1555_FE_DBTN42_n3886
XFE_OFC1555_FE_DBTN42_n3886 INV2 $PINS O=FE_OFN1555_FE_DBTN42_n3886
+ I=FE_DBTN42_n3886
XFE_OFC1554_n9713 INV1S $PINS O=FE_OFN1554_n9713 I=FE_OFN1552_n9713
XFE_OFC1553_n9713 INV2 $PINS O=FE_OFN1553_n9713 I=FE_OFN1552_n9713
XFE_OFC1552_n9713 INV2 $PINS O=FE_OFN1552_n9713 I=n9713
XFE_OFC1551_n9711 BUF3CK $PINS O=FE_OFN1551_n9711 I=n9711
XFE_OFC1548_n9433 BUF1CK $PINS O=FE_OFN1548_n9433 I=n9433
XFE_OFC1547_n9120 BUF2 $PINS O=FE_OFN1547_n9120 I=n9120
XFE_OFC1546_n8995 BUF1CK $PINS O=FE_OFN1546_n8995 I=n8995
XFE_OFC1545_n7188 BUF1 $PINS O=FE_OFN1545_n7188 I=n9465
XFE_OFC1544_n7067 BUF1 $PINS O=FE_OFN1544_n7067 I=FE_OFN1543_n7067
XFE_OFC1543_n7067 BUF1 $PINS O=FE_OFN1543_n7067 I=n7067
XFE_OFC1542_n7067 BUF1 $PINS O=FE_OFN1542_n7067 I=n7067
XFE_OFC1539_n6937 BUF1 $PINS O=FE_OFN1539_n6937 I=n6937
XFE_OFC1532_n6412 BUF1 $PINS O=FE_OFN1532_n6412 I=n6412
XFE_OFC1531_n6191 BUF2 $PINS O=FE_OFN1531_n6191 I=n6191
XFE_OFC1530_n6178 BUF2 $PINS O=FE_OFN1530_n6178 I=n6178
XFE_OFC1529_n6086 INV1S $PINS O=FE_OFN1529_n6086 I=FE_OFN1527_n6086
XFE_OFC1528_n6086 INV1S $PINS O=FE_OFN1528_n6086 I=FE_OFN1527_n6086
XFE_OFC1527_n6086 INV1S $PINS O=FE_OFN1527_n6086 I=n6086
XFE_OFC1526_n5853 BUF1 $PINS O=FE_OFN1526_n5853 I=FE_DBTN37_n5853
XFE_OFC1513_n5424 BUF6 $PINS O=FE_OFN1513_n5424 I=FE_OFN1511_n5424
XFE_OFC1512_n5424 BUF6CK $PINS O=FE_OFN1512_n5424 I=FE_OFN1510_n5424
XFE_OFC1511_n5424 INV2 $PINS O=FE_OFN1511_n5424 I=FE_OFN1509_n5424
XFE_OFC1510_n5424 INV4 $PINS O=FE_OFN1510_n5424 I=FE_OFN1509_n5424
XFE_OFC1509_n5424 INV4 $PINS O=FE_OFN1509_n5424 I=FE_OFN1507_n5424
XFE_OFC1508_n5424 BUF4CK $PINS O=FE_OFN1508_n5424 I=FE_OFN1505_n5424
XFE_OFC1507_n5424 BUF6CK $PINS O=FE_OFN1507_n5424 I=FE_OFN1499_n5424
XFE_OFC1506_n5424 BUF4CK $PINS O=FE_OFN1506_n5424 I=FE_OFN1503_n5424
XFE_OFC1505_n5424 BUF2 $PINS O=FE_OFN1505_n5424 I=FE_OFN1502_n5424
XFE_OFC1503_n5424 BUF6 $PINS O=FE_OFN1503_n5424 I=FE_OFN1497_n5424
XFE_OFC1502_n5424 INV2 $PINS O=FE_OFN1502_n5424 I=FE_OFN1496_n5424
XFE_OFC1501_n5424 INV1S $PINS O=FE_OFN1501_n5424 I=FE_OFN1496_n5424
XFE_OFC1500_n5424 BUF1 $PINS O=FE_OFN1500_n5424 I=FE_OFN1494_n5424
XFE_OFC1499_n5424 BUF6 $PINS O=FE_OFN1499_n5424 I=FE_OFN1494_n5424
XFE_OFC1498_n5424 BUF2 $PINS O=FE_OFN1498_n5424 I=FE_OFN1493_n5424
XFE_OFC1497_n5424 BUF6 $PINS O=FE_OFN1497_n5424 I=FE_OFN1492_n5424
XFE_OFC1496_n5424 INV2 $PINS O=FE_OFN1496_n5424 I=FE_OFN1491_n5424
XFE_OFC1495_n5424 BUF1CK $PINS O=FE_OFN1495_n5424 I=FE_OFN1491_n5424
XFE_OFC1494_n5424 BUF6 $PINS O=FE_OFN1494_n5424 I=FE_OFN1490_n5424
XFE_OFC1493_n5424 INV1S $PINS O=FE_OFN1493_n5424 I=FE_OFN1488_n5424
XFE_OFC1492_n5424 INV4 $PINS O=FE_OFN1492_n5424 I=FE_OFN1488_n5424
XFE_OFC1491_n5424 BUF2 $PINS O=FE_OFN1491_n5424 I=FE_OFN1487_n5424
XFE_OFC1490_n5424 BUF8CK $PINS O=FE_OFN1490_n5424 I=FE_OFN1486_n5424
XFE_OFC1489_n5424 BUF1 $PINS O=FE_OFN1489_n5424 I=FE_OFN1486_n5424
XFE_OFC1488_n5424 INV3 $PINS O=FE_OFN1488_n5424 I=FE_OFN1485_n5424
XFE_OFC1487_n5424 INV1S $PINS O=FE_OFN1487_n5424 I=FE_OFN1483_n5424
XFE_OFC1486_n5424 INV3 $PINS O=FE_OFN1486_n5424 I=FE_OFN1483_n5424
XFE_OFC1485_n5424 BUF6CK $PINS O=FE_OFN1485_n5424 I=FE_OFN1482_n5424
XFE_OFC1484_n5424 BUF1 $PINS O=FE_OFN1484_n5424 I=FE_OFN1482_n5424
XFE_OFC1483_n5424 INV4 $PINS O=FE_OFN1483_n5424 I=FE_RN_2
XFE_OFC1482_n5424 BUF3 $PINS O=FE_OFN1482_n5424 I=n5424
XFE_OFC1480_n4623 BUF1 $PINS O=FE_OFN1480_n4623 I=FE_OFN1479_n4623
XFE_OFC1479_n4623 BUF2 $PINS O=FE_OFN1479_n4623 I=n4623
XFE_OFC1474_n4495 BUF1 $PINS O=FE_OFN1474_n4495 I=n4495
XFE_OFC1473_n4404 BUF1S $PINS O=FE_OFN1473_n4404 I=n4404
XFE_OFC1472_n4404 BUF6 $PINS O=FE_OFN1472_n4404 I=n4404
XFE_OFC1471_n4329 BUF1 $PINS O=FE_OFN1471_n4329 I=n4329
XFE_OFC1466_n4128 BUF1 $PINS O=FE_OFN1466_n4128 I=FE_OFN1465_n4128
XFE_OFC1465_n4128 INV2 $PINS O=FE_OFN1465_n4128 I=FE_OFN1689_weight_2_r_19
XFE_OFC1463_n4128 INV2 $PINS O=FE_OFN1463_n4128 I=FE_OFN1689_weight_2_r_19
XFE_OFC1461_n3961 BUF2 $PINS O=FE_OFN1461_n3961 I=FE_OCPN9723_n3961
XFE_OFC1460_n3961 BUF1 $PINS O=FE_OFN1460_n3961 I=n3961
XFE_OFC1456_n2771 BUF1CK $PINS O=FE_OFN1456_n2771 I=n2771
XFE_OFC1455_n2727 INV1S $PINS O=FE_OFN1455_n2727 I=FE_OFN1453_n2727
XFE_OFC1454_n2727 INV2 $PINS O=FE_OFN1454_n2727 I=FE_OFN1453_n2727
XFE_OFC1453_n2727 INV2 $PINS O=FE_OFN1453_n2727 I=n2727
XFE_OFC1452_n2589 BUF1 $PINS O=FE_OFN1452_n2589 I=FE_OFN1451_n2589
XFE_OFC1451_n2589 BUF2 $PINS O=FE_OFN1451_n2589 I=n2589
XFE_OFC1450_n2480 BUF1S $PINS O=FE_OFN1450_n2480 I=n2480
XFE_OFC1446_FE_DBTN0_weight_0_r_7 BUF2 $PINS O=FE_OFN1446_FE_DBTN0_weight_0_r_7
+ I=FE_DBTN0_weight_0_r_7
XFE_OFC1444_FE_DBTN7_n4532 BUF2 $PINS O=FE_OFN1444_FE_DBTN7_n4532
+ I=FE_OFN1443_FE_DBTN7_n4532
XFE_OFC1443_FE_DBTN7_n4532 BUF2 $PINS O=FE_OFN1443_FE_DBTN7_n4532
+ I=FE_DBTN7_n4532
XFE_OFC1442_FE_DBTN9_n3607 BUF2 $PINS O=FE_OFN1442_FE_DBTN9_n3607
+ I=FE_OFN1441_FE_DBTN9_n3607
XFE_OFC1441_FE_DBTN9_n3607 BUF1 $PINS O=FE_OFN1441_FE_DBTN9_n3607
+ I=FE_DBTN9_n3607
XFE_OFC1440_FE_DBTN12_weight_2_r_7 BUF1 $PINS
+ O=FE_OFN1440_FE_DBTN12_weight_2_r_7 I=FE_DBTN12_weight_2_r_7
XFE_OFC1439_FE_DBTN16_n5612 INV2 $PINS O=FE_OFN1439_FE_DBTN16_n5612
+ I=FE_OFN1437_FE_DBTN16_n5612
XFE_OFC1438_FE_DBTN16_n5612 INV1S $PINS O=FE_OFN1438_FE_DBTN16_n5612
+ I=FE_OFN1437_FE_DBTN16_n5612
XFE_OFC1437_FE_DBTN16_n5612 INV2 $PINS O=FE_OFN1437_FE_DBTN16_n5612
+ I=FE_DBTN16_n5612
XFE_OFC1436_FE_DBTN18_n6407 BUF1 $PINS O=FE_OFN1436_FE_DBTN18_n6407
+ I=FE_DBTN18_n6407
XFE_OFC1435_FE_DBTN18_n6407 BUF1 $PINS O=FE_OFN1435_FE_DBTN18_n6407
+ I=FE_DBTN18_n6407
XFE_OFC1434_FE_DBTN19_n4371 BUF4CK $PINS O=FE_OFN1434_FE_DBTN19_n4371
+ I=FE_OFN1433_FE_DBTN19_n4371
XFE_OFC1433_FE_DBTN19_n4371 BUF2 $PINS O=FE_OFN1433_FE_DBTN19_n4371
+ I=FE_DBTN19_n4371
XFE_OFC1432_FE_DBTN23_weight_0_r_23 BUF3 $PINS
+ O=FE_OFN1432_FE_DBTN23_weight_0_r_23 I=FE_DBTN23_weight_0_r_23
XFE_OFC1431_FE_DBTN26_weight_1_r_15 BUF4CK $PINS
+ O=FE_OFN1431_FE_DBTN26_weight_1_r_15 I=FE_DBTN26_weight_1_r_15
XFE_OFC1430_FE_DBTN28_weight_0_r_15 BUF2 $PINS
+ O=FE_OFN1430_FE_DBTN28_weight_0_r_15 I=FE_DBTN28_weight_0_r_15
XFE_OFC1428_FE_DBTN34_weight_0_r_11 BUF3 $PINS
+ O=FE_OFN1428_FE_DBTN34_weight_0_r_11 I=FE_DBTN34_weight_0_r_11
XFE_OFC1414_data_2_r_17 BUF1CK $PINS O=FE_OFN1414_data_2_r_17 I=data_2_r[17]
XFE_OFC1413_weight_2_r_0 INV1S $PINS O=FE_OFN1413_weight_2_r_0
+ I=FE_OFN1411_weight_2_r_0
XFE_OFC1412_weight_2_r_0 INV1S $PINS O=FE_OFN1412_weight_2_r_0
+ I=FE_OFN1411_weight_2_r_0
XFE_OFC1411_weight_2_r_0 INV1S $PINS O=FE_OFN1411_weight_2_r_0
+ I=FE_OFN1410_weight_2_r_0
XFE_OFC1410_weight_2_r_0 BUF1 $PINS O=FE_OFN1410_weight_2_r_0 I=weight_2_r[0]
XFE_OFC1406_weight_2_r_3 BUF2 $PINS O=FE_OFN1406_weight_2_r_3
+ I=FE_OFN1404_weight_2_r_3
XFE_OFC1405_weight_2_r_3 BUF1 $PINS O=FE_OFN1405_weight_2_r_3 I=weight_2_r[3]
XFE_OFC1404_weight_2_r_3 BUF3 $PINS O=FE_OFN1404_weight_2_r_3 I=weight_2_r[3]
XFE_OFC1402_weight_2_r_5 BUF1 $PINS O=FE_OFN1402_weight_2_r_5 I=weight_2_r[5]
XFE_OFC1400_weight_2_r_7 BUF6 $PINS O=FE_OFN1400_weight_2_r_7
+ I=FE_OFN1398_weight_2_r_7
XFE_OFC1399_weight_2_r_7 BUF1S $PINS O=FE_OFN1399_weight_2_r_7 I=weight_2_r[7]
XFE_OFC1398_weight_2_r_7 BUF2 $PINS O=FE_OFN1398_weight_2_r_7 I=weight_2_r[7]
XFE_OFC1397_weight_2_r_8 BUF1 $PINS O=FE_OFN1397_weight_2_r_8
+ I=FE_OFN1396_weight_2_r_8
XFE_OFC1396_weight_2_r_8 BUF1 $PINS O=FE_OFN1396_weight_2_r_8 I=weight_2_r[8]
XFE_OFC1388_weight_2_r_13 INV1S $PINS O=FE_OFN1388_weight_2_r_13
+ I=FE_OFN1386_weight_2_r_13
XFE_OFC1387_weight_2_r_13 INV1S $PINS O=FE_OFN1387_weight_2_r_13
+ I=FE_OFN1386_weight_2_r_13
XFE_OFC1386_weight_2_r_13 INV1S $PINS O=FE_OFN1386_weight_2_r_13
+ I=weight_2_r[13]
XFE_OFC1382_weight_2_r_15 INV1S $PINS O=FE_OFN1382_weight_2_r_15
+ I=FE_OFN1383_weight_2_r_15
XFE_OFC1378_weight_2_r_16 BUF1 $PINS O=FE_OFN1378_weight_2_r_16
+ I=FE_OFN1377_weight_2_r_16
XFE_OFC1377_weight_2_r_16 BUF1 $PINS O=FE_OFN1377_weight_2_r_16
+ I=weight_2_r[16]
XFE_OFC1370_weight_2_r_21 BUF6 $PINS O=FE_OFN1370_weight_2_r_21
+ I=FE_OFN1369_weight_2_r_21
XFE_OFC1369_weight_2_r_21 BUF8CK $PINS O=FE_OFN1369_weight_2_r_21
+ I=FE_OFN1367_weight_2_r_21
XFE_OFC1368_weight_2_r_21 BUF1 $PINS O=FE_OFN1368_weight_2_r_21
+ I=weight_2_r[21]
XFE_OFC1367_weight_2_r_21 BUF6 $PINS O=FE_OFN1367_weight_2_r_21
+ I=weight_2_r[21]
XFE_OFC1366_weight_2_r_23 INV1S $PINS O=FE_OFN1366_weight_2_r_23
+ I=FE_OFN1535_n6821
XFE_OFC1364_weight_2_r_23 INV1S $PINS O=FE_OFN1364_weight_2_r_23
+ I=FE_OFN1535_n6821
XFE_OFC1358_data_1_r_33 BUF1 $PINS O=FE_OFN1358_data_1_r_33 I=data_1_r[33]
XFE_OFC1357_weight_1_r_0 BUF1 $PINS O=FE_OFN1357_weight_1_r_0
+ I=FE_OFN1356_weight_1_r_0
XFE_OFC1356_weight_1_r_0 BUF1 $PINS O=FE_OFN1356_weight_1_r_0 I=weight_1_r[0]
XFE_OFC1355_weight_1_r_1 BUF1 $PINS O=FE_OFN1355_weight_1_r_1
+ I=FE_OFN1353_weight_1_r_1
XFE_OFC1354_weight_1_r_1 INV1S $PINS O=FE_OFN1354_weight_1_r_1
+ I=FE_OFN1352_weight_1_r_1
XFE_OFC1353_weight_1_r_1 INV1S $PINS O=FE_OFN1353_weight_1_r_1
+ I=FE_OFN1352_weight_1_r_1
XFE_OFC1352_weight_1_r_1 INV1S $PINS O=FE_OFN1352_weight_1_r_1 I=weight_1_r[1]
XFE_OFC1351_weight_1_r_1 BUF2 $PINS O=FE_OFN1351_weight_1_r_1 I=weight_1_r[1]
XFE_OFC1346_weight_1_r_5 BUF2 $PINS O=FE_OFN1346_weight_1_r_5
+ I=FE_OFN1345_weight_1_r_5
XFE_OFC1345_weight_1_r_5 BUF1 $PINS O=FE_OFN1345_weight_1_r_5
+ I=FE_OFN1344_weight_1_r_5
XFE_OFC1344_weight_1_r_5 BUF2 $PINS O=FE_OFN1344_weight_1_r_5 I=weight_1_r[5]
XFE_OFC1343_weight_1_r_5 BUF4CK $PINS O=FE_OFN1343_weight_1_r_5 I=weight_1_r[5]
XFE_OFC1340_weight_1_r_7 INV2 $PINS O=FE_OFN1340_weight_1_r_7
+ I=FE_OFN1429_FE_DBTN32_weight_1_r_7
XFE_OFC1339_weight_1_r_7 INV2 $PINS O=FE_OFN1339_weight_1_r_7 I=weight_1_r[7]
XFE_OFC1338_weight_1_r_8 BUF1 $PINS O=FE_OFN1338_weight_1_r_8
+ I=FE_OFN1337_weight_1_r_8
XFE_OFC1336_weight_1_r_9 INV1CK $PINS O=FE_OFN1336_weight_1_r_9
+ I=FE_OFN1334_weight_1_r_9
XFE_OFC1335_weight_1_r_9 INV1S $PINS O=FE_OFN1335_weight_1_r_9
+ I=FE_OFN1334_weight_1_r_9
XFE_OFC1334_weight_1_r_9 INV1S $PINS O=FE_OFN1334_weight_1_r_9
+ I=FE_OFN1333_weight_1_r_9
XFE_OFC1333_weight_1_r_9 BUF4CK $PINS O=FE_OFN1333_weight_1_r_9
+ I=FE_OFN1331_weight_1_r_9
XFE_OFC1332_weight_1_r_9 INV2CK $PINS O=FE_OFN1332_weight_1_r_9
+ I=FE_OFN1330_weight_1_r_9
XFE_OFC1331_weight_1_r_9 INV4 $PINS O=FE_OFN1331_weight_1_r_9
+ I=FE_OFN1330_weight_1_r_9
XFE_OFC1330_weight_1_r_9 INV3 $PINS O=FE_OFN1330_weight_1_r_9 I=weight_1_r[9]
XFE_OFC1329_weight_1_r_11 BUF1 $PINS O=FE_OFN1329_weight_1_r_11
+ I=FE_OFN1328_weight_1_r_11
XFE_OFC1328_weight_1_r_11 BUF2 $PINS O=FE_OFN1328_weight_1_r_11
+ I=FE_OFN1426_FE_DBTN44_weight_1_r_11
XFE_OFC1326_weight_1_r_13 BUF1 $PINS O=FE_OFN1326_weight_1_r_13
+ I=FE_OFN1325_weight_1_r_13
XFE_OFC1325_weight_1_r_13 INV1S $PINS O=FE_OFN1325_weight_1_r_13
+ I=FE_OFN1322_weight_1_r_13
XFE_OFC1324_weight_1_r_13 INV1S $PINS O=FE_OFN1324_weight_1_r_13
+ I=FE_OFN1322_weight_1_r_13
XFE_OFC1323_weight_1_r_13 BUF4CK $PINS O=FE_OFN1323_weight_1_r_13
+ I=weight_1_r[13]
XFE_OFC1322_weight_1_r_13 INV1S $PINS O=FE_OFN1322_weight_1_r_13
+ I=weight_1_r[13]
XFE_OFC1321_weight_1_r_15 INV1S $PINS O=FE_OFN1321_weight_1_r_15
+ I=FE_OFN1318_weight_1_r_15
XFE_OFC1320_weight_1_r_15 INV2 $PINS O=FE_OFN1320_weight_1_r_15
+ I=FE_OFN1318_weight_1_r_15
XFE_OFC1319_weight_1_r_15 BUF1 $PINS O=FE_OFN1319_weight_1_r_15
+ I=FE_OFN1317_weight_1_r_15
XFE_OFC1318_weight_1_r_15 INV1S $PINS O=FE_OFN1318_weight_1_r_15
+ I=FE_OFN1317_weight_1_r_15
XFE_OFC1317_weight_1_r_15 BUF2 $PINS O=FE_OFN1317_weight_1_r_15
+ I=weight_1_r[15]
XFE_OFC1314_weight_1_r_17 BUF2 $PINS O=FE_OFN1314_weight_1_r_17
+ I=weight_1_r[17]
XFE_OFC1313_weight_1_r_17 BUF1 $PINS O=FE_OFN1313_weight_1_r_17
+ I=weight_1_r[17]
XFE_OFC1312_weight_1_r_19 BUF1S $PINS O=FE_OFN1312_weight_1_r_19
+ I=weight_1_r[19]
XFE_OFC1311_weight_1_r_19 BUF4CK $PINS O=FE_OFN1311_weight_1_r_19
+ I=weight_1_r[19]
XFE_OFC1310_weight_1_r_21 BUF4CK $PINS O=FE_OFN1310_weight_1_r_21
+ I=FE_OFN1308_weight_1_r_21
XFE_OFC1309_weight_1_r_21 BUF3 $PINS O=FE_OFN1309_weight_1_r_21
+ I=FE_OFN1308_weight_1_r_21
XFE_OFC1308_weight_1_r_21 BUF6 $PINS O=FE_OFN1308_weight_1_r_21
+ I=weight_1_r[21]
XFE_OFC1307_weight_1_r_23 INV2 $PINS O=FE_OFN1307_weight_1_r_23
+ I=FE_OFN1305_weight_1_r_23
XFE_OFC1306_weight_1_r_23 INV2 $PINS O=FE_OFN1306_weight_1_r_23
+ I=FE_OFN1305_weight_1_r_23
XFE_OFC1305_weight_1_r_23 INV2 $PINS O=FE_OFN1305_weight_1_r_23
+ I=FE_OFN1304_weight_1_r_23
XFE_OFC1304_weight_1_r_23 INV2 $PINS O=FE_OFN1304_weight_1_r_23
+ I=FE_OFN1303_weight_1_r_23
XFE_OFC1301_data_0_r_17 BUF2 $PINS O=FE_OFN1301_data_0_r_17 I=data_0_r[17]
XFE_OFC1300_weight_0_r_0 BUF1 $PINS O=FE_OFN1300_weight_0_r_0
+ I=FE_OFN1299_weight_0_r_0
XFE_OFC1299_weight_0_r_0 BUF1 $PINS O=FE_OFN1299_weight_0_r_0 I=weight_0_r[0]
XFE_OFC1295_weight_0_r_3 INV1S $PINS O=FE_OFN1295_weight_0_r_3
+ I=FE_OFN1293_weight_0_r_3
XFE_OFC1294_weight_0_r_3 INV1S $PINS O=FE_OFN1294_weight_0_r_3
+ I=FE_OFN1293_weight_0_r_3
XFE_OFC1293_weight_0_r_3 INV1S $PINS O=FE_OFN1293_weight_0_r_3
+ I=FE_OFN9128_weight_0_r_3
XFE_OFC1291_weight_0_r_5 BUF1 $PINS O=FE_OFN1291_weight_0_r_5
+ I=FE_OCPN9755_FE_OFN1289_weight_0_r_5
XFE_OFC1290_weight_0_r_5 BUF6 $PINS O=FE_OFN1290_weight_0_r_5
+ I=FE_OFN1288_weight_0_r_5
XFE_OFC1289_weight_0_r_5 INV1S $PINS O=FE_OFN1289_weight_0_r_5
+ I=FE_OFN1287_weight_0_r_5
XFE_OFC1288_weight_0_r_5 INV4 $PINS O=FE_OFN1288_weight_0_r_5
+ I=FE_OFN1287_weight_0_r_5
XFE_OFC1287_weight_0_r_5 INV4 $PINS O=FE_OFN1287_weight_0_r_5 I=weight_0_r[5]
XFE_OFC1286_weight_0_r_7 BUF1 $PINS O=FE_OFN1286_weight_0_r_7
+ I=FE_OFN1285_weight_0_r_7
XFE_OFC1285_weight_0_r_7 BUF2 $PINS O=FE_OFN1285_weight_0_r_7
+ I=FE_OFN1284_weight_0_r_7
XFE_OFC1284_weight_0_r_7 BUF2 $PINS O=FE_OFN1284_weight_0_r_7 I=weight_0_r[7]
XFE_OFC1283_weight_0_r_8 BUF1 $PINS O=FE_OFN1283_weight_0_r_8
+ I=FE_OFN1282_weight_0_r_8
XFE_OFC1282_weight_0_r_8 INV1S $PINS O=FE_OFN1282_weight_0_r_8
+ I=FE_OFN1280_weight_0_r_8
XFE_OFC1281_weight_0_r_8 INV1S $PINS O=FE_OFN1281_weight_0_r_8
+ I=FE_OFN1280_weight_0_r_8
XFE_OFC1280_weight_0_r_8 INV1S $PINS O=FE_OFN1280_weight_0_r_8 I=weight_0_r[8]
XFE_OFC1278_weight_0_r_9 BUF6 $PINS O=FE_OFN1278_weight_0_r_9
+ I=FE_OFN1277_weight_0_r_9
XFE_OFC1277_weight_0_r_9 BUF4CK $PINS O=FE_OFN1277_weight_0_r_9 I=weight_0_r[9]
XFE_OFC1276_weight_0_r_11 BUF1 $PINS O=FE_OFN1276_weight_0_r_11
+ I=FE_OFN1275_weight_0_r_11
XFE_OFC1275_weight_0_r_11 BUF8 $PINS O=FE_OFN1275_weight_0_r_11
+ I=FE_OFN1274_weight_0_r_11
XFE_OFC1274_weight_0_r_11 BUF6 $PINS O=FE_OFN1274_weight_0_r_11
+ I=weight_0_r[11]
XFE_OFC1273_weight_0_r_13 BUF1 $PINS O=FE_OFN1273_weight_0_r_13
+ I=FE_OFN1271_weight_0_r_13
XFE_OFC1269_weight_0_r_15 BUF1 $PINS O=FE_OFN1269_weight_0_r_15
+ I=FE_OFN1267_weight_0_r_15
XFE_OFC1268_weight_0_r_15 BUF1S $PINS O=FE_OFN1268_weight_0_r_15
+ I=weight_0_r[15]
XFE_OFC1267_weight_0_r_15 BUF3 $PINS O=FE_OFN1267_weight_0_r_15
+ I=weight_0_r[15]
XFE_OFC1266_weight_0_r_16 BUF2 $PINS O=FE_OFN1266_weight_0_r_16
+ I=FE_OFN1265_weight_0_r_16
XFE_OFC1265_weight_0_r_16 BUF2 $PINS O=FE_OFN1265_weight_0_r_16
+ I=weight_0_r[16]
XFE_OFC1264_weight_0_r_17 INV2 $PINS O=FE_OFN1264_weight_0_r_17
+ I=FE_OFN1262_weight_0_r_17
XFE_OFC1263_weight_0_r_17 INV1S $PINS O=FE_OFN1263_weight_0_r_17
+ I=FE_OFN1262_weight_0_r_17
XFE_OFC1262_weight_0_r_17 INV1S $PINS O=FE_OFN1262_weight_0_r_17
+ I=FE_OFN1261_weight_0_r_17
XFE_OFC1261_weight_0_r_17 BUF2 $PINS O=FE_OFN1261_weight_0_r_17
+ I=weight_0_r[17]
XFE_OFC1260_weight_0_r_19 INV1S $PINS O=FE_OFN1260_weight_0_r_19
+ I=FE_OFN1258_weight_0_r_19
XFE_OFC1259_weight_0_r_19 INV1S $PINS O=FE_OFN1259_weight_0_r_19
+ I=FE_OFN1258_weight_0_r_19
XFE_OFC1258_weight_0_r_19 INV1S $PINS O=FE_OFN1258_weight_0_r_19
+ I=FE_OFN1257_weight_0_r_19
XFE_OFC1257_weight_0_r_19 BUF1CK $PINS O=FE_OFN1257_weight_0_r_19
+ I=weight_0_r[19]
XFE_OFC1256_weight_0_r_19 BUF3 $PINS O=FE_OFN1256_weight_0_r_19
+ I=weight_0_r[19]
XFE_OFC1255_weight_0_r_21 BUF1 $PINS O=FE_OFN1255_weight_0_r_21
+ I=FE_OFN1253_weight_0_r_21
XFE_OFC1254_weight_0_r_21 BUF6 $PINS O=FE_OFN1254_weight_0_r_21
+ I=weight_0_r[21]
XFE_OFC1253_weight_0_r_21 BUF1CK $PINS O=FE_OFN1253_weight_0_r_21
+ I=weight_0_r[21]
XFE_OFC1252_weight_0_r_23 INV1S $PINS O=FE_OFN1252_weight_0_r_23
+ I=FE_OFN1250_weight_0_r_23
XFE_OFC1251_weight_0_r_23 INV2 $PINS O=FE_OFN1251_weight_0_r_23
+ I=FE_OFN1250_weight_0_r_23
XFE_OFC1250_weight_0_r_23 INV1S $PINS O=FE_OFN1250_weight_0_r_23
+ I=FE_OFN1249_weight_0_r_23
XFE_OFC1249_weight_0_r_23 BUF6 $PINS O=FE_OFN1249_weight_0_r_23
+ I=FE_OFN1248_weight_0_r_23
XFE_OFC1248_weight_0_r_23 BUF6 $PINS O=FE_OFN1248_weight_0_r_23
+ I=weight_0_r[23]
XFE_OFC1247_n9348 BUF1 $PINS O=FE_OFN1247_n9348 I=n9348
XFE_OFC1246_n8888 BUF1S $PINS O=FE_OFN1246_n8888 I=n8888
XFE_OFC1245_n7298 INV1S $PINS O=FE_OFN1245_n7298 I=FE_OFN1242_n7298
XFE_OFC1244_n7298 INV4 $PINS O=FE_OFN1244_n7298 I=FE_OFN1242_n7298
XFE_OFC1243_n7298 BUF1S $PINS O=FE_OFN1243_n7298 I=n7298
XFE_OFC1242_n7298 INV2 $PINS O=FE_OFN1242_n7298 I=n7298
XFE_OFC1241_n7179 BUF1CK $PINS O=FE_OFN1241_n7179 I=n7179
XFE_OFC1239_n5429 BUF2 $PINS O=FE_OFN1239_n5429 I=FE_OFN1237_n5429
XFE_OFC1238_n5429 BUF4CK $PINS O=FE_OFN1238_n5429 I=FE_OFN1236_n5429
XFE_OFC1237_n5429 INV2 $PINS O=FE_OFN1237_n5429 I=FE_OFN1235_n5429
XFE_OFC1236_n5429 INV2 $PINS O=FE_OFN1236_n5429 I=FE_OFN1235_n5429
XFE_OFC1235_n5429 INV3 $PINS O=FE_OFN1235_n5429 I=FE_OFN1234_n5429
XFE_OFC1234_n5429 BUF4CK $PINS O=FE_OFN1234_n5429 I=FE_OFN1229_n5429
XFE_OFC1231_n5429 BUF3CK $PINS O=FE_OFN1231_n5429 I=FE_OFN1228_n5429
XFE_OFC1228_n5429 BUF6CK $PINS O=FE_OFN1228_n5429 I=FE_OFN1226_n5429
XFE_OFC1226_n5429 INV2 $PINS O=FE_OFN1226_n5429 I=FE_OFN1222_n5429
XFE_OFC1225_n5429 INV1S $PINS O=FE_OFN1225_n5429 I=FE_OFN1222_n5429
XFE_OFC1224_n5429 INV1S $PINS O=FE_OFN1224_n5429 I=FE_OFN1223_n5429
XFE_OFC1222_n5429 INV3CK $PINS O=FE_OFN1222_n5429 I=FE_OFN1218_n5429
XFE_OFC1221_n5429 BUF1 $PINS O=FE_OFN1221_n5429 I=FE_OFN1218_n5429
XFE_OFC1219_n5429 BUF1 $PINS O=FE_OFN1219_n5429 I=FE_OFN1227_n5429
XFE_OFC1218_n5429 BUF2 $PINS O=FE_OFN1218_n5429 I=FE_OFN1215_n5429
XFE_OFC1217_n5429 BUF1S $PINS O=FE_OFN1217_n5429 I=FE_OFN1214_n5429
XFE_OFC1215_n5429 INV3 $PINS O=FE_OFN1215_n5429 I=FE_OFN1213_n5429
XFE_OFC1214_n5429 BUF1S $PINS O=FE_OFN1214_n5429 I=FE_OFN1212_n5429
XFE_OFC1213_n5429 INV2 $PINS O=FE_OFN1213_n5429 I=FE_RN_3
XFE_OFC1212_n5429 BUF2 $PINS O=FE_OFN1212_n5429 I=FE_OFN1210_n5429
XFE_OFC1210_n5429 BUF1 $PINS O=FE_OFN1210_n5429 I=FE_OFN1205_n5429
XFE_OFC1208_n5429 INV1S $PINS O=FE_OFN1208_n5429 I=FE_OFN1209_n5429
XFE_OFC1207_n5429 INV1S $PINS O=FE_OFN1207_n5429 I=FE_OFN1203_n5429
XFE_OFC1206_n5429 INV1S $PINS O=FE_OFN1206_n5429 I=FE_OFN1203_n5429
XFE_OFC1205_n5429 BUF1 $PINS O=FE_OFN1205_n5429 I=FE_OFN1202_n5429
XFE_OFC1203_n5429 INV1S $PINS O=FE_OFN1203_n5429 I=FE_OFN1200_n5429
XFE_OFC1202_n5429 BUF1 $PINS O=FE_OFN1202_n5429 I=n5429
XFE_OFC1199_n5413 BUF4CK $PINS O=FE_OFN1199_n5413 I=FE_OFN1193_n5413
XFE_OFC1198_n5413 INV2 $PINS O=FE_OFN1198_n5413 I=FE_OFN1192_n5413
XFE_OFC1196_n5413 INV2 $PINS O=FE_OFN1196_n5413 I=FE_OFN1192_n5413
XFE_OFC1195_n5413 INV2 $PINS O=FE_OFN1195_n5413 I=FE_OFN1192_n5413
XFE_OFC1194_n5413 INV2 $PINS O=FE_OFN1194_n5413 I=FE_OFN1192_n5413
XFE_OFC1193_n5413 BUF2 $PINS O=FE_OFN1193_n5413 I=FE_OFN1190_n5413
XFE_OFC1192_n5413 INV4CK $PINS O=FE_OFN1192_n5413 I=FE_OFN1189_n5413
XFE_OFC1191_n5413 INV1S $PINS O=FE_OFN1191_n5413 I=FE_OFN1187_n5413
XFE_OFC1190_n5413 INV2 $PINS O=FE_OFN1190_n5413 I=FE_OFN1187_n5413
XFE_OFC1189_n5413 BUF6 $PINS O=FE_OFN1189_n5413 I=FE_OFN1186_n5413
XFE_OFC1188_n5413 BUF2 $PINS O=FE_OFN1188_n5413 I=FE_OFN1185_n5413
XFE_OFC1187_n5413 INV2 $PINS O=FE_OFN1187_n5413 I=FE_OFN1181_n5413
XFE_OFC1186_n5413 BUF4CK $PINS O=FE_OFN1186_n5413 I=FE_OFN1180_n5413
XFE_OFC1185_n5413 BUF3CK $PINS O=FE_OFN1185_n5413 I=FE_OFN1180_n5413
XFE_OFC1184_n5413 BUF2 $PINS O=FE_OFN1184_n5413 I=FE_OFN1179_n5413
XFE_OFC1183_n5413 INV1S $PINS O=FE_OFN1183_n5413 I=FE_OFN1178_n5413
XFE_OFC1181_n5413 INV3 $PINS O=FE_OFN1181_n5413 I=FE_OFN1178_n5413
XFE_OFC1180_n5413 BUF8CK $PINS O=FE_OFN1180_n5413 I=FE_OFN1176_n5413
XFE_OFC1179_n5413 BUF2 $PINS O=FE_OFN1179_n5413 I=FE_OFN1175_n5413
XFE_OFC1178_n5413 INV2 $PINS O=FE_OFN1178_n5413 I=FE_OFN1174_n5413
XFE_OFC1177_n5413 BUF1 $PINS O=FE_OFN1177_n5413 I=FE_OFN1173_n5413
XFE_OFC1176_n5413 BUF6CK $PINS O=FE_OFN1176_n5413 I=FE_OFN1173_n5413
XFE_OFC1175_n5413 BUF3 $PINS O=FE_OFN1175_n5413 I=FE_OFN1172_n5413
XFE_OFC1174_n5413 INV2 $PINS O=FE_OFN1174_n5413 I=FE_OFN1170_n5413
XFE_OFC1173_n5413 INV4 $PINS O=FE_OFN1173_n5413 I=FE_OFN1170_n5413
XFE_OFC1172_n5413 INV4 $PINS O=FE_OFN1172_n5413 I=FE_OFN1169_n5413
XFE_OFC1171_n5413 INV1S $PINS O=FE_OFN1171_n5413 I=FE_OFN1169_n5413
XFE_OFC1170_n5413 INV12CK $PINS O=FE_OFN1170_n5413 I=n5413
XFE_OFC1169_n5413 INV2 $PINS O=FE_OFN1169_n5413 I=FE_OFN1166_n5413
XFE_OFC1166_n5413 INV4 $PINS O=FE_OFN1166_n5413 I=FE_OFN1170_n5413
XFE_OFC1165_n5413 INV1S $PINS O=FE_OFN1165_n5413 I=FE_OCPN9742_n5413
XFE_OFC1162_n5413 BUF1S $PINS O=FE_OFN1162_n5413 I=FE_OFN1168_n5413
XFE_OFC1161_n5413 BUF1S $PINS O=FE_OFN1161_n5413 I=FE_OFN1168_n5413
XFE_OFC1158_n5329 BUF1S $PINS O=FE_OFN1158_n5329 I=n5329
XFE_OFC1134_FE_DBTN13_n5209 BUF1S $PINS O=FE_OFN1134_FE_DBTN13_n5209
+ I=FE_DBTN13_n5209
XFE_OFC1133_FE_DBTN14_n4987 BUF1S $PINS O=FE_OFN1133_FE_DBTN14_n4987
+ I=FE_DBTN14_n4987
XFE_OFC1132_FE_DBTN15_n4765 BUF1S $PINS O=FE_OFN1132_FE_DBTN15_n4765
+ I=FE_DBTN15_n4765
XFE_OFC1131_FE_DBTN29_data_0_r_33 BUF1S $PINS
+ O=FE_OFN1131_FE_DBTN29_data_0_r_33 I=FE_DBTN29_data_0_r_33
XFE_OFC1130_FE_DBTN30_data_2_r_33 BUF1CK $PINS
+ O=FE_OFN1130_FE_DBTN30_data_2_r_33 I=FE_DBTN30_data_2_r_33
XFE_OFC1121_i_reset_n_i INV4 $PINS O=FE_OFN1121_i_reset_n_i
+ I=FE_OFN1120_i_reset_n_i
XFE_OFC1120_i_reset_n_i INV6 $PINS O=FE_OFN1120_i_reset_n_i
+ I=FE_OFN1108_i_reset_n_i
XFE_OFC1119_i_reset_n_i BUF2 $PINS O=FE_OFN1119_i_reset_n_i
+ I=FE_OFN1106_i_reset_n_i
XFE_OFC1118_i_reset_n_i BUF2 $PINS O=FE_OFN1118_i_reset_n_i
+ I=FE_OFN1105_i_reset_n_i
XFE_OFC1117_i_reset_n_i INV2 $PINS O=FE_OFN1117_i_reset_n_i
+ I=FE_OFN1103_i_reset_n_i
XFE_OFC1116_i_reset_n_i INV3 $PINS O=FE_OFN1116_i_reset_n_i
+ I=FE_OFN1103_i_reset_n_i
XFE_OFC1115_i_reset_n_i BUF2 $PINS O=FE_OFN1115_i_reset_n_i
+ I=FE_OFN1102_i_reset_n_i
XFE_OFC1114_i_reset_n_i BUF2 $PINS O=FE_OFN1114_i_reset_n_i
+ I=FE_OFN1101_i_reset_n_i
XFE_OFC1113_i_reset_n_i BUF2 $PINS O=FE_OFN1113_i_reset_n_i
+ I=FE_OFN1101_i_reset_n_i
XFE_OFC1112_i_reset_n_i BUF2 $PINS O=FE_OFN1112_i_reset_n_i
+ I=FE_OFN1101_i_reset_n_i
XFE_OFC1111_i_reset_n_i BUF2 $PINS O=FE_OFN1111_i_reset_n_i
+ I=FE_OFN1100_i_reset_n_i
XFE_OFC1110_i_reset_n_i BUF2 $PINS O=FE_OFN1110_i_reset_n_i
+ I=FE_OFN1099_i_reset_n_i
XFE_OFC1109_i_reset_n_i BUF2 $PINS O=FE_OFN1109_i_reset_n_i
+ I=FE_OFN1098_i_reset_n_i
XFE_OFC1108_i_reset_n_i INV4 $PINS O=FE_OFN1108_i_reset_n_i
+ I=FE_OFN1091_i_reset_n_i
XFE_OFC1107_i_reset_n_i INV1S $PINS O=FE_OFN1107_i_reset_n_i
+ I=FE_OFN1091_i_reset_n_i
XFE_OFC1106_i_reset_n_i BUF2 $PINS O=FE_OFN1106_i_reset_n_i
+ I=FE_OFN1086_i_reset_n_i
XFE_OFC1105_i_reset_n_i BUF2 $PINS O=FE_OFN1105_i_reset_n_i
+ I=FE_OFN1085_i_reset_n_i
XFE_OFC1104_i_reset_n_i BUF1 $PINS O=FE_OFN1104_i_reset_n_i
+ I=FE_OFN1085_i_reset_n_i
XFE_OFC1103_i_reset_n_i INV2 $PINS O=FE_OFN1103_i_reset_n_i
+ I=FE_OFN1083_i_reset_n_i
XFE_OFC1102_i_reset_n_i BUF3 $PINS O=FE_OFN1102_i_reset_n_i
+ I=FE_OFN1074_i_reset_n_i
XFE_OFC1101_i_reset_n_i BUF3 $PINS O=FE_OFN1101_i_reset_n_i
+ I=FE_OFN1071_i_reset_n_i
XFE_OFC1100_i_reset_n_i BUF2 $PINS O=FE_OFN1100_i_reset_n_i
+ I=FE_OFN1071_i_reset_n_i
XFE_OFC1099_i_reset_n_i BUF3 $PINS O=FE_OFN1099_i_reset_n_i
+ I=FE_OFN1068_i_reset_n_i
XFE_OFC1098_i_reset_n_i BUF2 $PINS O=FE_OFN1098_i_reset_n_i
+ I=FE_OFN1068_i_reset_n_i
XFE_OFC1097_i_reset_n_i BUF2 $PINS O=FE_OFN1097_i_reset_n_i
+ I=FE_OFN1066_i_reset_n_i
XFE_OFC1096_i_reset_n_i BUF1 $PINS O=FE_OFN1096_i_reset_n_i
+ I=FE_OFN1066_i_reset_n_i
XFE_OFC1095_i_reset_n_i BUF2 $PINS O=FE_OFN1095_i_reset_n_i
+ I=FE_OFN1064_i_reset_n_i
XFE_OFC1094_i_reset_n_i INV4 $PINS O=FE_OFN1094_i_reset_n_i
+ I=FE_OFN1063_i_reset_n_i
XFE_OFC1092_i_reset_n_i BUF2 $PINS O=FE_OFN1092_i_reset_n_i
+ I=FE_OFN1061_i_reset_n_i
XFE_OFC1091_i_reset_n_i INV6 $PINS O=FE_OFN1091_i_reset_n_i
+ I=FE_OFN1057_i_reset_n_i
XFE_OFC1090_i_reset_n_i INV3 $PINS O=FE_OFN1090_i_reset_n_i
+ I=FE_OFN1052_i_reset_n_i
XFE_OFC1089_i_reset_n_i INV2 $PINS O=FE_OFN1089_i_reset_n_i
+ I=FE_OFN1052_i_reset_n_i
XFE_OFC1088_i_reset_n_i BUF2 $PINS O=FE_OFN1088_i_reset_n_i
+ I=FE_OFN1049_i_reset_n_i
XFE_OFC1087_i_reset_n_i BUF2 $PINS O=FE_OFN1087_i_reset_n_i
+ I=FE_OFN1048_i_reset_n_i
XFE_OFC1086_i_reset_n_i BUF3 $PINS O=FE_OFN1086_i_reset_n_i
+ I=FE_OFN1047_i_reset_n_i
XFE_OFC1085_i_reset_n_i BUF2 $PINS O=FE_OFN1085_i_reset_n_i
+ I=FE_OFN1046_i_reset_n_i
XFE_OFC1084_i_reset_n_i BUF1 $PINS O=FE_OFN1084_i_reset_n_i
+ I=FE_OFN1045_i_reset_n_i
XFE_OFC1083_i_reset_n_i BUF2 $PINS O=FE_OFN1083_i_reset_n_i
+ I=FE_OFN1045_i_reset_n_i
XFE_OFC1082_i_reset_n_i BUF1 $PINS O=FE_OFN1082_i_reset_n_i
+ I=FE_OFN1045_i_reset_n_i
XFE_OFC1081_i_reset_n_i BUF1 $PINS O=FE_OFN1081_i_reset_n_i
+ I=FE_OFN1044_i_reset_n_i
XFE_OFC1080_i_reset_n_i BUF1 $PINS O=FE_OFN1080_i_reset_n_i
+ I=FE_OFN1043_i_reset_n_i
XFE_OFC1079_i_reset_n_i BUF2 $PINS O=FE_OFN1079_i_reset_n_i
+ I=FE_OFN1042_i_reset_n_i
XFE_OFC1078_i_reset_n_i BUF1 $PINS O=FE_OFN1078_i_reset_n_i
+ I=FE_OFN1042_i_reset_n_i
XFE_OFC1077_i_reset_n_i BUF2 $PINS O=FE_OFN1077_i_reset_n_i
+ I=FE_OFN1041_i_reset_n_i
XFE_OFC1076_i_reset_n_i BUF2 $PINS O=FE_OFN1076_i_reset_n_i
+ I=FE_OFN1040_i_reset_n_i
XFE_OFC1075_i_reset_n_i BUF1 $PINS O=FE_OFN1075_i_reset_n_i
+ I=FE_OFN1040_i_reset_n_i
XFE_OFC1074_i_reset_n_i INV6 $PINS O=FE_OFN1074_i_reset_n_i
+ I=FE_OFN1039_i_reset_n_i
XFE_OFC1073_i_reset_n_i INV1S $PINS O=FE_OFN1073_i_reset_n_i
+ I=FE_OFN1039_i_reset_n_i
XFE_OFC1072_i_reset_n_i BUF2 $PINS O=FE_OFN1072_i_reset_n_i
+ I=FE_OFN1036_i_reset_n_i
XFE_OFC1071_i_reset_n_i BUF4 $PINS O=FE_OFN1071_i_reset_n_i
+ I=FE_OFN1035_i_reset_n_i
XFE_OFC1070_i_reset_n_i BUF2 $PINS O=FE_OFN1070_i_reset_n_i
+ I=FE_OFN1032_i_reset_n_i
XFE_OFC1069_i_reset_n_i BUF1 $PINS O=FE_OFN1069_i_reset_n_i
+ I=FE_OFN1031_i_reset_n_i
XFE_OFC1068_i_reset_n_i BUF2 $PINS O=FE_OFN1068_i_reset_n_i
+ I=FE_OFN1031_i_reset_n_i
XFE_OFC1067_i_reset_n_i BUF1 $PINS O=FE_OFN1067_i_reset_n_i
+ I=FE_OFN1030_i_reset_n_i
XFE_OFC1066_i_reset_n_i BUF1 $PINS O=FE_OFN1066_i_reset_n_i
+ I=FE_OFN1030_i_reset_n_i
XFE_OFC1065_i_reset_n_i BUF2 $PINS O=FE_OFN1065_i_reset_n_i
+ I=FE_OFN1025_i_reset_n_i
XFE_OFC1064_i_reset_n_i BUF2 $PINS O=FE_OFN1064_i_reset_n_i
+ I=FE_OFN1020_i_reset_n_i
XFE_OFC1063_i_reset_n_i INV6 $PINS O=FE_OFN1063_i_reset_n_i
+ I=FE_OFN1011_i_reset_n_i
XFE_OFC1062_i_reset_n_i BUF2 $PINS O=FE_OFN1062_i_reset_n_i
+ I=FE_OFN1009_i_reset_n_i
XFE_OFC1061_i_reset_n_i INV4 $PINS O=FE_OFN1061_i_reset_n_i
+ I=FE_OFN1005_i_reset_n_i
XFE_OFC1060_i_reset_n_i INV2 $PINS O=FE_OFN1060_i_reset_n_i
+ I=FE_OFN1005_i_reset_n_i
XFE_OFC1058_i_reset_n_i INV1S $PINS O=FE_OFN1058_i_reset_n_i
+ I=FE_OFN993_i_reset_n_i
XFE_OFC1057_i_reset_n_i INV6 $PINS O=FE_OFN1057_i_reset_n_i
+ I=FE_OFN993_i_reset_n_i
XFE_OFC1056_i_reset_n_i INV2 $PINS O=FE_OFN1056_i_reset_n_i
+ I=FE_OFN992_i_reset_n_i
XFE_OFC1054_i_reset_n_i BUF2 $PINS O=FE_OFN1054_i_reset_n_i
+ I=FE_OFN980_i_reset_n_i
XFE_OFC1053_i_reset_n_i BUF2 $PINS O=FE_OFN1053_i_reset_n_i
+ I=FE_OFN979_i_reset_n_i
XFE_OFC1052_i_reset_n_i INV2 $PINS O=FE_OFN1052_i_reset_n_i
+ I=FE_OFN976_i_reset_n_i
XFE_OFC1051_i_reset_n_i BUF1 $PINS O=FE_OFN1051_i_reset_n_i
+ I=FE_OFN975_i_reset_n_i
XFE_OFC1050_i_reset_n_i BUF1 $PINS O=FE_OFN1050_i_reset_n_i
+ I=FE_OFN975_i_reset_n_i
XFE_OFC1049_i_reset_n_i BUF2 $PINS O=FE_OFN1049_i_reset_n_i
+ I=FE_OFN974_i_reset_n_i
XFE_OFC1048_i_reset_n_i BUF1 $PINS O=FE_OFN1048_i_reset_n_i
+ I=FE_OFN974_i_reset_n_i
XFE_OFC1047_i_reset_n_i INV4 $PINS O=FE_OFN1047_i_reset_n_i
+ I=FE_OFN973_i_reset_n_i
XFE_OFC1046_i_reset_n_i INV3 $PINS O=FE_OFN1046_i_reset_n_i
+ I=FE_OFN973_i_reset_n_i
XFE_OFC1045_i_reset_n_i BUF2 $PINS O=FE_OFN1045_i_reset_n_i
+ I=FE_OFN971_i_reset_n_i
XFE_OFC1044_i_reset_n_i BUF1 $PINS O=FE_OFN1044_i_reset_n_i
+ I=FE_OFN971_i_reset_n_i
XFE_OFC1043_i_reset_n_i BUF1 $PINS O=FE_OFN1043_i_reset_n_i
+ I=FE_OFN971_i_reset_n_i
XFE_OFC1042_i_reset_n_i BUF2 $PINS O=FE_OFN1042_i_reset_n_i
+ I=FE_OFN969_i_reset_n_i
XFE_OFC1041_i_reset_n_i BUF1 $PINS O=FE_OFN1041_i_reset_n_i
+ I=FE_OFN969_i_reset_n_i
XFE_OFC1040_i_reset_n_i BUF2 $PINS O=FE_OFN1040_i_reset_n_i
+ I=FE_OFN967_i_reset_n_i
XFE_OFC1039_i_reset_n_i INV8 $PINS O=FE_OFN1039_i_reset_n_i
+ I=FE_OFN964_i_reset_n_i
XFE_OFC1038_i_reset_n_i BUF1 $PINS O=FE_OFN1038_i_reset_n_i
+ I=FE_OFN964_i_reset_n_i
XFE_OFC1037_i_reset_n_i BUF1 $PINS O=FE_OFN1037_i_reset_n_i
+ I=FE_OFN964_i_reset_n_i
XFE_OFC1036_i_reset_n_i BUF2 $PINS O=FE_OFN1036_i_reset_n_i
+ I=FE_OFN963_i_reset_n_i
XFE_OFC1035_i_reset_n_i INV4 $PINS O=FE_OFN1035_i_reset_n_i
+ I=FE_OFN961_i_reset_n_i
XFE_OFC1033_i_reset_n_i INV1S $PINS O=FE_OFN1033_i_reset_n_i
+ I=FE_OFN961_i_reset_n_i
XFE_OFC1032_i_reset_n_i BUF2 $PINS O=FE_OFN1032_i_reset_n_i
+ I=FE_OFN959_i_reset_n_i
XFE_OFC1031_i_reset_n_i INV3 $PINS O=FE_OFN1031_i_reset_n_i
+ I=FE_OFN958_i_reset_n_i
XFE_OFC1030_i_reset_n_i INV2 $PINS O=FE_OFN1030_i_reset_n_i
+ I=FE_OFN958_i_reset_n_i
XFE_OFC1029_i_reset_n_i INV1S $PINS O=FE_OFN1029_i_reset_n_i
+ I=FE_OFN958_i_reset_n_i
XFE_OFC1028_i_reset_n_i BUF2 $PINS O=FE_OFN1028_i_reset_n_i
+ I=FE_OFN957_i_reset_n_i
XFE_OFC1027_i_reset_n_i BUF2 $PINS O=FE_OFN1027_i_reset_n_i
+ I=FE_OFN957_i_reset_n_i
XFE_OFC1026_i_reset_n_i BUF2 $PINS O=FE_OFN1026_i_reset_n_i
+ I=FE_OFN956_i_reset_n_i
XFE_OFC1025_i_reset_n_i BUF2 $PINS O=FE_OFN1025_i_reset_n_i
+ I=FE_OFN955_i_reset_n_i
XFE_OFC1024_i_reset_n_i INV2 $PINS O=FE_OFN1024_i_reset_n_i
+ I=FE_OFN953_i_reset_n_i
XFE_OFC1023_i_reset_n_i INV2 $PINS O=FE_OFN1023_i_reset_n_i
+ I=FE_OFN953_i_reset_n_i
XFE_OFC1022_i_reset_n_i INV2 $PINS O=FE_OFN1022_i_reset_n_i
+ I=FE_OFN952_i_reset_n_i
XFE_OFC1021_i_reset_n_i INV2 $PINS O=FE_OFN1021_i_reset_n_i
+ I=FE_OFN952_i_reset_n_i
XFE_OFC1020_i_reset_n_i INV3 $PINS O=FE_OFN1020_i_reset_n_i
+ I=FE_OFN951_i_reset_n_i
XFE_OFC1019_i_reset_n_i INV1S $PINS O=FE_OFN1019_i_reset_n_i
+ I=FE_OFN951_i_reset_n_i
XFE_OFC1017_i_reset_n_i BUF1 $PINS O=FE_OFN1017_i_reset_n_i
+ I=FE_OFN949_i_reset_n_i
XFE_OFC1016_i_reset_n_i BUF1 $PINS O=FE_OFN1016_i_reset_n_i
+ I=FE_OFN949_i_reset_n_i
XFE_OFC1015_i_reset_n_i INV2 $PINS O=FE_OFN1015_i_reset_n_i
+ I=FE_OFN948_i_reset_n_i
XFE_OFC1014_i_reset_n_i INV2 $PINS O=FE_OFN1014_i_reset_n_i
+ I=FE_OFN948_i_reset_n_i
XFE_OFC1013_i_reset_n_i BUF2 $PINS O=FE_OFN1013_i_reset_n_i
+ I=FE_OFN947_i_reset_n_i
XFE_OFC1012_i_reset_n_i BUF2 $PINS O=FE_OFN1012_i_reset_n_i
+ I=FE_OFN947_i_reset_n_i
XFE_OFC1011_i_reset_n_i BUF3 $PINS O=FE_OFN1011_i_reset_n_i
+ I=FE_OFN946_i_reset_n_i
XFE_OFC1010_i_reset_n_i BUF1 $PINS O=FE_OFN1010_i_reset_n_i
+ I=FE_OFN946_i_reset_n_i
XFE_OFC1009_i_reset_n_i BUF2 $PINS O=FE_OFN1009_i_reset_n_i
+ I=FE_OFN939_i_reset_n_i
XFE_OFC1008_i_reset_n_i BUF1CK $PINS O=FE_OFN1008_i_reset_n_i
+ I=FE_OFN938_i_reset_n_i
XFE_OFC1007_i_reset_n_i BUF1CK $PINS O=FE_OFN1007_i_reset_n_i
+ I=FE_OFN938_i_reset_n_i
XFE_OFC1006_i_reset_n_i BUF1CK $PINS O=FE_OFN1006_i_reset_n_i
+ I=FE_OFN938_i_reset_n_i
XFE_OFC1005_i_reset_n_i INV6 $PINS O=FE_OFN1005_i_reset_n_i
+ I=FE_OFN935_i_reset_n_i
XFE_OFC1004_i_reset_n_i BUF1 $PINS O=FE_OFN1004_i_reset_n_i
+ I=FE_OFN935_i_reset_n_i
XFE_OFC1003_i_reset_n_i INV2 $PINS O=FE_OFN1003_i_reset_n_i
+ I=FE_OFN934_i_reset_n_i
XFE_OFC1002_i_reset_n_i INV2 $PINS O=FE_OFN1002_i_reset_n_i
+ I=FE_OFN934_i_reset_n_i
XFE_OFC1001_i_reset_n_i BUF1 $PINS O=FE_OFN1001_i_reset_n_i
+ I=FE_OFN933_i_reset_n_i
XFE_OFC1000_i_reset_n_i BUF1 $PINS O=FE_OFN1000_i_reset_n_i
+ I=FE_OFN933_i_reset_n_i
XFE_OFC999_i_reset_n_i BUF1CK $PINS O=FE_OFN999_i_reset_n_i
+ I=FE_OFN931_i_reset_n_i
XFE_OFC998_i_reset_n_i BUF1 $PINS O=FE_OFN998_i_reset_n_i
+ I=FE_OFN931_i_reset_n_i
XFE_OFC997_i_reset_n_i BUF2 $PINS O=FE_OFN997_i_reset_n_i
+ I=FE_OFN931_i_reset_n_i
XFE_OFC996_i_reset_n_i BUF2 $PINS O=FE_OFN996_i_reset_n_i
+ I=FE_OFN930_i_reset_n_i
XFE_OFC995_i_reset_n_i BUF2 $PINS O=FE_OFN995_i_reset_n_i
+ I=FE_OFN926_i_reset_n_i
XFE_OFC994_i_reset_n_i BUF2 $PINS O=FE_OFN994_i_reset_n_i
+ I=FE_OFN925_i_reset_n_i
XFE_OFC993_i_reset_n_i INV6 $PINS O=FE_OFN993_i_reset_n_i
+ I=FE_OFN924_i_reset_n_i
XFE_OFC992_i_reset_n_i INV2 $PINS O=FE_OFN992_i_reset_n_i
+ I=FE_OFN920_i_reset_n_i
XFE_OFC991_i_reset_n_i BUF2 $PINS O=FE_OFN991_i_reset_n_i
+ I=FE_OFN913_i_reset_n_i
XFE_OFC990_i_reset_n_i BUF2 $PINS O=FE_OFN990_i_reset_n_i
+ I=FE_OFN909_i_reset_n_i
XFE_OFC989_i_reset_n_i BUF1 $PINS O=FE_OFN989_i_reset_n_i
+ I=FE_OFN909_i_reset_n_i
XFE_OFC988_i_reset_n_i BUF2 $PINS O=FE_OFN988_i_reset_n_i
+ I=FE_OFN908_i_reset_n_i
XFE_OFC987_i_reset_n_i INV2 $PINS O=FE_OFN987_i_reset_n_i
+ I=FE_OFN902_i_reset_n_i
XFE_OFC986_i_reset_n_i INV1S $PINS O=FE_OFN986_i_reset_n_i
+ I=FE_OFN902_i_reset_n_i
XFE_OFC985_i_reset_n_i BUF2 $PINS O=FE_OFN985_i_reset_n_i
+ I=FE_OFN901_i_reset_n_i
XFE_OFC984_i_reset_n_i BUF2 $PINS O=FE_OFN984_i_reset_n_i
+ I=FE_OFN900_i_reset_n_i
XFE_OFC983_i_reset_n_i INV1S $PINS O=FE_OFN983_i_reset_n_i
+ I=FE_OFN898_i_reset_n_i
XFE_OFC982_i_reset_n_i INV2 $PINS O=FE_OFN982_i_reset_n_i
+ I=FE_OFN898_i_reset_n_i
XFE_OFC981_i_reset_n_i BUF2 $PINS O=FE_OFN981_i_reset_n_i
+ I=FE_OFN897_i_reset_n_i
XFE_OFC980_i_reset_n_i BUF2 $PINS O=FE_OFN980_i_reset_n_i
+ I=FE_OFN894_i_reset_n_i
XFE_OFC979_i_reset_n_i BUF2 $PINS O=FE_OFN979_i_reset_n_i
+ I=FE_OFN894_i_reset_n_i
XFE_OFC978_i_reset_n_i BUF1 $PINS O=FE_OFN978_i_reset_n_i
+ I=FE_OFN894_i_reset_n_i
XFE_OFC977_i_reset_n_i BUF1 $PINS O=FE_OFN977_i_reset_n_i
+ I=FE_OFN891_i_reset_n_i
XFE_OFC976_i_reset_n_i BUF2 $PINS O=FE_OFN976_i_reset_n_i
+ I=FE_OFN891_i_reset_n_i
XFE_OFC975_i_reset_n_i BUF1 $PINS O=FE_OFN975_i_reset_n_i
+ I=FE_OFN890_i_reset_n_i
XFE_OFC974_i_reset_n_i BUF2 $PINS O=FE_OFN974_i_reset_n_i
+ I=FE_OFN890_i_reset_n_i
XFE_OFC973_i_reset_n_i INV4 $PINS O=FE_OFN973_i_reset_n_i
+ I=FE_OFN888_i_reset_n_i
XFE_OFC972_i_reset_n_i BUF1 $PINS O=FE_OFN972_i_reset_n_i
+ I=FE_OFN887_i_reset_n_i
XFE_OFC971_i_reset_n_i BUF6 $PINS O=FE_OFN971_i_reset_n_i
+ I=FE_OFN885_i_reset_n_i
XFE_OFC970_i_reset_n_i BUF1 $PINS O=FE_OFN970_i_reset_n_i
+ I=FE_OFN885_i_reset_n_i
XFE_OFC969_i_reset_n_i BUF2 $PINS O=FE_OFN969_i_reset_n_i
+ I=FE_OFN884_i_reset_n_i
XFE_OFC967_i_reset_n_i BUF1 $PINS O=FE_OFN967_i_reset_n_i
+ I=FE_OFN884_i_reset_n_i
XFE_OFC966_i_reset_n_i BUF1 $PINS O=FE_OFN966_i_reset_n_i
+ I=FE_OFN883_i_reset_n_i
XFE_OFC965_i_reset_n_i BUF1 $PINS O=FE_OFN965_i_reset_n_i
+ I=FE_OFN883_i_reset_n_i
XFE_OFC964_i_reset_n_i BUF6 $PINS O=FE_OFN964_i_reset_n_i
+ I=FE_OFN882_i_reset_n_i
XFE_OFC963_i_reset_n_i BUF2 $PINS O=FE_OFN963_i_reset_n_i
+ I=FE_OFN882_i_reset_n_i
XFE_OFC962_i_reset_n_i BUF1 $PINS O=FE_OFN962_i_reset_n_i
+ I=FE_OFN882_i_reset_n_i
XFE_OFC961_i_reset_n_i INV4 $PINS O=FE_OFN961_i_reset_n_i
+ I=FE_OFN881_i_reset_n_i
XFE_OFC960_i_reset_n_i BUF1 $PINS O=FE_OFN960_i_reset_n_i
+ I=FE_OFN881_i_reset_n_i
XFE_OFC959_i_reset_n_i BUF2 $PINS O=FE_OFN959_i_reset_n_i
+ I=FE_OFN880_i_reset_n_i
XFE_OFC958_i_reset_n_i INV3 $PINS O=FE_OFN958_i_reset_n_i
+ I=FE_OFN879_i_reset_n_i
XFE_OFC957_i_reset_n_i BUF2 $PINS O=FE_OFN957_i_reset_n_i
+ I=FE_OFN876_i_reset_n_i
XFE_OFC956_i_reset_n_i BUF2 $PINS O=FE_OFN956_i_reset_n_i
+ I=FE_OFN875_i_reset_n_i
XFE_OFC955_i_reset_n_i BUF2 $PINS O=FE_OFN955_i_reset_n_i
+ I=FE_OFN874_i_reset_n_i
XFE_OFC954_i_reset_n_i BUF1 $PINS O=FE_OFN954_i_reset_n_i
+ I=FE_OFN874_i_reset_n_i
XFE_OFC953_i_reset_n_i INV1S $PINS O=FE_OFN953_i_reset_n_i
+ I=FE_OFN871_i_reset_n_i
XFE_OFC952_i_reset_n_i INV2 $PINS O=FE_OFN952_i_reset_n_i
+ I=FE_OFN864_i_reset_n_i
XFE_OFC951_i_reset_n_i INV3 $PINS O=FE_OFN951_i_reset_n_i
+ I=FE_OFN858_i_reset_n_i
XFE_OFC950_i_reset_n_i BUF1 $PINS O=FE_OFN950_i_reset_n_i
+ I=FE_OFN858_i_reset_n_i
XFE_OFC949_i_reset_n_i BUF1 $PINS O=FE_OFN949_i_reset_n_i
+ I=FE_OFN858_i_reset_n_i
XFE_OFC948_i_reset_n_i INV1S $PINS O=FE_OFN948_i_reset_n_i
+ I=FE_OFN850_i_reset_n_i
XFE_OFC947_i_reset_n_i BUF4 $PINS O=FE_OFN947_i_reset_n_i
+ I=FE_OFN849_i_reset_n_i
XFE_OFC946_i_reset_n_i BUF6 $PINS O=FE_OFN946_i_reset_n_i
+ I=FE_OFN841_i_reset_n_i
XFE_OFC945_i_reset_n_i BUF1 $PINS O=FE_OFN945_i_reset_n_i
+ I=FE_OFN841_i_reset_n_i
XFE_OFC944_i_reset_n_i BUF1 $PINS O=FE_OFN944_i_reset_n_i
+ I=FE_OFN837_i_reset_n_i
XFE_OFC943_i_reset_n_i BUF1CK $PINS O=FE_OFN943_i_reset_n_i
+ I=FE_OFN837_i_reset_n_i
XFE_OFC941_i_reset_n_i BUF2 $PINS O=FE_OFN941_i_reset_n_i
+ I=FE_OFN835_i_reset_n_i
XFE_OFC940_i_reset_n_i BUF1 $PINS O=FE_OFN940_i_reset_n_i
+ I=FE_OFN835_i_reset_n_i
XFE_OFC939_i_reset_n_i BUF6 $PINS O=FE_OFN939_i_reset_n_i
+ I=FE_OFN832_i_reset_n_i
XFE_OFC938_i_reset_n_i BUF2 $PINS O=FE_OFN938_i_reset_n_i
+ I=FE_OFN829_i_reset_n_i
XFE_OFC936_i_reset_n_i BUF1 $PINS O=FE_OFN936_i_reset_n_i
+ I=FE_OFN829_i_reset_n_i
XFE_OFC935_i_reset_n_i BUF3 $PINS O=FE_OFN935_i_reset_n_i
+ I=FE_OFN827_i_reset_n_i
XFE_OFC934_i_reset_n_i INV2 $PINS O=FE_OFN934_i_reset_n_i
+ I=FE_OFN824_i_reset_n_i
XFE_OFC933_i_reset_n_i INV2 $PINS O=FE_OFN933_i_reset_n_i
+ I=FE_OFN815_i_reset_n_i
XFE_OFC932_i_reset_n_i INV1S $PINS O=FE_OFN932_i_reset_n_i
+ I=FE_OFN815_i_reset_n_i
XFE_OFC931_i_reset_n_i BUF2 $PINS O=FE_OFN931_i_reset_n_i
+ I=FE_OFN810_i_reset_n_i
XFE_OFC930_i_reset_n_i BUF1CK $PINS O=FE_OFN930_i_reset_n_i
+ I=FE_OFN810_i_reset_n_i
XFE_OFC929_i_reset_n_i BUF2 $PINS O=FE_OFN929_i_reset_n_i
+ I=FE_OFN809_i_reset_n_i
XFE_OFC928_i_reset_n_i BUF1 $PINS O=FE_OFN928_i_reset_n_i
+ I=FE_OFN809_i_reset_n_i
XFE_OFC927_i_reset_n_i BUF1 $PINS O=FE_OFN927_i_reset_n_i
+ I=FE_OFN808_i_reset_n_i
XFE_OFC926_i_reset_n_i BUF3 $PINS O=FE_OFN926_i_reset_n_i
+ I=FE_OFN807_i_reset_n_i
XFE_OFC925_i_reset_n_i BUF1 $PINS O=FE_OFN925_i_reset_n_i
+ I=FE_OFN807_i_reset_n_i
XFE_OFC924_i_reset_n_i BUF3 $PINS O=FE_OFN924_i_reset_n_i
+ I=FE_OFN804_i_reset_n_i
XFE_OFC923_i_reset_n_i BUF1 $PINS O=FE_OFN923_i_reset_n_i
+ I=FE_OFN804_i_reset_n_i
XFE_OFC922_i_reset_n_i BUF1 $PINS O=FE_OFN922_i_reset_n_i
+ I=FE_OFN802_i_reset_n_i
XFE_OFC921_i_reset_n_i BUF1 $PINS O=FE_OFN921_i_reset_n_i
+ I=FE_OFN801_i_reset_n_i
XFE_OFC920_i_reset_n_i BUF2 $PINS O=FE_OFN920_i_reset_n_i
+ I=FE_OFN801_i_reset_n_i
XFE_OFC919_i_reset_n_i BUF1 $PINS O=FE_OFN919_i_reset_n_i
+ I=FE_OFN800_i_reset_n_i
XFE_OFC918_i_reset_n_i BUF2 $PINS O=FE_OFN918_i_reset_n_i
+ I=FE_OFN799_i_reset_n_i
XFE_OFC917_i_reset_n_i BUF1CK $PINS O=FE_OFN917_i_reset_n_i
+ I=FE_OFN799_i_reset_n_i
XFE_OFC916_i_reset_n_i BUF1 $PINS O=FE_OFN916_i_reset_n_i
+ I=FE_OFN799_i_reset_n_i
XFE_OFC915_i_reset_n_i BUF2 $PINS O=FE_OFN915_i_reset_n_i
+ I=FE_OFN798_i_reset_n_i
XFE_OFC914_i_reset_n_i BUF1 $PINS O=FE_OFN914_i_reset_n_i
+ I=FE_OFN798_i_reset_n_i
XFE_OFC913_i_reset_n_i BUF2 $PINS O=FE_OFN913_i_reset_n_i
+ I=FE_OFN796_i_reset_n_i
XFE_OFC912_i_reset_n_i BUF1 $PINS O=FE_OFN912_i_reset_n_i
+ I=FE_OFN796_i_reset_n_i
XFE_OFC910_i_reset_n_i BUF1 $PINS O=FE_OFN910_i_reset_n_i
+ I=FE_OFN794_i_reset_n_i
XFE_OFC909_i_reset_n_i BUF2 $PINS O=FE_OFN909_i_reset_n_i
+ I=FE_OFN793_i_reset_n_i
XFE_OFC908_i_reset_n_i BUF1 $PINS O=FE_OFN908_i_reset_n_i
+ I=FE_OFN793_i_reset_n_i
XFE_OFC907_i_reset_n_i BUF2 $PINS O=FE_OFN907_i_reset_n_i
+ I=FE_OFN788_i_reset_n_i
XFE_OFC906_i_reset_n_i BUF1CK $PINS O=FE_OFN906_i_reset_n_i
+ I=FE_OFN788_i_reset_n_i
XFE_OFC905_i_reset_n_i BUF2 $PINS O=FE_OFN905_i_reset_n_i
+ I=FE_OFN787_i_reset_n_i
XFE_OFC904_i_reset_n_i BUF2 $PINS O=FE_OFN904_i_reset_n_i
+ I=FE_OFN785_i_reset_n_i
XFE_OFC903_i_reset_n_i BUF2 $PINS O=FE_OFN903_i_reset_n_i
+ I=FE_OFN784_i_reset_n_i
XFE_OFC902_i_reset_n_i INV2 $PINS O=FE_OFN902_i_reset_n_i
+ I=FE_OFN782_i_reset_n_i
XFE_OFC901_i_reset_n_i BUF2 $PINS O=FE_OFN901_i_reset_n_i
+ I=FE_OFN779_i_reset_n_i
XFE_OFC900_i_reset_n_i BUF2 $PINS O=FE_OFN900_i_reset_n_i
+ I=FE_OFN778_i_reset_n_i
XFE_OFC899_i_reset_n_i BUF1 $PINS O=FE_OFN899_i_reset_n_i
+ I=FE_OFN778_i_reset_n_i
XFE_OFC898_i_reset_n_i INV2 $PINS O=FE_OFN898_i_reset_n_i
+ I=FE_OFN773_i_reset_n_i
XFE_OFC897_i_reset_n_i BUF2 $PINS O=FE_OFN897_i_reset_n_i
+ I=FE_OFN771_i_reset_n_i
XFE_OFC896_i_reset_n_i BUF1 $PINS O=FE_OFN896_i_reset_n_i
+ I=FE_OFN771_i_reset_n_i
XFE_OFC895_i_reset_n_i BUF1 $PINS O=FE_OFN895_i_reset_n_i
+ I=FE_OFN769_i_reset_n_i
XFE_OFC894_i_reset_n_i BUF2 $PINS O=FE_OFN894_i_reset_n_i
+ I=FE_OFN767_i_reset_n_i
XFE_OFC893_i_reset_n_i BUF1 $PINS O=FE_OFN893_i_reset_n_i
+ I=FE_OFN767_i_reset_n_i
XFE_OFC892_i_reset_n_i BUF1 $PINS O=FE_OFN892_i_reset_n_i
+ I=FE_OFN764_i_reset_n_i
XFE_OFC891_i_reset_n_i BUF2 $PINS O=FE_OFN891_i_reset_n_i
+ I=FE_OFN763_i_reset_n_i
XFE_OFC890_i_reset_n_i BUF2 $PINS O=FE_OFN890_i_reset_n_i
+ I=FE_OFN760_i_reset_n_i
XFE_OFC889_i_reset_n_i BUF1 $PINS O=FE_OFN889_i_reset_n_i
+ I=FE_OFN760_i_reset_n_i
XFE_OFC888_i_reset_n_i BUF6 $PINS O=FE_OFN888_i_reset_n_i
+ I=FE_OFN758_i_reset_n_i
XFE_OFC887_i_reset_n_i BUF1 $PINS O=FE_OFN887_i_reset_n_i
+ I=FE_OFN758_i_reset_n_i
XFE_OFC886_i_reset_n_i BUF1 $PINS O=FE_OFN886_i_reset_n_i
+ I=FE_OFN758_i_reset_n_i
XFE_OFC885_i_reset_n_i BUF6 $PINS O=FE_OFN885_i_reset_n_i
+ I=FE_OFN756_i_reset_n_i
XFE_OFC884_i_reset_n_i BUF2 $PINS O=FE_OFN884_i_reset_n_i
+ I=FE_OFN755_i_reset_n_i
XFE_OFC883_i_reset_n_i BUF1 $PINS O=FE_OFN883_i_reset_n_i
+ I=FE_OFN755_i_reset_n_i
XFE_OFC882_i_reset_n_i BUF2 $PINS O=FE_OFN882_i_reset_n_i
+ I=FE_OFN754_i_reset_n_i
XFE_OFC881_i_reset_n_i BUF6 $PINS O=FE_OFN881_i_reset_n_i
+ I=FE_OFN752_i_reset_n_i
XFE_OFC880_i_reset_n_i BUF2 $PINS O=FE_OFN880_i_reset_n_i
+ I=FE_OFN752_i_reset_n_i
XFE_OFC879_i_reset_n_i BUF6 $PINS O=FE_OFN879_i_reset_n_i
+ I=FE_OFN750_i_reset_n_i
XFE_OFC877_i_reset_n_i BUF1 $PINS O=FE_OFN877_i_reset_n_i
+ I=FE_OFN750_i_reset_n_i
XFE_OFC876_i_reset_n_i BUF2 $PINS O=FE_OFN876_i_reset_n_i
+ I=FE_OFN749_i_reset_n_i
XFE_OFC875_i_reset_n_i BUF2 $PINS O=FE_OFN875_i_reset_n_i
+ I=FE_OFN749_i_reset_n_i
XFE_OFC874_i_reset_n_i BUF2 $PINS O=FE_OFN874_i_reset_n_i
+ I=FE_OFN748_i_reset_n_i
XFE_OFC873_i_reset_n_i BUF1 $PINS O=FE_OFN873_i_reset_n_i
+ I=FE_OFN745_i_reset_n_i
XFE_OFC871_i_reset_n_i BUF1 $PINS O=FE_OFN871_i_reset_n_i
+ I=FE_OFN743_i_reset_n_i
XFE_OFC870_i_reset_n_i BUF1 $PINS O=FE_OFN870_i_reset_n_i
+ I=FE_OFN743_i_reset_n_i
XFE_OFC869_i_reset_n_i BUF1 $PINS O=FE_OFN869_i_reset_n_i
+ I=FE_OFN741_i_reset_n_i
XFE_OFC868_i_reset_n_i BUF1 $PINS O=FE_OFN868_i_reset_n_i
+ I=FE_OFN740_i_reset_n_i
XFE_OFC867_i_reset_n_i BUF1 $PINS O=FE_OFN867_i_reset_n_i
+ I=FE_OFN739_i_reset_n_i
XFE_OFC865_i_reset_n_i BUF1 $PINS O=FE_OFN865_i_reset_n_i
+ I=FE_OFN737_i_reset_n_i
XFE_OFC864_i_reset_n_i BUF2 $PINS O=FE_OFN864_i_reset_n_i
+ I=FE_OFN736_i_reset_n_i
XFE_OFC863_i_reset_n_i BUF1 $PINS O=FE_OFN863_i_reset_n_i
+ I=FE_OFN734_i_reset_n_i
XFE_OFC862_i_reset_n_i BUF1 $PINS O=FE_OFN862_i_reset_n_i
+ I=FE_OFN734_i_reset_n_i
XFE_OFC861_i_reset_n_i BUF1 $PINS O=FE_OFN861_i_reset_n_i
+ I=FE_OFN733_i_reset_n_i
XFE_OFC860_i_reset_n_i BUF1 $PINS O=FE_OFN860_i_reset_n_i
+ I=FE_OFN733_i_reset_n_i
XFE_OFC859_i_reset_n_i BUF1 $PINS O=FE_OFN859_i_reset_n_i
+ I=FE_OFN733_i_reset_n_i
XFE_OFC858_i_reset_n_i BUF3 $PINS O=FE_OFN858_i_reset_n_i
+ I=FE_OFN732_i_reset_n_i
XFE_OFC857_i_reset_n_i BUF1 $PINS O=FE_OFN857_i_reset_n_i
+ I=FE_OFN730_i_reset_n_i
XFE_OFC856_i_reset_n_i BUF2 $PINS O=FE_OFN856_i_reset_n_i
+ I=FE_OFN729_i_reset_n_i
XFE_OFC855_i_reset_n_i BUF2 $PINS O=FE_OFN855_i_reset_n_i
+ I=FE_OFN729_i_reset_n_i
XFE_OFC854_i_reset_n_i BUF1 $PINS O=FE_OFN854_i_reset_n_i
+ I=FE_OFN727_i_reset_n_i
XFE_OFC853_i_reset_n_i BUF2 $PINS O=FE_OFN853_i_reset_n_i
+ I=FE_OFN727_i_reset_n_i
XFE_OFC852_i_reset_n_i BUF1 $PINS O=FE_OFN852_i_reset_n_i
+ I=FE_OFN726_i_reset_n_i
XFE_OFC851_i_reset_n_i BUF1 $PINS O=FE_OFN851_i_reset_n_i
+ I=FE_OFN722_i_reset_n_i
XFE_OFC850_i_reset_n_i BUF1 $PINS O=FE_OFN850_i_reset_n_i
+ I=FE_OFN722_i_reset_n_i
XFE_OFC849_i_reset_n_i BUF6 $PINS O=FE_OFN849_i_reset_n_i
+ I=FE_OFN720_i_reset_n_i
XFE_OFC848_i_reset_n_i BUF1 $PINS O=FE_OFN848_i_reset_n_i
+ I=FE_OFN720_i_reset_n_i
XFE_OFC847_i_reset_n_i BUF1 $PINS O=FE_OFN847_i_reset_n_i
+ I=FE_OFN720_i_reset_n_i
XFE_OFC846_i_reset_n_i BUF2 $PINS O=FE_OFN846_i_reset_n_i
+ I=FE_OFN716_i_reset_n_i
XFE_OFC845_i_reset_n_i BUF2 $PINS O=FE_OFN845_i_reset_n_i
+ I=FE_OFN714_i_reset_n_i
XFE_OFC844_i_reset_n_i BUF2 $PINS O=FE_OFN844_i_reset_n_i
+ I=FE_OFN714_i_reset_n_i
XFE_OFC842_i_reset_n_i BUF2 $PINS O=FE_OFN842_i_reset_n_i
+ I=FE_OFN713_i_reset_n_i
XFE_OFC841_i_reset_n_i BUF6 $PINS O=FE_OFN841_i_reset_n_i
+ I=FE_OFN711_i_reset_n_i
XFE_OFC840_i_reset_n_i BUF1 $PINS O=FE_OFN840_i_reset_n_i
+ I=FE_OFN711_i_reset_n_i
XFE_OFC839_i_reset_n_i BUF1 $PINS O=FE_OFN839_i_reset_n_i
+ I=FE_OFN711_i_reset_n_i
XFE_OFC838_i_reset_n_i BUF1 $PINS O=FE_OFN838_i_reset_n_i
+ I=FE_OFN710_i_reset_n_i
XFE_OFC837_i_reset_n_i BUF1 $PINS O=FE_OFN837_i_reset_n_i
+ I=FE_OFN710_i_reset_n_i
XFE_OFC836_i_reset_n_i BUF1 $PINS O=FE_OFN836_i_reset_n_i
+ I=FE_OFN709_i_reset_n_i
XFE_OFC835_i_reset_n_i BUF2 $PINS O=FE_OFN835_i_reset_n_i
+ I=FE_OFN706_i_reset_n_i
XFE_OFC834_i_reset_n_i BUF1 $PINS O=FE_OFN834_i_reset_n_i
+ I=FE_OFN706_i_reset_n_i
XFE_OFC833_i_reset_n_i BUF1 $PINS O=FE_OFN833_i_reset_n_i
+ I=FE_OFN706_i_reset_n_i
XFE_OFC832_i_reset_n_i BUF6 $PINS O=FE_OFN832_i_reset_n_i
+ I=FE_OFN702_i_reset_n_i
XFE_OFC831_i_reset_n_i BUF1 $PINS O=FE_OFN831_i_reset_n_i
+ I=FE_OFN702_i_reset_n_i
XFE_OFC830_i_reset_n_i BUF1 $PINS O=FE_OFN830_i_reset_n_i
+ I=FE_OFN701_i_reset_n_i
XFE_OFC829_i_reset_n_i BUF2 $PINS O=FE_OFN829_i_reset_n_i
+ I=FE_OFN699_i_reset_n_i
XFE_OFC828_i_reset_n_i BUF1 $PINS O=FE_OFN828_i_reset_n_i
+ I=FE_OFN699_i_reset_n_i
XFE_OFC827_i_reset_n_i BUF3 $PINS O=FE_OFN827_i_reset_n_i
+ I=FE_OFN692_i_reset_n_i
XFE_OFC825_i_reset_n_i BUF1 $PINS O=FE_OFN825_i_reset_n_i
+ I=FE_OFN692_i_reset_n_i
XFE_OFC824_i_reset_n_i BUF2 $PINS O=FE_OFN824_i_reset_n_i
+ I=FE_OFN691_i_reset_n_i
XFE_OFC823_i_reset_n_i BUF1 $PINS O=FE_OFN823_i_reset_n_i
+ I=FE_OFN691_i_reset_n_i
XFE_OFC822_i_reset_n_i BUF1 $PINS O=FE_OFN822_i_reset_n_i
+ I=FE_OFN689_i_reset_n_i
XFE_OFC821_i_reset_n_i BUF1 $PINS O=FE_OFN821_i_reset_n_i
+ I=FE_OFN688_i_reset_n_i
XFE_OFC820_i_reset_n_i BUF1 $PINS O=FE_OFN820_i_reset_n_i
+ I=FE_OFN688_i_reset_n_i
XFE_OFC819_i_reset_n_i BUF1 $PINS O=FE_OFN819_i_reset_n_i
+ I=FE_OFN688_i_reset_n_i
XFE_OFC818_i_reset_n_i BUF1 $PINS O=FE_OFN818_i_reset_n_i
+ I=FE_OFN687_i_reset_n_i
XFE_OFC817_i_reset_n_i BUF1 $PINS O=FE_OFN817_i_reset_n_i
+ I=FE_OFN685_i_reset_n_i
XFE_OFC816_i_reset_n_i BUF1 $PINS O=FE_OFN816_i_reset_n_i
+ I=FE_OFN685_i_reset_n_i
XFE_OFC815_i_reset_n_i INV2 $PINS O=FE_OFN815_i_reset_n_i
+ I=FE_OFN683_i_reset_n_i
XFE_OFC814_i_reset_n_i BUF1 $PINS O=FE_OFN814_i_reset_n_i
+ I=FE_OFN682_i_reset_n_i
XFE_OFC813_i_reset_n_i BUF1 $PINS O=FE_OFN813_i_reset_n_i
+ I=FE_OFN681_i_reset_n_i
XFE_OFC812_i_reset_n_i BUF1 $PINS O=FE_OFN812_i_reset_n_i
+ I=FE_OFN681_i_reset_n_i
XFE_OFC811_i_reset_n_i BUF1 $PINS O=FE_OFN811_i_reset_n_i
+ I=FE_OFN680_i_reset_n_i
XFE_OFC810_i_reset_n_i BUF2 $PINS O=FE_OFN810_i_reset_n_i
+ I=FE_OFN679_i_reset_n_i
XFE_OFC809_i_reset_n_i BUF1 $PINS O=FE_OFN809_i_reset_n_i
+ I=FE_OFN676_i_reset_n_i
XFE_OFC808_i_reset_n_i BUF1 $PINS O=FE_OFN808_i_reset_n_i
+ I=FE_OFN676_i_reset_n_i
XFE_OFC807_i_reset_n_i BUF4 $PINS O=FE_OFN807_i_reset_n_i
+ I=FE_OFN674_i_reset_n_i
XFE_OFC806_i_reset_n_i BUF1 $PINS O=FE_OFN806_i_reset_n_i
+ I=FE_OFN674_i_reset_n_i
XFE_OFC805_i_reset_n_i BUF1 $PINS O=FE_OFN805_i_reset_n_i
+ I=FE_OFN673_i_reset_n_i
XFE_OFC804_i_reset_n_i BUF2 $PINS O=FE_OFN804_i_reset_n_i
+ I=FE_OFN672_i_reset_n_i
XFE_OFC803_i_reset_n_i BUF1 $PINS O=FE_OFN803_i_reset_n_i
+ I=FE_OFN672_i_reset_n_i
XFE_OFC802_i_reset_n_i BUF1 $PINS O=FE_OFN802_i_reset_n_i
+ I=FE_OFN670_i_reset_n_i
XFE_OFC801_i_reset_n_i BUF2 $PINS O=FE_OFN801_i_reset_n_i
+ I=FE_OFN670_i_reset_n_i
XFE_OFC800_i_reset_n_i BUF1 $PINS O=FE_OFN800_i_reset_n_i
+ I=FE_OFN669_i_reset_n_i
XFE_OFC799_i_reset_n_i BUF1 $PINS O=FE_OFN799_i_reset_n_i
+ I=FE_OFN667_i_reset_n_i
XFE_OFC798_i_reset_n_i BUF1 $PINS O=FE_OFN798_i_reset_n_i
+ I=FE_OFN667_i_reset_n_i
XFE_OFC797_i_reset_n_i BUF1 $PINS O=FE_OFN797_i_reset_n_i
+ I=FE_OFN666_i_reset_n_i
XFE_OFC796_i_reset_n_i BUF2 $PINS O=FE_OFN796_i_reset_n_i
+ I=FE_OFN664_i_reset_n_i
XFE_OFC795_i_reset_n_i BUF1 $PINS O=FE_OFN795_i_reset_n_i
+ I=FE_OFN664_i_reset_n_i
XFE_OFC794_i_reset_n_i BUF1 $PINS O=FE_OFN794_i_reset_n_i
+ I=FE_OFN663_i_reset_n_i
XFE_OFC793_i_reset_n_i BUF2 $PINS O=FE_OFN793_i_reset_n_i
+ I=FE_OFN661_i_reset_n_i
XFE_OFC792_i_reset_n_i BUF1 $PINS O=FE_OFN792_i_reset_n_i
+ I=FE_OFN661_i_reset_n_i
XFE_OFC791_i_reset_n_i BUF1 $PINS O=FE_OFN791_i_reset_n_i
+ I=FE_OFN661_i_reset_n_i
XFE_OFC790_i_reset_n_i BUF1 $PINS O=FE_OFN790_i_reset_n_i
+ I=FE_OFN659_i_reset_n_i
XFE_OFC789_i_reset_n_i BUF1 $PINS O=FE_OFN789_i_reset_n_i
+ I=FE_OFN659_i_reset_n_i
XFE_OFC788_i_reset_n_i BUF2 $PINS O=FE_OFN788_i_reset_n_i
+ I=FE_OFN658_i_reset_n_i
XFE_OFC787_i_reset_n_i BUF2 $PINS O=FE_OFN787_i_reset_n_i
+ I=FE_OFN658_i_reset_n_i
XFE_OFC786_i_reset_n_i BUF1 $PINS O=FE_OFN786_i_reset_n_i
+ I=FE_OFN657_i_reset_n_i
XFE_OFC785_i_reset_n_i BUF1 $PINS O=FE_OFN785_i_reset_n_i
+ I=FE_OFN656_i_reset_n_i
XFE_OFC784_i_reset_n_i BUF1 $PINS O=FE_OFN784_i_reset_n_i
+ I=FE_OFN656_i_reset_n_i
XFE_OFC783_i_reset_n_i BUF1 $PINS O=FE_OFN783_i_reset_n_i
+ I=FE_OFN656_i_reset_n_i
XFE_OFC782_i_reset_n_i BUF2 $PINS O=FE_OFN782_i_reset_n_i
+ I=FE_OFN655_i_reset_n_i
XFE_OFC781_i_reset_n_i BUF1 $PINS O=FE_OFN781_i_reset_n_i
+ I=FE_OFN655_i_reset_n_i
XFE_OFC780_i_reset_n_i BUF1 $PINS O=FE_OFN780_i_reset_n_i
+ I=FE_OFN654_i_reset_n_i
XFE_OFC779_i_reset_n_i BUF2 $PINS O=FE_OFN779_i_reset_n_i
+ I=FE_OFN654_i_reset_n_i
XFE_OFC778_i_reset_n_i BUF2 $PINS O=FE_OFN778_i_reset_n_i
+ I=FE_OFN654_i_reset_n_i
XFE_OFC777_i_reset_n_i BUF2 $PINS O=FE_OFN777_i_reset_n_i
+ I=FE_OFN652_i_reset_n_i
XFE_OFC776_i_reset_n_i BUF1 $PINS O=FE_OFN776_i_reset_n_i
+ I=FE_OFN652_i_reset_n_i
XFE_OFC775_i_reset_n_i BUF1 $PINS O=FE_OFN775_i_reset_n_i
+ I=FE_OFN651_i_reset_n_i
XFE_OFC774_i_reset_n_i BUF1 $PINS O=FE_OFN774_i_reset_n_i
+ I=FE_OFN650_i_reset_n_i
XFE_OFC773_i_reset_n_i BUF2 $PINS O=FE_OFN773_i_reset_n_i
+ I=FE_OFN649_i_reset_n_i
XFE_OFC772_i_reset_n_i BUF1 $PINS O=FE_OFN772_i_reset_n_i
+ I=FE_OFN649_i_reset_n_i
XFE_OFC771_i_reset_n_i BUF2 $PINS O=FE_OFN771_i_reset_n_i
+ I=FE_OFN647_i_reset_n_i
XFE_OFC770_i_reset_n_i BUF1 $PINS O=FE_OFN770_i_reset_n_i
+ I=FE_OFN646_i_reset_n_i
XFE_OFC769_i_reset_n_i INV2 $PINS O=FE_OFN769_i_reset_n_i
+ I=FE_OFN645_i_reset_n_i
XFE_OFC768_i_reset_n_i INV1S $PINS O=FE_OFN768_i_reset_n_i
+ I=FE_OFN645_i_reset_n_i
XFE_OFC767_i_reset_n_i BUF2 $PINS O=FE_OFN767_i_reset_n_i
+ I=FE_OFN639_i_reset_n_i
XFE_OFC766_i_reset_n_i BUF1 $PINS O=FE_OFN766_i_reset_n_i
+ I=FE_OFN636_i_reset_n_i
XFE_OFC765_i_reset_n_i BUF1 $PINS O=FE_OFN765_i_reset_n_i
+ I=FE_OFN636_i_reset_n_i
XFE_OFC764_i_reset_n_i BUF1 $PINS O=FE_OFN764_i_reset_n_i
+ I=FE_OFN633_i_reset_n_i
XFE_OFC763_i_reset_n_i BUF2 $PINS O=FE_OFN763_i_reset_n_i
+ I=FE_OFN631_i_reset_n_i
XFE_OFC762_i_reset_n_i BUF1 $PINS O=FE_OFN762_i_reset_n_i
+ I=FE_OFN631_i_reset_n_i
XFE_OFC761_i_reset_n_i BUF1 $PINS O=FE_OFN761_i_reset_n_i
+ I=FE_OFN631_i_reset_n_i
XFE_OFC760_i_reset_n_i BUF2 $PINS O=FE_OFN760_i_reset_n_i
+ I=FE_OFN629_i_reset_n_i
XFE_OFC759_i_reset_n_i BUF1 $PINS O=FE_OFN759_i_reset_n_i
+ I=FE_OFN629_i_reset_n_i
XFE_OFC758_i_reset_n_i BUF6 $PINS O=FE_OFN758_i_reset_n_i
+ I=FE_OFN627_i_reset_n_i
XFE_OFC757_i_reset_n_i BUF1 $PINS O=FE_OFN757_i_reset_n_i
+ I=FE_OFN626_i_reset_n_i
XFE_OFC756_i_reset_n_i BUF6 $PINS O=FE_OFN756_i_reset_n_i
+ I=FE_OFN625_i_reset_n_i
XFE_OFC755_i_reset_n_i BUF1 $PINS O=FE_OFN755_i_reset_n_i
+ I=FE_OFN624_i_reset_n_i
XFE_OFC754_i_reset_n_i BUF2 $PINS O=FE_OFN754_i_reset_n_i
+ I=FE_OFN622_i_reset_n_i
XFE_OFC753_i_reset_n_i BUF1 $PINS O=FE_OFN753_i_reset_n_i
+ I=FE_OFN622_i_reset_n_i
XFE_OFC752_i_reset_n_i BUF2 $PINS O=FE_OFN752_i_reset_n_i
+ I=FE_OFN620_i_reset_n_i
XFE_OFC751_i_reset_n_i BUF1 $PINS O=FE_OFN751_i_reset_n_i
+ I=FE_OFN620_i_reset_n_i
XFE_OFC750_i_reset_n_i BUF2 $PINS O=FE_OFN750_i_reset_n_i
+ I=FE_OFN619_i_reset_n_i
XFE_OFC749_i_reset_n_i BUF1 $PINS O=FE_OFN749_i_reset_n_i
+ I=FE_OFN618_i_reset_n_i
XFE_OFC748_i_reset_n_i BUF2 $PINS O=FE_OFN748_i_reset_n_i
+ I=FE_OFN616_i_reset_n_i
XFE_OFC747_i_reset_n_i BUF1 $PINS O=FE_OFN747_i_reset_n_i
+ I=FE_OFN616_i_reset_n_i
XFE_OFC745_i_reset_n_i BUF1 $PINS O=FE_OFN745_i_reset_n_i
+ I=FE_OFN614_i_reset_n_i
XFE_OFC744_i_reset_n_i BUF1 $PINS O=FE_OFN744_i_reset_n_i
+ I=FE_OFN614_i_reset_n_i
XFE_OFC743_i_reset_n_i BUF1 $PINS O=FE_OFN743_i_reset_n_i
+ I=FE_OFN613_i_reset_n_i
XFE_OFC742_i_reset_n_i BUF1 $PINS O=FE_OFN742_i_reset_n_i
+ I=FE_OFN613_i_reset_n_i
XFE_OFC741_i_reset_n_i BUF1 $PINS O=FE_OFN741_i_reset_n_i
+ I=FE_OFN611_i_reset_n_i
XFE_OFC740_i_reset_n_i BUF1 $PINS O=FE_OFN740_i_reset_n_i
+ I=FE_OFN608_i_reset_n_i
XFE_OFC739_i_reset_n_i BUF1 $PINS O=FE_OFN739_i_reset_n_i
+ I=FE_OFN608_i_reset_n_i
XFE_OFC738_i_reset_n_i BUF1 $PINS O=FE_OFN738_i_reset_n_i
+ I=FE_OFN608_i_reset_n_i
XFE_OFC737_i_reset_n_i BUF1 $PINS O=FE_OFN737_i_reset_n_i
+ I=FE_OFN607_i_reset_n_i
XFE_OFC736_i_reset_n_i BUF2 $PINS O=FE_OFN736_i_reset_n_i
+ I=FE_OFN607_i_reset_n_i
XFE_OFC735_i_reset_n_i BUF1 $PINS O=FE_OFN735_i_reset_n_i
+ I=FE_OFN606_i_reset_n_i
XFE_OFC734_i_reset_n_i INV1S $PINS O=FE_OFN734_i_reset_n_i
+ I=FE_OFN604_i_reset_n_i
XFE_OFC733_i_reset_n_i INV2 $PINS O=FE_OFN733_i_reset_n_i
+ I=FE_OFN604_i_reset_n_i
XFE_OFC732_i_reset_n_i BUF2 $PINS O=FE_OFN732_i_reset_n_i
+ I=FE_OFN601_i_reset_n_i
XFE_OFC731_i_reset_n_i BUF1 $PINS O=FE_OFN731_i_reset_n_i
+ I=FE_OFN601_i_reset_n_i
XFE_OFC730_i_reset_n_i BUF2 $PINS O=FE_OFN730_i_reset_n_i
+ I=FE_OFN599_i_reset_n_i
XFE_OFC729_i_reset_n_i BUF1 $PINS O=FE_OFN729_i_reset_n_i
+ I=FE_OFN599_i_reset_n_i
XFE_OFC728_i_reset_n_i BUF1 $PINS O=FE_OFN728_i_reset_n_i
+ I=FE_OFN599_i_reset_n_i
XFE_OFC727_i_reset_n_i BUF1 $PINS O=FE_OFN727_i_reset_n_i
+ I=FE_OFN598_i_reset_n_i
XFE_OFC726_i_reset_n_i BUF1 $PINS O=FE_OFN726_i_reset_n_i
+ I=FE_OFN598_i_reset_n_i
XFE_OFC725_i_reset_n_i BUF1 $PINS O=FE_OFN725_i_reset_n_i
+ I=FE_OFN598_i_reset_n_i
XFE_OFC724_i_reset_n_i BUF1 $PINS O=FE_OFN724_i_reset_n_i
+ I=FE_OFN597_i_reset_n_i
XFE_OFC723_i_reset_n_i BUF1 $PINS O=FE_OFN723_i_reset_n_i
+ I=FE_OFN596_i_reset_n_i
XFE_OFC722_i_reset_n_i BUF1 $PINS O=FE_OFN722_i_reset_n_i
+ I=FE_OFN596_i_reset_n_i
XFE_OFC721_i_reset_n_i BUF1 $PINS O=FE_OFN721_i_reset_n_i
+ I=FE_OFN595_i_reset_n_i
XFE_OFC720_i_reset_n_i BUF3 $PINS O=FE_OFN720_i_reset_n_i
+ I=FE_OFN594_i_reset_n_i
XFE_OFC719_i_reset_n_i BUF1 $PINS O=FE_OFN719_i_reset_n_i
+ I=FE_OFN594_i_reset_n_i
XFE_OFC718_i_reset_n_i BUF1 $PINS O=FE_OFN718_i_reset_n_i
+ I=FE_OFN592_i_reset_n_i
XFE_OFC717_i_reset_n_i BUF1 $PINS O=FE_OFN717_i_reset_n_i
+ I=FE_OFN592_i_reset_n_i
XFE_OFC716_i_reset_n_i BUF2 $PINS O=FE_OFN716_i_reset_n_i
+ I=FE_OFN591_i_reset_n_i
XFE_OFC715_i_reset_n_i BUF1 $PINS O=FE_OFN715_i_reset_n_i
+ I=FE_OFN591_i_reset_n_i
XFE_OFC714_i_reset_n_i BUF1 $PINS O=FE_OFN714_i_reset_n_i
+ I=FE_OFN590_i_reset_n_i
XFE_OFC713_i_reset_n_i BUF1 $PINS O=FE_OFN713_i_reset_n_i
+ I=FE_OFN590_i_reset_n_i
XFE_OFC712_i_reset_n_i BUF1 $PINS O=FE_OFN712_i_reset_n_i
+ I=FE_OFN588_i_reset_n_i
XFE_OFC711_i_reset_n_i BUF6 $PINS O=FE_OFN711_i_reset_n_i
+ I=FE_OFN587_i_reset_n_i
XFE_OFC710_i_reset_n_i BUF1 $PINS O=FE_OFN710_i_reset_n_i
+ I=FE_OFN584_i_reset_n_i
XFE_OFC709_i_reset_n_i BUF1 $PINS O=FE_OFN709_i_reset_n_i
+ I=FE_OFN584_i_reset_n_i
XFE_OFC708_i_reset_n_i BUF1 $PINS O=FE_OFN708_i_reset_n_i
+ I=FE_OFN584_i_reset_n_i
XFE_OFC707_i_reset_n_i BUF1 $PINS O=FE_OFN707_i_reset_n_i
+ I=FE_OFN581_i_reset_n_i
XFE_OFC706_i_reset_n_i BUF2 $PINS O=FE_OFN706_i_reset_n_i
+ I=FE_OFN580_i_reset_n_i
XFE_OFC705_i_reset_n_i BUF1 $PINS O=FE_OFN705_i_reset_n_i
+ I=FE_OFN580_i_reset_n_i
XFE_OFC704_i_reset_n_i BUF1 $PINS O=FE_OFN704_i_reset_n_i
+ I=FE_OFN580_i_reset_n_i
XFE_OFC703_i_reset_n_i BUF1 $PINS O=FE_OFN703_i_reset_n_i
+ I=FE_OFN579_i_reset_n_i
XFE_OFC702_i_reset_n_i BUF3 $PINS O=FE_OFN702_i_reset_n_i
+ I=FE_OFN578_i_reset_n_i
XFE_OFC701_i_reset_n_i BUF1 $PINS O=FE_OFN701_i_reset_n_i
+ I=FE_OFN578_i_reset_n_i
XFE_OFC700_i_reset_n_i BUF1 $PINS O=FE_OFN700_i_reset_n_i
+ I=FE_OFN578_i_reset_n_i
XFE_OFC699_i_reset_n_i BUF2 $PINS O=FE_OFN699_i_reset_n_i
+ I=FE_OFN576_i_reset_n_i
XFE_OFC698_i_reset_n_i BUF1 $PINS O=FE_OFN698_i_reset_n_i
+ I=FE_OFN576_i_reset_n_i
XFE_OFC697_i_reset_n_i BUF1 $PINS O=FE_OFN697_i_reset_n_i
+ I=FE_OFN571_i_reset_n_i
XFE_OFC696_i_reset_n_i BUF1 $PINS O=FE_OFN696_i_reset_n_i
+ I=FE_OFN571_i_reset_n_i
XFE_OFC694_i_reset_n_i BUF1 $PINS O=FE_OFN694_i_reset_n_i
+ I=FE_OFN570_i_reset_n_i
XFE_OFC693_i_reset_n_i BUF1 $PINS O=FE_OFN693_i_reset_n_i
+ I=FE_OFN570_i_reset_n_i
XFE_OFC692_i_reset_n_i BUF2 $PINS O=FE_OFN692_i_reset_n_i
+ I=FE_OFN569_i_reset_n_i
XFE_OFC691_i_reset_n_i BUF2 $PINS O=FE_OFN691_i_reset_n_i
+ I=FE_OFN568_i_reset_n_i
XFE_OFC690_i_reset_n_i BUF1 $PINS O=FE_OFN690_i_reset_n_i
+ I=FE_OFN568_i_reset_n_i
XFE_OFC689_i_reset_n_i BUF1 $PINS O=FE_OFN689_i_reset_n_i
+ I=FE_OFN568_i_reset_n_i
XFE_OFC688_i_reset_n_i BUF1 $PINS O=FE_OFN688_i_reset_n_i
+ I=FE_OFN566_i_reset_n_i
XFE_OFC687_i_reset_n_i BUF1 $PINS O=FE_OFN687_i_reset_n_i
+ I=FE_OFN566_i_reset_n_i
XFE_OFC686_i_reset_n_i BUF1 $PINS O=FE_OFN686_i_reset_n_i
+ I=FE_OFN565_i_reset_n_i
XFE_OFC685_i_reset_n_i BUF1 $PINS O=FE_OFN685_i_reset_n_i
+ I=FE_OFN564_i_reset_n_i
XFE_OFC683_i_reset_n_i BUF2 $PINS O=FE_OFN683_i_reset_n_i
+ I=FE_OFN564_i_reset_n_i
XFE_OFC682_i_reset_n_i BUF1 $PINS O=FE_OFN682_i_reset_n_i
+ I=FE_OFN562_i_reset_n_i
XFE_OFC681_i_reset_n_i BUF1 $PINS O=FE_OFN681_i_reset_n_i
+ I=FE_OFN561_i_reset_n_i
XFE_OFC680_i_reset_n_i BUF1 $PINS O=FE_OFN680_i_reset_n_i
+ I=FE_OFN561_i_reset_n_i
XFE_OFC679_i_reset_n_i BUF2 $PINS O=FE_OFN679_i_reset_n_i
+ I=FE_OFN560_i_reset_n_i
XFE_OFC678_i_reset_n_i BUF1 $PINS O=FE_OFN678_i_reset_n_i
+ I=FE_OFN559_i_reset_n_i
XFE_OFC677_i_reset_n_i BUF1 $PINS O=FE_OFN677_i_reset_n_i
+ I=FE_OFN559_i_reset_n_i
XFE_OFC676_i_reset_n_i BUF2 $PINS O=FE_OFN676_i_reset_n_i
+ I=FE_OFN557_i_reset_n_i
XFE_OFC675_i_reset_n_i BUF1 $PINS O=FE_OFN675_i_reset_n_i
+ I=FE_OFN557_i_reset_n_i
XFE_OFC674_i_reset_n_i BUF3 $PINS O=FE_OFN674_i_reset_n_i
+ I=FE_OFN555_i_reset_n_i
XFE_OFC673_i_reset_n_i BUF1 $PINS O=FE_OFN673_i_reset_n_i
+ I=FE_OFN555_i_reset_n_i
XFE_OFC672_i_reset_n_i BUF2 $PINS O=FE_OFN672_i_reset_n_i
+ I=FE_OFN553_i_reset_n_i
XFE_OFC671_i_reset_n_i BUF1 $PINS O=FE_OFN671_i_reset_n_i
+ I=FE_OFN553_i_reset_n_i
XFE_OFC670_i_reset_n_i BUF2 $PINS O=FE_OFN670_i_reset_n_i
+ I=FE_OFN551_i_reset_n_i
XFE_OFC669_i_reset_n_i BUF1 $PINS O=FE_OFN669_i_reset_n_i
+ I=FE_OFN551_i_reset_n_i
XFE_OFC668_i_reset_n_i BUF1 $PINS O=FE_OFN668_i_reset_n_i
+ I=FE_OFN551_i_reset_n_i
XFE_OFC667_i_reset_n_i BUF2 $PINS O=FE_OFN667_i_reset_n_i
+ I=FE_OFN550_i_reset_n_i
XFE_OFC666_i_reset_n_i BUF1 $PINS O=FE_OFN666_i_reset_n_i
+ I=FE_OFN550_i_reset_n_i
XFE_OFC665_i_reset_n_i BUF1 $PINS O=FE_OFN665_i_reset_n_i
+ I=FE_OFN550_i_reset_n_i
XFE_OFC664_i_reset_n_i BUF2 $PINS O=FE_OFN664_i_reset_n_i
+ I=FE_OFN549_i_reset_n_i
XFE_OFC663_i_reset_n_i BUF1 $PINS O=FE_OFN663_i_reset_n_i
+ I=FE_OFN549_i_reset_n_i
XFE_OFC661_i_reset_n_i BUF2 $PINS O=FE_OFN661_i_reset_n_i
+ I=FE_OFN547_i_reset_n_i
XFE_OFC660_i_reset_n_i BUF1 $PINS O=FE_OFN660_i_reset_n_i
+ I=FE_OFN547_i_reset_n_i
XFE_OFC659_i_reset_n_i BUF1 $PINS O=FE_OFN659_i_reset_n_i
+ I=FE_OFN546_i_reset_n_i
XFE_OFC658_i_reset_n_i BUF2 $PINS O=FE_OFN658_i_reset_n_i
+ I=FE_OFN545_i_reset_n_i
XFE_OFC657_i_reset_n_i BUF1 $PINS O=FE_OFN657_i_reset_n_i
+ I=FE_OFN544_i_reset_n_i
XFE_OFC656_i_reset_n_i BUF1 $PINS O=FE_OFN656_i_reset_n_i
+ I=FE_OFN541_i_reset_n_i
XFE_OFC655_i_reset_n_i BUF1 $PINS O=FE_OFN655_i_reset_n_i
+ I=FE_OFN541_i_reset_n_i
XFE_OFC654_i_reset_n_i BUF2 $PINS O=FE_OFN654_i_reset_n_i
+ I=FE_OFN539_i_reset_n_i
XFE_OFC653_i_reset_n_i BUF1 $PINS O=FE_OFN653_i_reset_n_i
+ I=FE_OFN539_i_reset_n_i
XFE_OFC652_i_reset_n_i BUF1 $PINS O=FE_OFN652_i_reset_n_i
+ I=FE_OFN538_i_reset_n_i
XFE_OFC651_i_reset_n_i BUF1 $PINS O=FE_OFN651_i_reset_n_i
+ I=FE_OFN538_i_reset_n_i
XFE_OFC650_i_reset_n_i BUF1 $PINS O=FE_OFN650_i_reset_n_i
+ I=FE_OFN538_i_reset_n_i
XFE_OFC649_i_reset_n_i BUF2 $PINS O=FE_OFN649_i_reset_n_i
+ I=FE_OFN536_i_reset_n_i
XFE_OFC648_i_reset_n_i BUF1 $PINS O=FE_OFN648_i_reset_n_i
+ I=FE_OFN534_i_reset_n_i
XFE_OFC647_i_reset_n_i BUF2 $PINS O=FE_OFN647_i_reset_n_i
+ I=FE_OFN533_i_reset_n_i
XFE_OFC646_i_reset_n_i BUF1 $PINS O=FE_OFN646_i_reset_n_i
+ I=FE_OFN533_i_reset_n_i
XFE_OFC645_i_reset_n_i INV1S $PINS O=FE_OFN645_i_reset_n_i
+ I=FE_OFN531_i_reset_n_i
XFE_OFC644_i_reset_n_i BUF1 $PINS O=FE_OFN644_i_reset_n_i
+ I=FE_OFN531_i_reset_n_i
XFE_OFC643_i_reset_n_i BUF1 $PINS O=FE_OFN643_i_reset_n_i
+ I=FE_OFN530_i_reset_n_i
XFE_OFC642_i_reset_n_i BUF1 $PINS O=FE_OFN642_i_reset_n_i
+ I=FE_OFN530_i_reset_n_i
XFE_OFC641_i_reset_n_i BUF1 $PINS O=FE_OFN641_i_reset_n_i
+ I=FE_OFN527_i_reset_n_i
XFE_OFC640_i_reset_n_i BUF1 $PINS O=FE_OFN640_i_reset_n_i
+ I=FE_OFN526_i_reset_n_i
XFE_OFC639_i_reset_n_i BUF3 $PINS O=FE_OFN639_i_reset_n_i
+ I=FE_OFN525_i_reset_n_i
XFE_OFC638_i_reset_n_i BUF1 $PINS O=FE_OFN638_i_reset_n_i
+ I=FE_OFN525_i_reset_n_i
XFE_OFC637_i_reset_n_i BUF1 $PINS O=FE_OFN637_i_reset_n_i
+ I=FE_OFN525_i_reset_n_i
XFE_OFC636_i_reset_n_i BUF1 $PINS O=FE_OFN636_i_reset_n_i
+ I=FE_OFN524_i_reset_n_i
XFE_OFC634_i_reset_n_i BUF1 $PINS O=FE_OFN634_i_reset_n_i
+ I=FE_OFN524_i_reset_n_i
XFE_OFC633_i_reset_n_i BUF1 $PINS O=FE_OFN633_i_reset_n_i
+ I=FE_OFN523_i_reset_n_i
XFE_OFC632_i_reset_n_i BUF1 $PINS O=FE_OFN632_i_reset_n_i
+ I=FE_OFN523_i_reset_n_i
XFE_OFC631_i_reset_n_i BUF2 $PINS O=FE_OFN631_i_reset_n_i
+ I=FE_OFN522_i_reset_n_i
XFE_OFC629_i_reset_n_i BUF6 $PINS O=FE_OFN629_i_reset_n_i
+ I=FE_OFN521_i_reset_n_i
XFE_OFC628_i_reset_n_i BUF1 $PINS O=FE_OFN628_i_reset_n_i
+ I=FE_OFN521_i_reset_n_i
XFE_OFC627_i_reset_n_i BUF6 $PINS O=FE_OFN627_i_reset_n_i
+ I=FE_OFN519_i_reset_n_i
XFE_OFC626_i_reset_n_i BUF1 $PINS O=FE_OFN626_i_reset_n_i
+ I=FE_OFN519_i_reset_n_i
XFE_OFC625_i_reset_n_i BUF4 $PINS O=FE_OFN625_i_reset_n_i
+ I=FE_OFN518_i_reset_n_i
XFE_OFC624_i_reset_n_i BUF2 $PINS O=FE_OFN624_i_reset_n_i
+ I=FE_OFN514_i_reset_n_i
XFE_OFC622_i_reset_n_i BUF1 $PINS O=FE_OFN622_i_reset_n_i
+ I=FE_OFN516_i_reset_n_i
XFE_OFC620_i_reset_n_i BUF1 $PINS O=FE_OFN620_i_reset_n_i
+ I=FE_OFN516_i_reset_n_i
XFE_OFC619_i_reset_n_i BUF1 $PINS O=FE_OFN619_i_reset_n_i
+ I=FE_OFN516_i_reset_n_i
XFE_OFC618_i_reset_n_i BUF1 $PINS O=FE_OFN618_i_reset_n_i
+ I=FE_OFN515_i_reset_n_i
XFE_OFC616_i_reset_n_i BUF1 $PINS O=FE_OFN616_i_reset_n_i
+ I=FE_OFN514_i_reset_n_i
XFE_OFC615_i_reset_n_i BUF1 $PINS O=FE_OFN615_i_reset_n_i
+ I=FE_OFN513_i_reset_n_i
XFE_OFC614_i_reset_n_i BUF1 $PINS O=FE_OFN614_i_reset_n_i
+ I=FE_OFN513_i_reset_n_i
XFE_OFC613_i_reset_n_i BUF1 $PINS O=FE_OFN613_i_reset_n_i
+ I=FE_OFN512_i_reset_n_i
XFE_OFC612_i_reset_n_i BUF1 $PINS O=FE_OFN612_i_reset_n_i
+ I=FE_OFN512_i_reset_n_i
XFE_OFC611_i_reset_n_i BUF1 $PINS O=FE_OFN611_i_reset_n_i
+ I=FE_OFN511_i_reset_n_i
XFE_OFC610_i_reset_n_i BUF1 $PINS O=FE_OFN610_i_reset_n_i
+ I=FE_OFN511_i_reset_n_i
XFE_OFC609_i_reset_n_i BUF1 $PINS O=FE_OFN609_i_reset_n_i
+ I=FE_OFN511_i_reset_n_i
XFE_OFC608_i_reset_n_i BUF1 $PINS O=FE_OFN608_i_reset_n_i
+ I=FE_OFN510_i_reset_n_i
XFE_OFC607_i_reset_n_i BUF1 $PINS O=FE_OFN607_i_reset_n_i
+ I=FE_OFN508_i_reset_n_i
XFE_OFC606_i_reset_n_i BUF1 $PINS O=FE_OFN606_i_reset_n_i
+ I=FE_OFN508_i_reset_n_i
XFE_OFC605_i_reset_n_i BUF1 $PINS O=FE_OFN605_i_reset_n_i
+ I=FE_OFN508_i_reset_n_i
XFE_OFC604_i_reset_n_i INV1S $PINS O=FE_OFN604_i_reset_n_i
+ I=FE_OFN505_i_reset_n_i
XFE_OFC603_i_reset_n_i BUF1 $PINS O=FE_OFN603_i_reset_n_i
+ I=FE_OFN504_i_reset_n_i
XFE_OFC602_i_reset_n_i BUF1 $PINS O=FE_OFN602_i_reset_n_i
+ I=FE_OFN501_i_reset_n_i
XFE_OFC601_i_reset_n_i BUF2 $PINS O=FE_OFN601_i_reset_n_i
+ I=FE_OFN500_i_reset_n_i
XFE_OFC600_i_reset_n_i BUF1 $PINS O=FE_OFN600_i_reset_n_i
+ I=FE_OFN499_i_reset_n_i
XFE_OFC599_i_reset_n_i BUF1 $PINS O=FE_OFN599_i_reset_n_i
+ I=FE_OFN499_i_reset_n_i
XFE_OFC598_i_reset_n_i BUF1 $PINS O=FE_OFN598_i_reset_n_i
+ I=FE_OFN498_i_reset_n_i
XFE_OFC597_i_reset_n_i BUF1 $PINS O=FE_OFN597_i_reset_n_i
+ I=FE_OFN498_i_reset_n_i
XFE_OFC596_i_reset_n_i BUF1 $PINS O=FE_OFN596_i_reset_n_i
+ I=FE_OFN496_i_reset_n_i
XFE_OFC595_i_reset_n_i BUF1 $PINS O=FE_OFN595_i_reset_n_i
+ I=FE_OFN495_i_reset_n_i
XFE_OFC594_i_reset_n_i BUF2 $PINS O=FE_OFN594_i_reset_n_i
+ I=FE_OFN494_i_reset_n_i
XFE_OFC593_i_reset_n_i BUF1 $PINS O=FE_OFN593_i_reset_n_i
+ I=FE_OFN494_i_reset_n_i
XFE_OFC592_i_reset_n_i BUF1 $PINS O=FE_OFN592_i_reset_n_i
+ I=FE_OFN492_i_reset_n_i
XFE_OFC591_i_reset_n_i BUF1 $PINS O=FE_OFN591_i_reset_n_i
+ I=FE_OFN489_i_reset_n_i
XFE_OFC590_i_reset_n_i BUF1 $PINS O=FE_OFN590_i_reset_n_i
+ I=FE_OFN487_i_reset_n_i
XFE_OFC589_i_reset_n_i BUF1 $PINS O=FE_OFN589_i_reset_n_i
+ I=FE_OFN487_i_reset_n_i
XFE_OFC588_i_reset_n_i BUF1 $PINS O=FE_OFN588_i_reset_n_i
+ I=FE_OFN487_i_reset_n_i
XFE_OFC587_i_reset_n_i BUF3 $PINS O=FE_OFN587_i_reset_n_i
+ I=FE_OFN486_i_reset_n_i
XFE_OFC586_i_reset_n_i BUF1 $PINS O=FE_OFN586_i_reset_n_i
+ I=FE_OFN486_i_reset_n_i
XFE_OFC585_i_reset_n_i BUF1 $PINS O=FE_OFN585_i_reset_n_i
+ I=FE_OFN485_i_reset_n_i
XFE_OFC584_i_reset_n_i BUF1 $PINS O=FE_OFN584_i_reset_n_i
+ I=FE_OFN484_i_reset_n_i
XFE_OFC582_i_reset_n_i BUF1 $PINS O=FE_OFN582_i_reset_n_i
+ I=FE_OFN484_i_reset_n_i
XFE_OFC581_i_reset_n_i BUF1 $PINS O=FE_OFN581_i_reset_n_i
+ I=FE_OFN482_i_reset_n_i
XFE_OFC580_i_reset_n_i BUF2 $PINS O=FE_OFN580_i_reset_n_i
+ I=FE_OFN482_i_reset_n_i
XFE_OFC579_i_reset_n_i BUF1 $PINS O=FE_OFN579_i_reset_n_i
+ I=FE_OFN482_i_reset_n_i
XFE_OFC578_i_reset_n_i BUF2 $PINS O=FE_OFN578_i_reset_n_i
+ I=FE_OFN479_i_reset_n_i
XFE_OFC577_i_reset_n_i BUF1 $PINS O=FE_OFN577_i_reset_n_i
+ I=FE_OFN478_i_reset_n_i
XFE_OFC576_i_reset_n_i BUF1 $PINS O=FE_OFN576_i_reset_n_i
+ I=FE_OFN477_i_reset_n_i
XFE_OFC574_i_reset_n_i BUF1 $PINS O=FE_OFN574_i_reset_n_i
+ I=FE_OFN476_i_reset_n_i
XFE_OFC573_i_reset_n_i BUF1 $PINS O=FE_OFN573_i_reset_n_i
+ I=FE_OFN476_i_reset_n_i
XFE_OFC572_i_reset_n_i BUF1 $PINS O=FE_OFN572_i_reset_n_i
+ I=FE_OFN475_i_reset_n_i
XFE_OFC571_i_reset_n_i BUF1 $PINS O=FE_OFN571_i_reset_n_i
+ I=FE_OFN473_i_reset_n_i
XFE_OFC570_i_reset_n_i BUF1 $PINS O=FE_OFN570_i_reset_n_i
+ I=FE_OFN473_i_reset_n_i
XFE_OFC569_i_reset_n_i BUF2 $PINS O=FE_OFN569_i_reset_n_i
+ I=FE_OFN471_i_reset_n_i
XFE_OFC568_i_reset_n_i BUF2 $PINS O=FE_OFN568_i_reset_n_i
+ I=FE_OFN469_i_reset_n_i
XFE_OFC567_i_reset_n_i BUF1 $PINS O=FE_OFN567_i_reset_n_i
+ I=FE_OFN469_i_reset_n_i
XFE_OFC566_i_reset_n_i BUF1 $PINS O=FE_OFN566_i_reset_n_i
+ I=FE_OFN468_i_reset_n_i
XFE_OFC565_i_reset_n_i BUF1 $PINS O=FE_OFN565_i_reset_n_i
+ I=FE_OFN467_i_reset_n_i
XFE_OFC564_i_reset_n_i BUF1 $PINS O=FE_OFN564_i_reset_n_i
+ I=FE_OFN467_i_reset_n_i
XFE_OFC563_i_reset_n_i BUF1 $PINS O=FE_OFN563_i_reset_n_i
+ I=FE_OFN467_i_reset_n_i
XFE_OFC562_i_reset_n_i BUF1 $PINS O=FE_OFN562_i_reset_n_i
+ I=FE_OFN465_i_reset_n_i
XFE_OFC561_i_reset_n_i BUF1 $PINS O=FE_OFN561_i_reset_n_i
+ I=FE_OFN465_i_reset_n_i
XFE_OFC560_i_reset_n_i BUF2 $PINS O=FE_OFN560_i_reset_n_i
+ I=FE_OFN463_i_reset_n_i
XFE_OFC559_i_reset_n_i BUF1 $PINS O=FE_OFN559_i_reset_n_i
+ I=FE_OFN463_i_reset_n_i
XFE_OFC558_i_reset_n_i BUF1 $PINS O=FE_OFN558_i_reset_n_i
+ I=FE_OFN461_i_reset_n_i
XFE_OFC557_i_reset_n_i BUF1 $PINS O=FE_OFN557_i_reset_n_i
+ I=FE_OFN461_i_reset_n_i
XFE_OFC556_i_reset_n_i BUF1 $PINS O=FE_OFN556_i_reset_n_i
+ I=FE_OFN398_i_reset_n_i
XFE_OFC555_i_reset_n_i BUF2 $PINS O=FE_OFN555_i_reset_n_i
+ I=FE_OFN459_i_reset_n_i
XFE_OFC554_i_reset_n_i BUF1 $PINS O=FE_OFN554_i_reset_n_i
+ I=FE_OFN459_i_reset_n_i
XFE_OFC553_i_reset_n_i INV3 $PINS O=FE_OFN553_i_reset_n_i
+ I=FE_OFN458_i_reset_n_i
XFE_OFC552_i_reset_n_i BUF1 $PINS O=FE_OFN552_i_reset_n_i
+ I=FE_OFN457_i_reset_n_i
XFE_OFC551_i_reset_n_i BUF2 $PINS O=FE_OFN551_i_reset_n_i
+ I=FE_OFN456_i_reset_n_i
XFE_OFC550_i_reset_n_i BUF1 $PINS O=FE_OFN550_i_reset_n_i
+ I=FE_OFN454_i_reset_n_i
XFE_OFC549_i_reset_n_i BUF2 $PINS O=FE_OFN549_i_reset_n_i
+ I=FE_OFN453_i_reset_n_i
XFE_OFC548_i_reset_n_i BUF1 $PINS O=FE_OFN548_i_reset_n_i
+ I=FE_OFN453_i_reset_n_i
XFE_OFC547_i_reset_n_i BUF2 $PINS O=FE_OFN547_i_reset_n_i
+ I=FE_OFN451_i_reset_n_i
XFE_OFC546_i_reset_n_i BUF1 $PINS O=FE_OFN546_i_reset_n_i
+ I=FE_OFN451_i_reset_n_i
XFE_OFC545_i_reset_n_i BUF2 $PINS O=FE_OFN545_i_reset_n_i
+ I=FE_OFN450_i_reset_n_i
XFE_OFC544_i_reset_n_i BUF1 $PINS O=FE_OFN544_i_reset_n_i
+ I=FE_OFN450_i_reset_n_i
XFE_OFC543_i_reset_n_i BUF1 $PINS O=FE_OFN543_i_reset_n_i
+ I=FE_OFN450_i_reset_n_i
XFE_OFC542_i_reset_n_i BUF1 $PINS O=FE_OFN542_i_reset_n_i
+ I=FE_OFN449_i_reset_n_i
XFE_OFC541_i_reset_n_i BUF2 $PINS O=FE_OFN541_i_reset_n_i
+ I=FE_OFN449_i_reset_n_i
XFE_OFC540_i_reset_n_i BUF1 $PINS O=FE_OFN540_i_reset_n_i
+ I=FE_OFN448_i_reset_n_i
XFE_OFC539_i_reset_n_i BUF2 $PINS O=FE_OFN539_i_reset_n_i
+ I=FE_OFN448_i_reset_n_i
XFE_OFC538_i_reset_n_i BUF1 $PINS O=FE_OFN538_i_reset_n_i
+ I=FE_OFN447_i_reset_n_i
XFE_OFC537_i_reset_n_i BUF1 $PINS O=FE_OFN537_i_reset_n_i
+ I=FE_OFN447_i_reset_n_i
XFE_OFC536_i_reset_n_i BUF2 $PINS O=FE_OFN536_i_reset_n_i
+ I=FE_OFN446_i_reset_n_i
XFE_OFC535_i_reset_n_i BUF1 $PINS O=FE_OFN535_i_reset_n_i
+ I=FE_OFN446_i_reset_n_i
XFE_OFC534_i_reset_n_i BUF1 $PINS O=FE_OFN534_i_reset_n_i
+ I=FE_OFN446_i_reset_n_i
XFE_OFC533_i_reset_n_i BUF2 $PINS O=FE_OFN533_i_reset_n_i
+ I=FE_OFN445_i_reset_n_i
XFE_OFC532_i_reset_n_i BUF1 $PINS O=FE_OFN532_i_reset_n_i
+ I=FE_OFN445_i_reset_n_i
XFE_OFC531_i_reset_n_i BUF1 $PINS O=FE_OFN531_i_reset_n_i
+ I=FE_OFN444_i_reset_n_i
XFE_OFC530_i_reset_n_i BUF1 $PINS O=FE_OFN530_i_reset_n_i
+ I=FE_OFN444_i_reset_n_i
XFE_OFC529_i_reset_n_i BUF1 $PINS O=FE_OFN529_i_reset_n_i
+ I=FE_OFN442_i_reset_n_i
XFE_OFC528_i_reset_n_i BUF1 $PINS O=FE_OFN528_i_reset_n_i
+ I=FE_OFN441_i_reset_n_i
XFE_OFC527_i_reset_n_i BUF1 $PINS O=FE_OFN527_i_reset_n_i
+ I=FE_OFN440_i_reset_n_i
XFE_OFC526_i_reset_n_i BUF1 $PINS O=FE_OFN526_i_reset_n_i
+ I=FE_OFN439_i_reset_n_i
XFE_OFC525_i_reset_n_i BUF2 $PINS O=FE_OFN525_i_reset_n_i
+ I=FE_OFN438_i_reset_n_i
XFE_OFC524_i_reset_n_i BUF1 $PINS O=FE_OFN524_i_reset_n_i
+ I=FE_OFN437_i_reset_n_i
XFE_OFC523_i_reset_n_i INV1S $PINS O=FE_OFN523_i_reset_n_i
+ I=FE_OFN436_i_reset_n_i
XFE_OFC522_i_reset_n_i INV3 $PINS O=FE_OFN522_i_reset_n_i
+ I=FE_OFN436_i_reset_n_i
XFE_OFC521_i_reset_n_i BUF2 $PINS O=FE_OFN521_i_reset_n_i
+ I=FE_OFN434_i_reset_n_i
XFE_OFC520_i_reset_n_i BUF1 $PINS O=FE_OFN520_i_reset_n_i
+ I=FE_OFN434_i_reset_n_i
XFE_OFC519_i_reset_n_i BUF6 $PINS O=FE_OFN519_i_reset_n_i
+ I=FE_OFN433_i_reset_n_i
XFE_OFC518_i_reset_n_i BUF2 $PINS O=FE_OFN518_i_reset_n_i
+ I=FE_OFN432_i_reset_n_i
XFE_OFC516_i_reset_n_i INV4 $PINS O=FE_OFN516_i_reset_n_i
+ I=FE_OFN379_i_reset_n_i
XFE_OFC515_i_reset_n_i INV1S $PINS O=FE_OFN515_i_reset_n_i
+ I=FE_OFN379_i_reset_n_i
XFE_OFC514_i_reset_n_i INV2 $PINS O=FE_OFN514_i_reset_n_i
+ I=FE_OFN379_i_reset_n_i
XFE_OFC513_i_reset_n_i INV1S $PINS O=FE_OFN513_i_reset_n_i
+ I=FE_OFN430_i_reset_n_i
XFE_OFC512_i_reset_n_i INV2 $PINS O=FE_OFN512_i_reset_n_i
+ I=FE_OFN430_i_reset_n_i
XFE_OFC511_i_reset_n_i BUF1 $PINS O=FE_OFN511_i_reset_n_i
+ I=FE_OFN429_i_reset_n_i
XFE_OFC510_i_reset_n_i BUF1 $PINS O=FE_OFN510_i_reset_n_i
+ I=FE_OFN429_i_reset_n_i
XFE_OFC509_i_reset_n_i BUF1 $PINS O=FE_OFN509_i_reset_n_i
+ I=FE_OFN428_i_reset_n_i
XFE_OFC508_i_reset_n_i BUF1 $PINS O=FE_OFN508_i_reset_n_i
+ I=FE_OFN428_i_reset_n_i
XFE_OFC505_i_reset_n_i BUF1 $PINS O=FE_OFN505_i_reset_n_i
+ I=FE_OFN427_i_reset_n_i
XFE_OFC504_i_reset_n_i BUF1 $PINS O=FE_OFN504_i_reset_n_i
+ I=FE_OFN427_i_reset_n_i
XFE_OFC502_i_reset_n_i BUF1 $PINS O=FE_OFN502_i_reset_n_i
+ I=FE_OFN426_i_reset_n_i
XFE_OFC501_i_reset_n_i BUF1 $PINS O=FE_OFN501_i_reset_n_i
+ I=FE_OFN426_i_reset_n_i
XFE_OFC500_i_reset_n_i BUF2 $PINS O=FE_OFN500_i_reset_n_i
+ I=FE_OFN425_i_reset_n_i
XFE_OFC499_i_reset_n_i BUF1 $PINS O=FE_OFN499_i_reset_n_i
+ I=FE_OFN424_i_reset_n_i
XFE_OFC498_i_reset_n_i BUF1 $PINS O=FE_OFN498_i_reset_n_i
+ I=FE_OFN423_i_reset_n_i
XFE_OFC497_i_reset_n_i BUF1 $PINS O=FE_OFN497_i_reset_n_i
+ I=FE_OFN423_i_reset_n_i
XFE_OFC496_i_reset_n_i BUF1 $PINS O=FE_OFN496_i_reset_n_i
+ I=FE_OFN346_i_reset_n_i
XFE_OFC495_i_reset_n_i BUF1 $PINS O=FE_OFN495_i_reset_n_i
+ I=FE_OCPN9778_FE_OFN346_i_reset_n_i
XFE_OFC494_i_reset_n_i BUF2 $PINS O=FE_OFN494_i_reset_n_i
+ I=FE_OFN420_i_reset_n_i
XFE_OFC493_i_reset_n_i BUF1 $PINS O=FE_OFN493_i_reset_n_i
+ I=FE_OFN420_i_reset_n_i
XFE_OFC492_i_reset_n_i BUF1 $PINS O=FE_OFN492_i_reset_n_i
+ I=FE_OFN420_i_reset_n_i
XFE_OFC491_i_reset_n_i BUF1 $PINS O=FE_OFN491_i_reset_n_i
+ I=FE_OFN419_i_reset_n_i
XFE_OFC490_i_reset_n_i BUF1 $PINS O=FE_OFN490_i_reset_n_i
+ I=FE_OFN418_i_reset_n_i
XFE_OFC489_i_reset_n_i BUF2 $PINS O=FE_OFN489_i_reset_n_i
+ I=FE_OFN417_i_reset_n_i
XFE_OFC488_i_reset_n_i BUF1 $PINS O=FE_OFN488_i_reset_n_i
+ I=FE_OFN417_i_reset_n_i
XFE_OFC487_i_reset_n_i BUF1 $PINS O=FE_OFN487_i_reset_n_i
+ I=FE_OFN416_i_reset_n_i
XFE_OFC486_i_reset_n_i BUF2 $PINS O=FE_OFN486_i_reset_n_i
+ I=FE_OFN415_i_reset_n_i
XFE_OFC485_i_reset_n_i BUF1 $PINS O=FE_OFN485_i_reset_n_i
+ I=FE_OFN415_i_reset_n_i
XFE_OFC484_i_reset_n_i BUF1 $PINS O=FE_OFN484_i_reset_n_i
+ I=FE_OFN367_i_reset_n_i
XFE_OFC482_i_reset_n_i BUF2 $PINS O=FE_OFN482_i_reset_n_i
+ I=FE_OFN413_i_reset_n_i
XFE_OFC481_i_reset_n_i BUF1 $PINS O=FE_OFN481_i_reset_n_i
+ I=FE_OFN413_i_reset_n_i
XFE_OFC480_i_reset_n_i BUF1 $PINS O=FE_OFN480_i_reset_n_i
+ I=FE_OFN411_i_reset_n_i
XFE_OFC479_i_reset_n_i BUF2 $PINS O=FE_OFN479_i_reset_n_i
+ I=FE_OFN410_i_reset_n_i
XFE_OFC478_i_reset_n_i BUF1 $PINS O=FE_OFN478_i_reset_n_i
+ I=FE_OFN410_i_reset_n_i
XFE_OFC477_i_reset_n_i BUF2 $PINS O=FE_OFN477_i_reset_n_i
+ I=FE_OFN408_i_reset_n_i
XFE_OFC476_i_reset_n_i BUF1 $PINS O=FE_OFN476_i_reset_n_i
+ I=FE_OFN407_i_reset_n_i
XFE_OFC475_i_reset_n_i BUF1 $PINS O=FE_OFN475_i_reset_n_i
+ I=FE_OFN407_i_reset_n_i
XFE_OFC474_i_reset_n_i BUF1 $PINS O=FE_OFN474_i_reset_n_i
+ I=FE_OFN406_i_reset_n_i
XFE_OFC473_i_reset_n_i BUF1 $PINS O=FE_OFN473_i_reset_n_i
+ I=FE_OFN406_i_reset_n_i
XFE_OFC472_i_reset_n_i BUF1 $PINS O=FE_OFN472_i_reset_n_i
+ I=FE_OFN405_i_reset_n_i
XFE_OFC471_i_reset_n_i BUF2 $PINS O=FE_OFN471_i_reset_n_i
+ I=FE_OFN405_i_reset_n_i
XFE_OFC470_i_reset_n_i BUF1 $PINS O=FE_OFN470_i_reset_n_i
+ I=FE_OFN404_i_reset_n_i
XFE_OFC469_i_reset_n_i BUF1 $PINS O=FE_OFN469_i_reset_n_i
+ I=FE_OFN404_i_reset_n_i
XFE_OFC468_i_reset_n_i BUF1 $PINS O=FE_OFN468_i_reset_n_i
+ I=FE_OFN402_i_reset_n_i
XFE_OFC467_i_reset_n_i BUF1 $PINS O=FE_OFN467_i_reset_n_i
+ I=FE_OFN401_i_reset_n_i
XFE_OFC465_i_reset_n_i BUF1 $PINS O=FE_OFN465_i_reset_n_i
+ I=FE_OFN400_i_reset_n_i
XFE_OFC463_i_reset_n_i BUF2 $PINS O=FE_OFN463_i_reset_n_i
+ I=FE_OFN399_i_reset_n_i
XFE_OFC461_i_reset_n_i BUF1 $PINS O=FE_OFN461_i_reset_n_i
+ I=FE_OFN398_i_reset_n_i
XFE_OFC459_i_reset_n_i BUF1 $PINS O=FE_OFN459_i_reset_n_i
+ I=FE_OFN397_i_reset_n_i
XFE_OFC458_i_reset_n_i INV3 $PINS O=FE_OFN458_i_reset_n_i
+ I=FE_OFN396_i_reset_n_i
XFE_OFC457_i_reset_n_i BUF1 $PINS O=FE_OFN457_i_reset_n_i
+ I=FE_OFN396_i_reset_n_i
XFE_OFC456_i_reset_n_i BUF2 $PINS O=FE_OFN456_i_reset_n_i
+ I=FE_OFN395_i_reset_n_i
XFE_OFC455_i_reset_n_i BUF1 $PINS O=FE_OFN455_i_reset_n_i
+ I=FE_OFN391_i_reset_n_i
XFE_OFC454_i_reset_n_i BUF2 $PINS O=FE_OFN454_i_reset_n_i
+ I=FE_OFN391_i_reset_n_i
XFE_OFC453_i_reset_n_i BUF2 $PINS O=FE_OFN453_i_reset_n_i
+ I=FE_OFN393_i_reset_n_i
XFE_OFC452_i_reset_n_i BUF1 $PINS O=FE_OFN452_i_reset_n_i
+ I=FE_OFN393_i_reset_n_i
XFE_OFC451_i_reset_n_i BUF2 $PINS O=FE_OFN451_i_reset_n_i
+ I=FE_OFN392_i_reset_n_i
XFE_OFC450_i_reset_n_i BUF1 $PINS O=FE_OFN450_i_reset_n_i
+ I=FE_OFN391_i_reset_n_i
XFE_OFC449_i_reset_n_i BUF2 $PINS O=FE_OFN449_i_reset_n_i
+ I=FE_OFN390_i_reset_n_i
XFE_OFC448_i_reset_n_i BUF4 $PINS O=FE_OFN448_i_reset_n_i
+ I=FE_OFN389_i_reset_n_i
XFE_OFC447_i_reset_n_i BUF1 $PINS O=FE_OFN447_i_reset_n_i
+ I=FE_OFN388_i_reset_n_i
XFE_OFC446_i_reset_n_i BUF2 $PINS O=FE_OFN446_i_reset_n_i
+ I=FE_OFN387_i_reset_n_i
XFE_OFC445_i_reset_n_i BUF2 $PINS O=FE_OFN445_i_reset_n_i
+ I=FE_OFN386_i_reset_n_i
XFE_OFC444_i_reset_n_i BUF1 $PINS O=FE_OFN444_i_reset_n_i
+ I=FE_OFN385_i_reset_n_i
XFE_OFC442_i_reset_n_i BUF1 $PINS O=FE_OFN442_i_reset_n_i
+ I=FE_OFN385_i_reset_n_i
XFE_OFC441_i_reset_n_i BUF1 $PINS O=FE_OFN441_i_reset_n_i
+ I=FE_OFN384_i_reset_n_i
XFE_OFC440_i_reset_n_i BUF1 $PINS O=FE_OFN440_i_reset_n_i
+ I=FE_OFN384_i_reset_n_i
XFE_OFC439_i_reset_n_i BUF1 $PINS O=FE_OFN439_i_reset_n_i
+ I=FE_OFN384_i_reset_n_i
XFE_OFC438_i_reset_n_i BUF6 $PINS O=FE_OFN438_i_reset_n_i
+ I=FE_OFN383_i_reset_n_i
XFE_OFC437_i_reset_n_i BUF1 $PINS O=FE_OFN437_i_reset_n_i
+ I=FE_OFN381_i_reset_n_i
XFE_OFC436_i_reset_n_i INV1S $PINS O=FE_OFN436_i_reset_n_i
+ I=FE_OFN380_i_reset_n_i
XFE_OFC434_i_reset_n_i INV2 $PINS O=FE_OFN434_i_reset_n_i
+ I=FE_OFN379_i_reset_n_i
XFE_OFC433_i_reset_n_i INV3 $PINS O=FE_OFN433_i_reset_n_i
+ I=FE_OFN379_i_reset_n_i
XFE_OFC432_i_reset_n_i INV4 $PINS O=FE_OFN432_i_reset_n_i
+ I=FE_OFN379_i_reset_n_i
XFE_OFC430_i_reset_n_i INV1S $PINS O=FE_OFN430_i_reset_n_i
+ I=FE_OCPN9786_FE_OFN350_i_reset_n_i
XFE_OFC429_i_reset_n_i INV2 $PINS O=FE_OFN429_i_reset_n_i
+ I=FE_OCPN9777_FE_OFN377_i_reset_n_i
XFE_OFC428_i_reset_n_i INV2 $PINS O=FE_OFN428_i_reset_n_i
+ I=FE_OCPN9777_FE_OFN377_i_reset_n_i
XFE_OFC427_i_reset_n_i BUF1 $PINS O=FE_OFN427_i_reset_n_i
+ I=FE_OCPN9739_FE_OFN344_i_reset_n_i
XFE_OFC426_i_reset_n_i BUF1 $PINS O=FE_OFN426_i_reset_n_i
+ I=FE_OCPN9740_FE_OFN344_i_reset_n_i
XFE_OFC425_i_reset_n_i BUF2 $PINS O=FE_OFN425_i_reset_n_i
+ I=FE_OFN372_i_reset_n_i
XFE_OFC424_i_reset_n_i BUF2 $PINS O=FE_OFN424_i_reset_n_i
+ I=FE_OFN349_i_reset_n_i
XFE_OFC423_i_reset_n_i BUF1 $PINS O=FE_OFN423_i_reset_n_i
+ I=FE_OFN376_i_reset_n_i
XFE_OFC421_i_reset_n_i BUF1 $PINS O=FE_OFN421_i_reset_n_i
+ I=FE_OFN376_i_reset_n_i
XFE_OFC420_i_reset_n_i BUF2 $PINS O=FE_OFN420_i_reset_n_i
+ I=FE_OFN371_i_reset_n_i
XFE_OFC419_i_reset_n_i BUF1 $PINS O=FE_OFN419_i_reset_n_i
+ I=FE_OFN370_i_reset_n_i
XFE_OFC418_i_reset_n_i BUF1 $PINS O=FE_OFN418_i_reset_n_i
+ I=FE_OFN370_i_reset_n_i
XFE_OFC417_i_reset_n_i BUF1 $PINS O=FE_OFN417_i_reset_n_i
+ I=FE_OFN369_i_reset_n_i
XFE_OFC416_i_reset_n_i BUF2 $PINS O=FE_OFN416_i_reset_n_i
+ I=FE_OFN368_i_reset_n_i
XFE_OFC415_i_reset_n_i BUF2 $PINS O=FE_OFN415_i_reset_n_i
+ I=FE_OFN367_i_reset_n_i
XFE_OFC413_i_reset_n_i BUF1 $PINS O=FE_OFN413_i_reset_n_i
+ I=FE_OFN366_i_reset_n_i
XFE_OFC412_i_reset_n_i BUF1 $PINS O=FE_OFN412_i_reset_n_i
+ I=FE_OFN365_i_reset_n_i
XFE_OFC411_i_reset_n_i BUF1 $PINS O=FE_OFN411_i_reset_n_i
+ I=FE_OFN365_i_reset_n_i
XFE_OFC410_i_reset_n_i BUF1 $PINS O=FE_OFN410_i_reset_n_i
+ I=FE_OFN372_i_reset_n_i
XFE_OFC408_i_reset_n_i INV2 $PINS O=FE_OFN408_i_reset_n_i
+ I=FE_OFN347_i_reset_n_i
XFE_OFC407_i_reset_n_i INV1S $PINS O=FE_OFN407_i_reset_n_i
+ I=FE_OFN347_i_reset_n_i
XFE_OFC406_i_reset_n_i INV1S $PINS O=FE_OFN406_i_reset_n_i
+ I=FE_OFN347_i_reset_n_i
XFE_OFC405_i_reset_n_i INV1S $PINS O=FE_OFN405_i_reset_n_i
+ I=FE_OFN347_i_reset_n_i
XFE_OFC404_i_reset_n_i BUF2 $PINS O=FE_OFN404_i_reset_n_i
+ I=FE_OFN362_i_reset_n_i
XFE_OFC403_i_reset_n_i BUF1 $PINS O=FE_OFN403_i_reset_n_i
+ I=FE_OFN362_i_reset_n_i
XFE_OFC402_i_reset_n_i INV2 $PINS O=FE_OFN402_i_reset_n_i
+ I=FE_OFN375_i_reset_n_i
XFE_OFC401_i_reset_n_i INV2 $PINS O=FE_OFN401_i_reset_n_i
+ I=FE_OFN375_i_reset_n_i
XFE_OFC400_i_reset_n_i INV1S $PINS O=FE_OFN400_i_reset_n_i
+ I=FE_OFN345_i_reset_n_i
XFE_OFC399_i_reset_n_i INV2 $PINS O=FE_OFN399_i_reset_n_i
+ I=FE_OFN345_i_reset_n_i
XFE_OFC398_i_reset_n_i INV2 $PINS O=FE_OFN398_i_reset_n_i
+ I=FE_OFN345_i_reset_n_i
XFE_OFC397_i_reset_n_i INV2 $PINS O=FE_OFN397_i_reset_n_i
+ I=FE_OFN375_i_reset_n_i
XFE_OFC396_i_reset_n_i BUF2 $PINS O=FE_OFN396_i_reset_n_i
+ I=FE_OFN359_i_reset_n_i
XFE_OFC395_i_reset_n_i BUF2 $PINS O=FE_OFN395_i_reset_n_i
+ I=FE_OFN359_i_reset_n_i
XFE_OFC393_i_reset_n_i INV2 $PINS O=FE_OFN393_i_reset_n_i
+ I=FE_OFN358_i_reset_n_i
XFE_OFC392_i_reset_n_i INV2 $PINS O=FE_OFN392_i_reset_n_i
+ I=FE_OFN358_i_reset_n_i
XFE_OFC391_i_reset_n_i INV3 $PINS O=FE_OFN391_i_reset_n_i
+ I=FE_OFN358_i_reset_n_i
XFE_OFC390_i_reset_n_i INV2 $PINS O=FE_OFN390_i_reset_n_i
+ I=FE_OFN357_i_reset_n_i
XFE_OFC389_i_reset_n_i INV3 $PINS O=FE_OFN389_i_reset_n_i
+ I=FE_OFN357_i_reset_n_i
XFE_OFC388_i_reset_n_i INV2 $PINS O=FE_OFN388_i_reset_n_i
+ I=FE_OFN357_i_reset_n_i
XFE_OFC387_i_reset_n_i BUF2 $PINS O=FE_OFN387_i_reset_n_i
+ I=FE_OFN356_i_reset_n_i
XFE_OFC386_i_reset_n_i INV2 $PINS O=FE_OFN386_i_reset_n_i
+ I=FE_OFN363_i_reset_n_i
XFE_OFC385_i_reset_n_i INV1S $PINS O=FE_OFN385_i_reset_n_i
+ I=FE_OFN345_i_reset_n_i
XFE_OFC384_i_reset_n_i INV1S $PINS O=FE_OFN384_i_reset_n_i
+ I=FE_OFN345_i_reset_n_i
XFE_OFC383_i_reset_n_i INV3 $PINS O=FE_OFN383_i_reset_n_i
+ I=FE_OFN1124_FE_OFN344_i_reset_n_i
XFE_OFC382_i_reset_n_i INV1S $PINS O=FE_OFN382_i_reset_n_i
+ I=FE_OFN345_i_reset_n_i
XFE_OFC381_i_reset_n_i INV2 $PINS O=FE_OFN381_i_reset_n_i
+ I=FE_OFN347_i_reset_n_i
XFE_OFC380_i_reset_n_i INV2CK $PINS O=FE_OFN380_i_reset_n_i
+ I=FE_OFN363_i_reset_n_i
XFE_OFC379_i_reset_n_i INV12 $PINS O=FE_OFN379_i_reset_n_i
+ I=FE_OFN1123_FE_OFN344_i_reset_n_i
XFE_OFC377_i_reset_n_i INV1S $PINS O=FE_OFN377_i_reset_n_i
+ I=FE_OFN372_i_reset_n_i
XFE_OFC371_i_reset_n_i INV2 $PINS O=FE_OFN371_i_reset_n_i
+ I=FE_OFN374_i_reset_n_i
XFE_OFC370_i_reset_n_i INV1S $PINS O=FE_OFN370_i_reset_n_i
+ I=FE_OFN374_i_reset_n_i
XFE_OFC369_i_reset_n_i INV1S $PINS O=FE_OFN369_i_reset_n_i
+ I=FE_OFN374_i_reset_n_i
XFE_OFC368_i_reset_n_i INV1S $PINS O=FE_OFN368_i_reset_n_i
+ I=FE_OFN374_i_reset_n_i
XFE_OFC367_i_reset_n_i INV3 $PINS O=FE_OFN367_i_reset_n_i
+ I=FE_OFN374_i_reset_n_i
XFE_OFC366_i_reset_n_i INV1S $PINS O=FE_OFN366_i_reset_n_i
+ I=FE_OFN374_i_reset_n_i
XFE_OFC365_i_reset_n_i INV1S $PINS O=FE_OFN365_i_reset_n_i
+ I=FE_OFN347_i_reset_n_i
XFE_OFC359_i_reset_n_i INV4CK $PINS O=FE_OFN359_i_reset_n_i
+ I=FE_OFN363_i_reset_n_i
XFE_OFC358_i_reset_n_i BUF4CK $PINS O=FE_OFN358_i_reset_n_i
+ I=FE_OFN363_i_reset_n_i
XFE_OFC357_i_reset_n_i BUF4CK $PINS O=FE_OFN357_i_reset_n_i
+ I=FE_OFN363_i_reset_n_i
XFE_OFC356_i_reset_n_i INV2 $PINS O=FE_OFN356_i_reset_n_i
+ I=FE_OFN363_i_reset_n_i
XFE_OFC344_i_reset_n_i INV8 $PINS O=FE_OFN344_i_reset_n_i I=rst_n
XFE_OFC343_FE_DBTN1_n7298 INV2 $PINS O=FE_OFN343_FE_DBTN1_n7298
+ I=FE_OFN341_FE_DBTN1_n7298
XFE_OFC342_FE_DBTN1_n7298 INV2 $PINS O=FE_OFN342_FE_DBTN1_n7298
+ I=FE_OFN341_FE_DBTN1_n7298
XFE_OFC341_FE_DBTN1_n7298 INV2 $PINS O=FE_OFN341_FE_DBTN1_n7298
+ I=FE_OFN336_FE_DBTN1_n7298
XFE_OFC340_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN340_FE_DBTN1_n7298
+ I=FE_OFN335_FE_DBTN1_n7298
XFE_OFC339_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN339_FE_DBTN1_n7298
+ I=FE_OFN334_FE_DBTN1_n7298
XFE_OFC338_FE_DBTN1_n7298 INV2 $PINS O=FE_OFN338_FE_DBTN1_n7298
+ I=FE_OFN332_FE_DBTN1_n7298
XFE_OFC337_FE_DBTN1_n7298 INV2 $PINS O=FE_OFN337_FE_DBTN1_n7298
+ I=FE_OFN332_FE_DBTN1_n7298
XFE_OFC336_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN336_FE_DBTN1_n7298
+ I=FE_OFN331_FE_DBTN1_n7298
XFE_OFC335_FE_DBTN1_n7298 INV2 $PINS O=FE_OFN335_FE_DBTN1_n7298
+ I=FE_OFN330_FE_DBTN1_n7298
XFE_OFC334_FE_DBTN1_n7298 INV3 $PINS O=FE_OFN334_FE_DBTN1_n7298
+ I=FE_OFN330_FE_DBTN1_n7298
XFE_OFC333_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN333_FE_DBTN1_n7298
+ I=FE_OFN327_FE_DBTN1_n7298
XFE_OFC332_FE_DBTN1_n7298 INV2 $PINS O=FE_OFN332_FE_DBTN1_n7298
+ I=FE_OFN324_FE_DBTN1_n7298
XFE_OFC331_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN331_FE_DBTN1_n7298
+ I=FE_OFN321_FE_DBTN1_n7298
XFE_OFC330_FE_DBTN1_n7298 INV2 $PINS O=FE_OFN330_FE_DBTN1_n7298
+ I=FE_OFN320_FE_DBTN1_n7298
XFE_OFC329_FE_DBTN1_n7298 INV2 $PINS O=FE_OFN329_FE_DBTN1_n7298
+ I=FE_OFN319_FE_DBTN1_n7298
XFE_OFC328_FE_DBTN1_n7298 INV1S $PINS O=FE_OFN328_FE_DBTN1_n7298
+ I=FE_OFN319_FE_DBTN1_n7298
XFE_OFC327_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN327_FE_DBTN1_n7298
+ I=FE_OFN318_FE_DBTN1_n7298
XFE_OFC326_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN326_FE_DBTN1_n7298
+ I=FE_OFN318_FE_DBTN1_n7298
XFE_OFC325_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN325_FE_DBTN1_n7298
+ I=FE_OFN317_FE_DBTN1_n7298
XFE_OFC324_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN324_FE_DBTN1_n7298
+ I=FE_OFN313_FE_DBTN1_n7298
XFE_OFC323_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN323_FE_DBTN1_n7298
+ I=FE_OFN305_FE_DBTN1_n7298
XFE_OFC322_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN322_FE_DBTN1_n7298
+ I=FE_OFN304_FE_DBTN1_n7298
XFE_OFC321_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN321_FE_DBTN1_n7298
+ I=FE_OFN302_FE_DBTN1_n7298
XFE_OFC320_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN320_FE_DBTN1_n7298
+ I=FE_OFN297_FE_DBTN1_n7298
XFE_OFC319_FE_DBTN1_n7298 INV2 $PINS O=FE_OFN319_FE_DBTN1_n7298
+ I=FE_OFN296_FE_DBTN1_n7298
XFE_OFC318_FE_DBTN1_n7298 INV3CK $PINS O=FE_OFN318_FE_DBTN1_n7298
+ I=FE_OFN294_FE_DBTN1_n7298
XFE_OFC317_FE_DBTN1_n7298 INV2 $PINS O=FE_OFN317_FE_DBTN1_n7298
+ I=FE_OFN294_FE_DBTN1_n7298
XFE_OFC316_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN316_FE_DBTN1_n7298
+ I=FE_OFN293_FE_DBTN1_n7298
XFE_OFC315_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN315_FE_DBTN1_n7298
+ I=FE_OFN292_FE_DBTN1_n7298
XFE_OFC314_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN314_FE_DBTN1_n7298
+ I=FE_OFN289_FE_DBTN1_n7298
XFE_OFC313_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN313_FE_DBTN1_n7298
+ I=FE_OFN275_FE_DBTN1_n7298
XFE_OFC312_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN312_FE_DBTN1_n7298
+ I=FE_OFN275_FE_DBTN1_n7298
XFE_OFC311_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN311_FE_DBTN1_n7298
+ I=FE_OFN275_FE_DBTN1_n7298
XFE_OFC310_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN310_FE_DBTN1_n7298
+ I=FE_OFN274_FE_DBTN1_n7298
XFE_OFC309_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN309_FE_DBTN1_n7298
+ I=FE_OFN273_FE_DBTN1_n7298
XFE_OFC308_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN308_FE_DBTN1_n7298
+ I=FE_OFN272_FE_DBTN1_n7298
XFE_OFC307_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN307_FE_DBTN1_n7298
+ I=FE_OFN272_FE_DBTN1_n7298
XFE_OFC306_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN306_FE_DBTN1_n7298
+ I=FE_OFN272_FE_DBTN1_n7298
XFE_OFC305_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN305_FE_DBTN1_n7298
+ I=FE_OFN270_FE_DBTN1_n7298
XFE_OFC304_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN304_FE_DBTN1_n7298
+ I=FE_OFN270_FE_DBTN1_n7298
XFE_OFC303_FE_DBTN1_n7298 INV1S $PINS O=FE_OFN303_FE_DBTN1_n7298
+ I=FE_OFN269_FE_DBTN1_n7298
XFE_OFC302_FE_DBTN1_n7298 INV3 $PINS O=FE_OFN302_FE_DBTN1_n7298
+ I=FE_OFN269_FE_DBTN1_n7298
XFE_OFC301_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN301_FE_DBTN1_n7298
+ I=FE_OFN268_FE_DBTN1_n7298
XFE_OFC300_FE_DBTN1_n7298 INV1S $PINS O=FE_OFN300_FE_DBTN1_n7298
+ I=FE_OFN263_FE_DBTN1_n7298
XFE_OFC299_FE_DBTN1_n7298 INV1S $PINS O=FE_OFN299_FE_DBTN1_n7298
+ I=FE_OFN263_FE_DBTN1_n7298
XFE_OFC298_FE_DBTN1_n7298 INV1S $PINS O=FE_OFN298_FE_DBTN1_n7298
+ I=FE_OFN262_FE_DBTN1_n7298
XFE_OFC297_FE_DBTN1_n7298 INV3 $PINS O=FE_OFN297_FE_DBTN1_n7298
+ I=FE_OFN262_FE_DBTN1_n7298
XFE_OFC296_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN296_FE_DBTN1_n7298
+ I=FE_OFN255_FE_DBTN1_n7298
XFE_OFC295_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN295_FE_DBTN1_n7298
+ I=FE_OFN253_FE_DBTN1_n7298
XFE_OFC294_FE_DBTN1_n7298 INV2 $PINS O=FE_OFN294_FE_DBTN1_n7298
+ I=FE_OFN253_FE_DBTN1_n7298
XFE_OFC293_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN293_FE_DBTN1_n7298
+ I=FE_OFN251_FE_DBTN1_n7298
XFE_OFC292_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN292_FE_DBTN1_n7298
+ I=FE_OFN250_FE_DBTN1_n7298
XFE_OFC291_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN291_FE_DBTN1_n7298
+ I=FE_OFN233_FE_DBTN1_n7298
XFE_OFC290_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN290_FE_DBTN1_n7298
+ I=FE_OFN228_FE_DBTN1_n7298
XFE_OFC289_FE_DBTN1_n7298 INV1S $PINS O=FE_OFN289_FE_DBTN1_n7298
+ I=FE_OFN225_FE_DBTN1_n7298
XFE_OFC288_FE_DBTN1_n7298 INV1S $PINS O=FE_OFN288_FE_DBTN1_n7298
+ I=FE_OFN225_FE_DBTN1_n7298
XFE_OFC287_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN287_FE_DBTN1_n7298
+ I=FE_OFN223_FE_DBTN1_n7298
XFE_OFC286_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN286_FE_DBTN1_n7298
+ I=FE_OFN223_FE_DBTN1_n7298
XFE_OFC285_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN285_FE_DBTN1_n7298
+ I=FE_OFN223_FE_DBTN1_n7298
XFE_OFC284_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN284_FE_DBTN1_n7298
+ I=FE_OFN222_FE_DBTN1_n7298
XFE_OFC283_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN283_FE_DBTN1_n7298
+ I=FE_OFN222_FE_DBTN1_n7298
XFE_OFC282_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN282_FE_DBTN1_n7298
+ I=FE_OFN221_FE_DBTN1_n7298
XFE_OFC281_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN281_FE_DBTN1_n7298
+ I=FE_OFN221_FE_DBTN1_n7298
XFE_OFC280_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN280_FE_DBTN1_n7298
+ I=FE_OFN221_FE_DBTN1_n7298
XFE_OFC279_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN279_FE_DBTN1_n7298
+ I=FE_OFN218_FE_DBTN1_n7298
XFE_OFC278_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN278_FE_DBTN1_n7298
+ I=FE_OFN218_FE_DBTN1_n7298
XFE_OFC277_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN277_FE_DBTN1_n7298
+ I=FE_OFN218_FE_DBTN1_n7298
XFE_OFC276_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN276_FE_DBTN1_n7298
+ I=FE_OFN216_FE_DBTN1_n7298
XFE_OFC275_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN275_FE_DBTN1_n7298
+ I=FE_OFN214_FE_DBTN1_n7298
XFE_OFC274_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN274_FE_DBTN1_n7298
+ I=FE_OFN214_FE_DBTN1_n7298
XFE_OFC273_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN273_FE_DBTN1_n7298
+ I=FE_OFN213_FE_DBTN1_n7298
XFE_OFC272_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN272_FE_DBTN1_n7298
+ I=FE_OFN213_FE_DBTN1_n7298
XFE_OFC271_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN271_FE_DBTN1_n7298
+ I=FE_OFN212_FE_DBTN1_n7298
XFE_OFC270_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN270_FE_DBTN1_n7298
+ I=FE_OFN210_FE_DBTN1_n7298
XFE_OFC269_FE_DBTN1_n7298 INV2 $PINS O=FE_OFN269_FE_DBTN1_n7298
+ I=FE_OFN208_FE_DBTN1_n7298
XFE_OFC268_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN268_FE_DBTN1_n7298
+ I=FE_OFN208_FE_DBTN1_n7298
XFE_OFC267_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN267_FE_DBTN1_n7298
+ I=FE_OFN207_FE_DBTN1_n7298
XFE_OFC266_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN266_FE_DBTN1_n7298
+ I=FE_OFN207_FE_DBTN1_n7298
XFE_OFC265_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN265_FE_DBTN1_n7298
+ I=FE_OFN206_FE_DBTN1_n7298
XFE_OFC264_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN264_FE_DBTN1_n7298
+ I=FE_OFN206_FE_DBTN1_n7298
XFE_OFC263_FE_DBTN1_n7298 INV1S $PINS O=FE_OFN263_FE_DBTN1_n7298
+ I=FE_OFN205_FE_DBTN1_n7298
XFE_OFC262_FE_DBTN1_n7298 INV2 $PINS O=FE_OFN262_FE_DBTN1_n7298
+ I=FE_OFN201_FE_DBTN1_n7298
XFE_OFC261_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN261_FE_DBTN1_n7298
+ I=FE_OFN199_FE_DBTN1_n7298
XFE_OFC260_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN260_FE_DBTN1_n7298
+ I=FE_OFN199_FE_DBTN1_n7298
XFE_OFC259_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN259_FE_DBTN1_n7298
+ I=FE_OFN198_FE_DBTN1_n7298
XFE_OFC258_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN258_FE_DBTN1_n7298
+ I=FE_OFN198_FE_DBTN1_n7298
XFE_OFC255_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN255_FE_DBTN1_n7298
+ I=FE_OFN196_FE_DBTN1_n7298
XFE_OFC254_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN254_FE_DBTN1_n7298
+ I=FE_OFN196_FE_DBTN1_n7298
XFE_OFC253_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN253_FE_DBTN1_n7298
+ I=FE_OFN195_FE_DBTN1_n7298
XFE_OFC252_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN252_FE_DBTN1_n7298
+ I=FE_OFN195_FE_DBTN1_n7298
XFE_OFC251_FE_DBTN1_n7298 INV2 $PINS O=FE_OFN251_FE_DBTN1_n7298
+ I=FE_OFN193_FE_DBTN1_n7298
XFE_OFC250_FE_DBTN1_n7298 INV3 $PINS O=FE_OFN250_FE_DBTN1_n7298
+ I=FE_OFN193_FE_DBTN1_n7298
XFE_OFC249_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN249_FE_DBTN1_n7298
+ I=FE_OFN192_FE_DBTN1_n7298
XFE_OFC248_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN248_FE_DBTN1_n7298
+ I=FE_OFN191_FE_DBTN1_n7298
XFE_OFC247_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN247_FE_DBTN1_n7298
+ I=FE_OFN191_FE_DBTN1_n7298
XFE_OFC246_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN246_FE_DBTN1_n7298
+ I=FE_OFN189_FE_DBTN1_n7298
XFE_OFC245_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN245_FE_DBTN1_n7298
+ I=FE_OFN188_FE_DBTN1_n7298
XFE_OFC244_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN244_FE_DBTN1_n7298
+ I=FE_OFN187_FE_DBTN1_n7298
XFE_OFC243_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN243_FE_DBTN1_n7298
+ I=FE_OFN187_FE_DBTN1_n7298
XFE_OFC242_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN242_FE_DBTN1_n7298
+ I=FE_OFN186_FE_DBTN1_n7298
XFE_OFC241_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN241_FE_DBTN1_n7298
+ I=FE_OFN185_FE_DBTN1_n7298
XFE_OFC240_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN240_FE_DBTN1_n7298
+ I=FE_OFN185_FE_DBTN1_n7298
XFE_OFC239_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN239_FE_DBTN1_n7298
+ I=FE_OFN184_FE_DBTN1_n7298
XFE_OFC238_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN238_FE_DBTN1_n7298
+ I=FE_OFN182_FE_DBTN1_n7298
XFE_OFC236_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN236_FE_DBTN1_n7298
+ I=FE_OFN178_FE_DBTN1_n7298
XFE_OFC235_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN235_FE_DBTN1_n7298
+ I=FE_OFN178_FE_DBTN1_n7298
XFE_OFC234_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN234_FE_DBTN1_n7298
+ I=FE_OFN175_FE_DBTN1_n7298
XFE_OFC233_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN233_FE_DBTN1_n7298
+ I=FE_OFN174_FE_DBTN1_n7298
XFE_OFC232_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN232_FE_DBTN1_n7298
+ I=FE_OFN174_FE_DBTN1_n7298
XFE_OFC231_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN231_FE_DBTN1_n7298
+ I=FE_OFN174_FE_DBTN1_n7298
XFE_OFC230_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN230_FE_DBTN1_n7298
+ I=FE_OFN170_FE_DBTN1_n7298
XFE_OFC229_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN229_FE_DBTN1_n7298
+ I=FE_OFN168_FE_DBTN1_n7298
XFE_OFC228_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN228_FE_DBTN1_n7298
+ I=FE_OFN166_FE_DBTN1_n7298
XFE_OFC227_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN227_FE_DBTN1_n7298
+ I=FE_OFN164_FE_DBTN1_n7298
XFE_OFC226_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN226_FE_DBTN1_n7298
+ I=FE_OFN164_FE_DBTN1_n7298
XFE_OFC225_FE_DBTN1_n7298 INV1S $PINS O=FE_OFN225_FE_DBTN1_n7298
+ I=FE_OFN163_FE_DBTN1_n7298
XFE_OFC224_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN224_FE_DBTN1_n7298
+ I=FE_OFN162_FE_DBTN1_n7298
XFE_OFC223_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN223_FE_DBTN1_n7298
+ I=FE_OFN161_FE_DBTN1_n7298
XFE_OFC222_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN222_FE_DBTN1_n7298
+ I=FE_OFN161_FE_DBTN1_n7298
XFE_OFC221_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN221_FE_DBTN1_n7298
+ I=FE_OFN160_FE_DBTN1_n7298
XFE_OFC220_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN220_FE_DBTN1_n7298
+ I=FE_OFN160_FE_DBTN1_n7298
XFE_OFC219_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN219_FE_DBTN1_n7298
+ I=FE_OFN160_FE_DBTN1_n7298
XFE_OFC218_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN218_FE_DBTN1_n7298
+ I=FE_OFN158_FE_DBTN1_n7298
XFE_OFC217_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN217_FE_DBTN1_n7298
+ I=FE_OFN158_FE_DBTN1_n7298
XFE_OFC216_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN216_FE_DBTN1_n7298
+ I=FE_OFN156_FE_DBTN1_n7298
XFE_OFC215_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN215_FE_DBTN1_n7298
+ I=FE_OFN155_FE_DBTN1_n7298
XFE_OFC214_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN214_FE_DBTN1_n7298
+ I=FE_OFN155_FE_DBTN1_n7298
XFE_OFC213_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN213_FE_DBTN1_n7298
+ I=FE_OFN153_FE_DBTN1_n7298
XFE_OFC212_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN212_FE_DBTN1_n7298
+ I=FE_OFN153_FE_DBTN1_n7298
XFE_OFC210_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN210_FE_DBTN1_n7298
+ I=FE_OFN151_FE_DBTN1_n7298
XFE_OFC209_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN209_FE_DBTN1_n7298
+ I=FE_OFN151_FE_DBTN1_n7298
XFE_OFC208_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN208_FE_DBTN1_n7298
+ I=FE_OFN150_FE_DBTN1_n7298
XFE_OFC207_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN207_FE_DBTN1_n7298
+ I=FE_OFN147_FE_DBTN1_n7298
XFE_OFC206_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN206_FE_DBTN1_n7298
+ I=FE_OFN147_FE_DBTN1_n7298
XFE_OFC205_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN205_FE_DBTN1_n7298
+ I=FE_OFN145_FE_DBTN1_n7298
XFE_OFC204_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN204_FE_DBTN1_n7298
+ I=FE_OFN144_FE_DBTN1_n7298
XFE_OFC203_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN203_FE_DBTN1_n7298
+ I=FE_OFN144_FE_DBTN1_n7298
XFE_OFC202_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN202_FE_DBTN1_n7298
+ I=FE_OFN143_FE_DBTN1_n7298
XFE_OFC201_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN201_FE_DBTN1_n7298
+ I=FE_OFN141_FE_DBTN1_n7298
XFE_OFC200_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN200_FE_DBTN1_n7298
+ I=FE_OFN141_FE_DBTN1_n7298
XFE_OFC199_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN199_FE_DBTN1_n7298
+ I=FE_OFN140_FE_DBTN1_n7298
XFE_OFC198_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN198_FE_DBTN1_n7298
+ I=FE_OFN140_FE_DBTN1_n7298
XFE_OFC197_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN197_FE_DBTN1_n7298
+ I=FE_OFN138_FE_DBTN1_n7298
XFE_OFC196_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN196_FE_DBTN1_n7298
+ I=FE_OFN138_FE_DBTN1_n7298
XFE_OFC195_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN195_FE_DBTN1_n7298
+ I=FE_OFN134_FE_DBTN1_n7298
XFE_OFC194_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN194_FE_DBTN1_n7298
+ I=FE_OFN134_FE_DBTN1_n7298
XFE_OFC193_FE_DBTN1_n7298 INV2 $PINS O=FE_OFN193_FE_DBTN1_n7298
+ I=FE_OFN133_FE_DBTN1_n7298
XFE_OFC192_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN192_FE_DBTN1_n7298
+ I=FE_OFN130_FE_DBTN1_n7298
XFE_OFC191_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN191_FE_DBTN1_n7298
+ I=FE_OFN130_FE_DBTN1_n7298
XFE_OFC190_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN190_FE_DBTN1_n7298
+ I=FE_OFN130_FE_DBTN1_n7298
XFE_OFC189_FE_DBTN1_n7298 BUF1CK $PINS O=FE_OFN189_FE_DBTN1_n7298
+ I=FE_OFN130_FE_DBTN1_n7298
XFE_OFC188_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN188_FE_DBTN1_n7298
+ I=FE_OFN128_FE_DBTN1_n7298
XFE_OFC187_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN187_FE_DBTN1_n7298
+ I=FE_OFN128_FE_DBTN1_n7298
XFE_OFC186_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN186_FE_DBTN1_n7298
+ I=FE_OFN128_FE_DBTN1_n7298
XFE_OFC185_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN185_FE_DBTN1_n7298
+ I=FE_OFN127_FE_DBTN1_n7298
XFE_OFC184_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN184_FE_DBTN1_n7298
+ I=FE_OFN127_FE_DBTN1_n7298
XFE_OFC183_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN183_FE_DBTN1_n7298
+ I=FE_OFN125_FE_DBTN1_n7298
XFE_OFC182_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN182_FE_DBTN1_n7298
+ I=FE_OFN124_FE_DBTN1_n7298
XFE_OFC181_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN181_FE_DBTN1_n7298
+ I=FE_OFN124_FE_DBTN1_n7298
XFE_OFC180_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN180_FE_DBTN1_n7298
+ I=FE_OFN124_FE_DBTN1_n7298
XFE_OFC179_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN179_FE_DBTN1_n7298
+ I=FE_OFN123_FE_DBTN1_n7298
XFE_OFC178_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN178_FE_DBTN1_n7298
+ I=FE_OFN121_FE_DBTN1_n7298
XFE_OFC176_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN176_FE_DBTN1_n7298
+ I=FE_OFN121_FE_DBTN1_n7298
XFE_OFC175_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN175_FE_DBTN1_n7298
+ I=FE_OFN121_FE_DBTN1_n7298
XFE_OFC174_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN174_FE_DBTN1_n7298
+ I=FE_OFN118_FE_DBTN1_n7298
XFE_OFC173_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN173_FE_DBTN1_n7298
+ I=FE_OFN118_FE_DBTN1_n7298
XFE_OFC172_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN172_FE_DBTN1_n7298
+ I=FE_OFN117_FE_DBTN1_n7298
XFE_OFC171_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN171_FE_DBTN1_n7298
+ I=FE_OFN116_FE_DBTN1_n7298
XFE_OFC170_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN170_FE_DBTN1_n7298
+ I=FE_OFN115_FE_DBTN1_n7298
XFE_OFC169_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN169_FE_DBTN1_n7298
+ I=FE_OFN115_FE_DBTN1_n7298
XFE_OFC168_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN168_FE_DBTN1_n7298
+ I=FE_OFN115_FE_DBTN1_n7298
XFE_OFC167_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN167_FE_DBTN1_n7298
+ I=FE_OFN114_FE_DBTN1_n7298
XFE_OFC166_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN166_FE_DBTN1_n7298
+ I=FE_OFN113_FE_DBTN1_n7298
XFE_OFC165_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN165_FE_DBTN1_n7298
+ I=FE_OFN110_FE_DBTN1_n7298
XFE_OFC164_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN164_FE_DBTN1_n7298
+ I=FE_OFN110_FE_DBTN1_n7298
XFE_OFC163_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN163_FE_DBTN1_n7298
+ I=FE_OFN110_FE_DBTN1_n7298
XFE_OFC162_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN162_FE_DBTN1_n7298
+ I=FE_OFN109_FE_DBTN1_n7298
XFE_OFC161_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN161_FE_DBTN1_n7298
+ I=FE_OFN107_FE_DBTN1_n7298
XFE_OFC160_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN160_FE_DBTN1_n7298
+ I=FE_OFN104_FE_DBTN1_n7298
XFE_OFC159_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN159_FE_DBTN1_n7298
+ I=FE_OFN104_FE_DBTN1_n7298
XFE_OFC158_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN158_FE_DBTN1_n7298
+ I=FE_OFN102_FE_DBTN1_n7298
XFE_OFC156_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN156_FE_DBTN1_n7298
+ I=FE_OFN102_FE_DBTN1_n7298
XFE_OFC155_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN155_FE_DBTN1_n7298
+ I=FE_OFN100_FE_DBTN1_n7298
XFE_OFC154_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN154_FE_DBTN1_n7298
+ I=FE_OFN100_FE_DBTN1_n7298
XFE_OFC153_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN153_FE_DBTN1_n7298
+ I=FE_OFN99_FE_DBTN1_n7298
XFE_OFC152_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN152_FE_DBTN1_n7298
+ I=FE_OFN99_FE_DBTN1_n7298
XFE_OFC151_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN151_FE_DBTN1_n7298
+ I=FE_OFN98_FE_DBTN1_n7298
XFE_OFC150_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN150_FE_DBTN1_n7298
+ I=FE_OFN97_FE_DBTN1_n7298
XFE_OFC148_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN148_FE_DBTN1_n7298
+ I=FE_OFN97_FE_DBTN1_n7298
XFE_OFC147_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN147_FE_DBTN1_n7298
+ I=FE_OFN96_FE_DBTN1_n7298
XFE_OFC146_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN146_FE_DBTN1_n7298
+ I=FE_OFN96_FE_DBTN1_n7298
XFE_OFC145_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN145_FE_DBTN1_n7298
+ I=FE_OFN94_FE_DBTN1_n7298
XFE_OFC144_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN144_FE_DBTN1_n7298
+ I=FE_OFN94_FE_DBTN1_n7298
XFE_OFC143_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN143_FE_DBTN1_n7298
+ I=FE_OFN94_FE_DBTN1_n7298
XFE_OFC142_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN142_FE_DBTN1_n7298
+ I=FE_OFN93_FE_DBTN1_n7298
XFE_OFC141_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN141_FE_DBTN1_n7298
+ I=FE_OFN92_FE_DBTN1_n7298
XFE_OFC140_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN140_FE_DBTN1_n7298
+ I=FE_OFN91_FE_DBTN1_n7298
XFE_OFC139_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN139_FE_DBTN1_n7298
+ I=FE_OFN91_FE_DBTN1_n7298
XFE_OFC138_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN138_FE_DBTN1_n7298
+ I=FE_OFN89_FE_DBTN1_n7298
XFE_OFC137_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN137_FE_DBTN1_n7298
+ I=FE_OFN89_FE_DBTN1_n7298
XFE_OFC136_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN136_FE_DBTN1_n7298
+ I=FE_OFN89_FE_DBTN1_n7298
XFE_OFC135_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN135_FE_DBTN1_n7298
+ I=FE_OFN88_FE_DBTN1_n7298
XFE_OFC134_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN134_FE_DBTN1_n7298
+ I=FE_OFN87_FE_DBTN1_n7298
XFE_OFC133_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN133_FE_DBTN1_n7298
+ I=FE_OFN85_FE_DBTN1_n7298
XFE_OFC132_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN132_FE_DBTN1_n7298
+ I=FE_OFN84_FE_DBTN1_n7298
XFE_OFC131_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN131_FE_DBTN1_n7298
+ I=FE_OFN84_FE_DBTN1_n7298
XFE_OFC130_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN130_FE_DBTN1_n7298
+ I=FE_OFN83_FE_DBTN1_n7298
XFE_OFC129_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN129_FE_DBTN1_n7298
+ I=FE_OFN83_FE_DBTN1_n7298
XFE_OFC128_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN128_FE_DBTN1_n7298
+ I=FE_OFN80_FE_DBTN1_n7298
XFE_OFC127_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN127_FE_DBTN1_n7298
+ I=FE_OFN78_FE_DBTN1_n7298
XFE_OFC126_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN126_FE_DBTN1_n7298
+ I=FE_OFN78_FE_DBTN1_n7298
XFE_OFC125_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN125_FE_DBTN1_n7298
+ I=FE_OFN76_FE_DBTN1_n7298
XFE_OFC124_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN124_FE_DBTN1_n7298
+ I=FE_OFN75_FE_DBTN1_n7298
XFE_OFC123_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN123_FE_DBTN1_n7298
+ I=FE_OFN73_FE_DBTN1_n7298
XFE_OFC122_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN122_FE_DBTN1_n7298
+ I=FE_OFN73_FE_DBTN1_n7298
XFE_OFC121_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN121_FE_DBTN1_n7298
+ I=FE_OFN71_FE_DBTN1_n7298
XFE_OFC120_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN120_FE_DBTN1_n7298
+ I=FE_OFN71_FE_DBTN1_n7298
XFE_OFC119_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN119_FE_DBTN1_n7298
+ I=FE_OFN71_FE_DBTN1_n7298
XFE_OFC118_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN118_FE_DBTN1_n7298
+ I=FE_OFN70_FE_DBTN1_n7298
XFE_OFC117_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN117_FE_DBTN1_n7298
+ I=FE_OFN69_FE_DBTN1_n7298
XFE_OFC116_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN116_FE_DBTN1_n7298
+ I=FE_OFN68_FE_DBTN1_n7298
XFE_OFC115_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN115_FE_DBTN1_n7298
+ I=FE_OFN67_FE_DBTN1_n7298
XFE_OFC114_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN114_FE_DBTN1_n7298
+ I=FE_OFN67_FE_DBTN1_n7298
XFE_OFC113_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN113_FE_DBTN1_n7298
+ I=FE_OFN65_FE_DBTN1_n7298
XFE_OFC112_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN112_FE_DBTN1_n7298
+ I=FE_OFN65_FE_DBTN1_n7298
XFE_OFC111_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN111_FE_DBTN1_n7298
+ I=FE_OFN65_FE_DBTN1_n7298
XFE_OFC110_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN110_FE_DBTN1_n7298
+ I=FE_OFN63_FE_DBTN1_n7298
XFE_OFC109_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN109_FE_DBTN1_n7298
+ I=FE_OFN63_FE_DBTN1_n7298
XFE_OFC107_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN107_FE_DBTN1_n7298
+ I=FE_OFN62_FE_DBTN1_n7298
XFE_OFC106_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN106_FE_DBTN1_n7298
+ I=FE_OFN62_FE_DBTN1_n7298
XFE_OFC105_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN105_FE_DBTN1_n7298
+ I=FE_OFN61_FE_DBTN1_n7298
XFE_OFC104_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN104_FE_DBTN1_n7298
+ I=FE_OFN61_FE_DBTN1_n7298
XFE_OFC103_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN103_FE_DBTN1_n7298
+ I=FE_OFN61_FE_DBTN1_n7298
XFE_OFC102_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN102_FE_DBTN1_n7298
+ I=FE_OFN60_FE_DBTN1_n7298
XFE_OFC101_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN101_FE_DBTN1_n7298
+ I=FE_OFN60_FE_DBTN1_n7298
XFE_OFC100_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN100_FE_DBTN1_n7298
+ I=FE_OFN59_FE_DBTN1_n7298
XFE_OFC99_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN99_FE_DBTN1_n7298
+ I=FE_OFN58_FE_DBTN1_n7298
XFE_OFC98_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN98_FE_DBTN1_n7298
+ I=FE_OFN57_FE_DBTN1_n7298
XFE_OFC97_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN97_FE_DBTN1_n7298
+ I=FE_OFN56_FE_DBTN1_n7298
XFE_OFC96_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN96_FE_DBTN1_n7298
+ I=FE_OFN55_FE_DBTN1_n7298
XFE_OFC95_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN95_FE_DBTN1_n7298
+ I=FE_OFN55_FE_DBTN1_n7298
XFE_OFC94_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN94_FE_DBTN1_n7298
+ I=FE_OFN54_FE_DBTN1_n7298
XFE_OFC93_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN93_FE_DBTN1_n7298
+ I=FE_OFN53_FE_DBTN1_n7298
XFE_OFC92_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN92_FE_DBTN1_n7298
+ I=FE_OFN55_FE_DBTN1_n7298
XFE_OFC91_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN91_FE_DBTN1_n7298
+ I=FE_OFN51_FE_DBTN1_n7298
XFE_OFC90_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN90_FE_DBTN1_n7298
+ I=FE_OFN51_FE_DBTN1_n7298
XFE_OFC89_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN89_FE_DBTN1_n7298
+ I=FE_OFN48_FE_DBTN1_n7298
XFE_OFC88_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN88_FE_DBTN1_n7298
+ I=FE_OFN48_FE_DBTN1_n7298
XFE_OFC87_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN87_FE_DBTN1_n7298
+ I=FE_OFN46_FE_DBTN1_n7298
XFE_OFC86_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN86_FE_DBTN1_n7298
+ I=FE_OFN46_FE_DBTN1_n7298
XFE_OFC85_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN85_FE_DBTN1_n7298
+ I=FE_OFN45_FE_DBTN1_n7298
XFE_OFC84_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN84_FE_DBTN1_n7298
+ I=FE_OFN45_FE_DBTN1_n7298
XFE_OFC83_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN83_FE_DBTN1_n7298
+ I=FE_OFN43_FE_DBTN1_n7298
XFE_OFC82_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN82_FE_DBTN1_n7298
+ I=FE_OFN43_FE_DBTN1_n7298
XFE_OFC81_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN81_FE_DBTN1_n7298
+ I=FE_OFN42_FE_DBTN1_n7298
XFE_OFC80_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN80_FE_DBTN1_n7298
+ I=FE_OFN41_FE_DBTN1_n7298
XFE_OFC79_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN79_FE_DBTN1_n7298
+ I=FE_OFN41_FE_DBTN1_n7298
XFE_OFC78_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN78_FE_DBTN1_n7298
+ I=FE_OFN39_FE_DBTN1_n7298
XFE_OFC77_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN77_FE_DBTN1_n7298
+ I=FE_OFN39_FE_DBTN1_n7298
XFE_OFC76_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN76_FE_DBTN1_n7298
+ I=FE_OFN38_FE_DBTN1_n7298
XFE_OFC75_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN75_FE_DBTN1_n7298
+ I=FE_OFN37_FE_DBTN1_n7298
XFE_OFC73_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN73_FE_DBTN1_n7298
+ I=FE_OFN37_FE_DBTN1_n7298
XFE_OFC71_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN71_FE_DBTN1_n7298
+ I=FE_OFN35_FE_DBTN1_n7298
XFE_OFC70_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN70_FE_DBTN1_n7298
+ I=FE_OFN34_FE_DBTN1_n7298
XFE_OFC69_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN69_FE_DBTN1_n7298
+ I=FE_OFN34_FE_DBTN1_n7298
XFE_OFC68_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN68_FE_DBTN1_n7298
+ I=FE_OFN34_FE_DBTN1_n7298
XFE_OFC67_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN67_FE_DBTN1_n7298
+ I=FE_OFN33_FE_DBTN1_n7298
XFE_OFC66_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN66_FE_DBTN1_n7298
+ I=FE_OFN33_FE_DBTN1_n7298
XFE_OFC65_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN65_FE_DBTN1_n7298
+ I=FE_OFN32_FE_DBTN1_n7298
XFE_OFC64_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN64_FE_DBTN1_n7298
+ I=FE_OFN32_FE_DBTN1_n7298
XFE_OFC63_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN63_FE_DBTN1_n7298
+ I=FE_OFN29_FE_DBTN1_n7298
XFE_OFC62_FE_DBTN1_n7298 INV1S $PINS O=FE_OFN62_FE_DBTN1_n7298
+ I=FE_OFN28_FE_DBTN1_n7298
XFE_OFC61_FE_DBTN1_n7298 INV1S $PINS O=FE_OFN61_FE_DBTN1_n7298
+ I=FE_OFN28_FE_DBTN1_n7298
XFE_OFC60_FE_DBTN1_n7298 INV1S $PINS O=FE_OFN60_FE_DBTN1_n7298
+ I=FE_OFN28_FE_DBTN1_n7298
XFE_OFC59_FE_DBTN1_n7298 INV2 $PINS O=FE_OFN59_FE_DBTN1_n7298
+ I=FE_OFN28_FE_DBTN1_n7298
XFE_OFC58_FE_DBTN1_n7298 INV1S $PINS O=FE_OFN58_FE_DBTN1_n7298
+ I=FE_OFN28_FE_DBTN1_n7298
XFE_OFC57_FE_DBTN1_n7298 INV1S $PINS O=FE_OFN57_FE_DBTN1_n7298
+ I=FE_OFN28_FE_DBTN1_n7298
XFE_OFC56_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN56_FE_DBTN1_n7298
+ I=FE_OFN27_FE_DBTN1_n7298
XFE_OFC55_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN55_FE_DBTN1_n7298
+ I=FE_OFN27_FE_DBTN1_n7298
XFE_OFC54_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN54_FE_DBTN1_n7298
+ I=FE_OFN27_FE_DBTN1_n7298
XFE_OFC53_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN53_FE_DBTN1_n7298
+ I=FE_OFN27_FE_DBTN1_n7298
XFE_OFC51_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN51_FE_DBTN1_n7298
+ I=FE_OFN26_FE_DBTN1_n7298
XFE_OFC50_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN50_FE_DBTN1_n7298
+ I=FE_OFN26_FE_DBTN1_n7298
XFE_OFC49_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN49_FE_DBTN1_n7298
+ I=FE_OFN26_FE_DBTN1_n7298
XFE_OFC48_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN48_FE_DBTN1_n7298
+ I=FE_OFN25_FE_DBTN1_n7298
XFE_OFC46_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN46_FE_DBTN1_n7298
+ I=FE_OFN25_FE_DBTN1_n7298
XFE_OFC45_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN45_FE_DBTN1_n7298
+ I=FE_OFN24_FE_DBTN1_n7298
XFE_OFC44_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN44_FE_DBTN1_n7298
+ I=FE_OFN24_FE_DBTN1_n7298
XFE_OFC43_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN43_FE_DBTN1_n7298
+ I=FE_OFN23_FE_DBTN1_n7298
XFE_OFC42_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN42_FE_DBTN1_n7298
+ I=FE_OFN23_FE_DBTN1_n7298
XFE_OFC41_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN41_FE_DBTN1_n7298
+ I=FE_OFN21_FE_DBTN1_n7298
XFE_OFC40_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN40_FE_DBTN1_n7298
+ I=FE_OFN21_FE_DBTN1_n7298
XFE_OFC39_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN39_FE_DBTN1_n7298
+ I=FE_OFN20_FE_DBTN1_n7298
XFE_OFC38_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN38_FE_DBTN1_n7298
+ I=FE_OFN19_FE_DBTN1_n7298
XFE_OFC37_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN37_FE_DBTN1_n7298
+ I=FE_OFN18_FE_DBTN1_n7298
XFE_OFC36_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN36_FE_DBTN1_n7298
+ I=FE_OFN18_FE_DBTN1_n7298
XFE_OFC35_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN35_FE_DBTN1_n7298
+ I=FE_OFN15_FE_DBTN1_n7298
XFE_OFC34_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN34_FE_DBTN1_n7298
+ I=FE_OFN16_FE_DBTN1_n7298
XFE_OFC33_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN33_FE_DBTN1_n7298
+ I=FE_OFN15_FE_DBTN1_n7298
XFE_OFC32_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN32_FE_DBTN1_n7298
+ I=FE_OFN14_FE_DBTN1_n7298
XFE_OFC31_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN31_FE_DBTN1_n7298
+ I=FE_OFN14_FE_DBTN1_n7298
XFE_OFC30_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN30_FE_DBTN1_n7298
+ I=FE_OFN14_FE_DBTN1_n7298
XFE_OFC29_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN29_FE_DBTN1_n7298
+ I=FE_OFN3_FE_DBTN1_n7298
XFE_OFC28_FE_DBTN1_n7298 BUF2 $PINS O=FE_OFN28_FE_DBTN1_n7298
+ I=FE_OFN11_FE_DBTN1_n7298
XFE_OFC27_FE_DBTN1_n7298 INV3 $PINS O=FE_OFN27_FE_DBTN1_n7298
+ I=FE_OFN11_FE_DBTN1_n7298
XFE_OFC26_FE_DBTN1_n7298 INV1S $PINS O=FE_OFN26_FE_DBTN1_n7298
+ I=FE_OFN11_FE_DBTN1_n7298
XFE_OFC25_FE_DBTN1_n7298 INV2 $PINS O=FE_OFN25_FE_DBTN1_n7298
+ I=FE_OFN11_FE_DBTN1_n7298
XFE_OFC24_FE_DBTN1_n7298 INV1S $PINS O=FE_OFN24_FE_DBTN1_n7298
+ I=FE_OFN11_FE_DBTN1_n7298
XFE_OFC23_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN23_FE_DBTN1_n7298
+ I=FE_OFN10_FE_DBTN1_n7298
XFE_OFC22_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN22_FE_DBTN1_n7298
+ I=FE_OFN10_FE_DBTN1_n7298
XFE_OFC21_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN21_FE_DBTN1_n7298
+ I=FE_OFN2_FE_DBTN1_n7298
XFE_OFC20_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN20_FE_DBTN1_n7298
+ I=FE_OFN7_FE_DBTN1_n7298
XFE_OFC19_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN19_FE_DBTN1_n7298
+ I=FE_OFN1_FE_DBTN1_n7298
XFE_OFC18_FE_DBTN1_n7298 INV1S $PINS O=FE_OFN18_FE_DBTN1_n7298
+ I=FE_OFN5_FE_DBTN1_n7298
XFE_OFC16_FE_DBTN1_n7298 INV1S $PINS O=FE_OFN16_FE_DBTN1_n7298
+ I=FE_OFN5_FE_DBTN1_n7298
XFE_OFC15_FE_DBTN1_n7298 INV2 $PINS O=FE_OFN15_FE_DBTN1_n7298
+ I=FE_OFN5_FE_DBTN1_n7298
XFE_OFC14_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN14_FE_DBTN1_n7298
+ I=FE_OFN4_FE_DBTN1_n7298
XFE_OFC11_FE_DBTN1_n7298 INV4 $PINS O=FE_OFN11_FE_DBTN1_n7298
+ I=FE_OFN3_FE_DBTN1_n7298
XFE_OFC10_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN10_FE_DBTN1_n7298
+ I=FE_OFN2_FE_DBTN1_n7298
XFE_OFC9_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN9_FE_DBTN1_n7298
+ I=FE_OFN2_FE_DBTN1_n7298
XFE_OFC7_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN7_FE_DBTN1_n7298
+ I=FE_OFN1_FE_DBTN1_n7298
XFE_OFC5_FE_DBTN1_n7298 BUF1 $PINS O=FE_OFN5_FE_DBTN1_n7298
+ I=FE_OFN0_FE_DBTN1_n7298
XFE_OFC4_FE_DBTN1_n7298 INV1S $PINS O=FE_OFN4_FE_DBTN1_n7298
+ I=FE_OFN0_FE_DBTN1_n7298
XFE_OFC3_FE_DBTN1_n7298 INV4 $PINS O=FE_OFN3_FE_DBTN1_n7298
+ I=FE_OFN0_FE_DBTN1_n7298
XFE_OFC2_FE_DBTN1_n7298 INV1S $PINS O=FE_OFN2_FE_DBTN1_n7298
+ I=FE_OFN0_FE_DBTN1_n7298
XFE_OFC1_FE_DBTN1_n7298 INV1S $PINS O=FE_OFN1_FE_DBTN1_n7298
+ I=FE_OFN0_FE_DBTN1_n7298
XFE_OFC0_FE_DBTN1_n7298 INV6 $PINS O=FE_OFN0_FE_DBTN1_n7298 I=FE_DBTN1_n7298
XFE_DBTC46_n4426 INV1S $PINS O=FE_DBTN46_n4426 I=n4426
XFE_DBTC42_n3886 INV1S $PINS O=FE_DBTN42_n3886 I=n3886
XFE_DBTC41_n4329 INV2 $PINS O=FE_DBTN41_n4329 I=n4329
XFE_DBTC38_n6714 INV1S $PINS O=FE_DBTN38_n6714 I=n6714
XFE_DBTC36_n9707 INV2 $PINS O=FE_DBTN36_n9707 I=n9707
XFE_DBTC35_weight_0_r_17 INV2 $PINS O=FE_DBTN35_weight_0_r_17
+ I=FE_OFN1261_weight_0_r_17
XFE_DBTC34_weight_0_r_11 INV12 $PINS O=FE_DBTN34_weight_0_r_11
+ I=FE_OFN1275_weight_0_r_11
XFE_DBTC30_data_2_r_33 INV1S $PINS O=FE_DBTN30_data_2_r_33 I=data_2_r[33]
XFE_DBTC29_data_0_r_33 INV1S $PINS O=FE_DBTN29_data_0_r_33 I=data_0_r[33]
XFE_DBTC28_weight_0_r_15 INV2 $PINS O=FE_DBTN28_weight_0_r_15
+ I=FE_OFN1267_weight_0_r_15
XFE_DBTC27_n6338 INV1S $PINS O=FE_DBTN27_n6338 I=n6338
XFE_DBTC26_weight_1_r_15 INV2 $PINS O=FE_DBTN26_weight_1_r_15
+ I=FE_OFN1317_weight_1_r_15
XFE_DBTC24_weight_1_r_13 INV3 $PINS O=FE_DBTN24_weight_1_r_13
+ I=FE_OFN1323_weight_1_r_13
XFE_DBTC23_weight_0_r_23 INV3 $PINS O=FE_DBTN23_weight_0_r_23
+ I=FE_OFN1249_weight_0_r_23
XFE_DBTC22_n3850 INV4 $PINS O=FE_DBTN22_n3850 I=n3850
XFE_DBTC19_n4371 INV2 $PINS O=FE_DBTN19_n4371 I=n4371
XFE_DBTC18_n6407 INV2 $PINS O=FE_DBTN18_n6407 I=n6407
XFE_DBTC16_n5612 INV3 $PINS O=FE_DBTN16_n5612 I=n5612
XFE_DBTC15_n4765 INV1S $PINS O=FE_DBTN15_n4765 I=n4765
XFE_DBTC14_n4987 INV1S $PINS O=FE_DBTN14_n4987 I=n4987
XFE_DBTC13_n5209 INV1S $PINS O=FE_DBTN13_n5209 I=n5209
XFE_DBTC12_weight_2_r_7 INV3 $PINS O=FE_DBTN12_weight_2_r_7
+ I=FE_OFN1400_weight_2_r_7
XFE_DBTC9_n3607 INV2 $PINS O=FE_DBTN9_n3607 I=n3607
XFE_DBTC7_n4532 INV2 $PINS O=FE_DBTN7_n4532 I=n4532
XFE_DBTC6_n7135 INV2 $PINS O=FE_DBTN6_n7135 I=n7135
XFE_DBTC5_n7246 INV2 $PINS O=FE_DBTN5_n7246 I=n7246
XFE_DBTC4_n9073 INV1S $PINS O=FE_DBTN4_n9073 I=n9073
XFE_DBTC1_n7298 INV4 $PINS O=FE_DBTN1_n7298 I=FE_OFN1244_n7298
XFE_DBTC0_weight_0_r_7 INV2 $PINS O=FE_DBTN0_weight_0_r_7 I=weight_0_r[7]
XAdder_relu Adder_relu $PINS i_data_0[24]=pconv_0_r[23] i_data_0[23]=n2078
+ i_data_0[22]=pconv_0_r[22] i_data_0[21]=pconv_0_r[21]
+ i_data_0[20]=pconv_0_r[20] i_data_0[19]=pconv_0_r[19]
+ i_data_0[18]=pconv_0_r[18] i_data_0[17]=pconv_0_r[17]
+ i_data_0[16]=pconv_0_r[16] i_data_0[15]=pconv_0_r[15]
+ i_data_0[14]=pconv_0_r[14] i_data_0[13]=pconv_0_r[13]
+ i_data_0[12]=pconv_0_r[12] i_data_0[11]=pconv_0_r[11]
+ i_data_0[10]=pconv_0_r[10] i_data_0[9]=pconv_0_r[9] i_data_0[8]=pconv_0_r[8]
+ i_data_0[7]=pconv_0_r[7] i_data_0[6]=pconv_0_r[6] i_data_0[5]=pconv_0_r[5]
+ i_data_0[4]=pconv_0_r[4] i_data_0[3]=pconv_0_r[3] i_data_0[2]=pconv_0_r[2]
+ i_data_0[1]=pconv_0_r[1] i_data_0[0]=pconv_0_r[0] i_data_1[24]=pconv_1_r[23]
+ i_data_1[23]=pconv_1_r[23] i_data_1[22]=pconv_1_r[22]
+ i_data_1[21]=pconv_1_r[21] i_data_1[20]=pconv_1_r[20]
+ i_data_1[19]=pconv_1_r[19] i_data_1[18]=pconv_1_r[18]
+ i_data_1[17]=pconv_1_r[17] i_data_1[16]=pconv_1_r[16]
+ i_data_1[15]=pconv_1_r[15] i_data_1[14]=pconv_1_r[14]
+ i_data_1[13]=pconv_1_r[13] i_data_1[12]=pconv_1_r[12]
+ i_data_1[11]=pconv_1_r[11] i_data_1[10]=pconv_1_r[10] i_data_1[9]=pconv_1_r[9]
+ i_data_1[8]=pconv_1_r[8] i_data_1[7]=pconv_1_r[7] i_data_1[6]=pconv_1_r[6]
+ i_data_1[5]=pconv_1_r[5] i_data_1[4]=pconv_1_r[4] i_data_1[3]=pconv_1_r[3]
+ i_data_1[2]=pconv_1_r[2] i_data_1[1]=pconv_1_r[1] i_data_1[0]=pconv_1_r[0]
+ i_data_2[24]=pconv_2_r[23] i_data_2[23]=n2078 i_data_2[22]=pconv_2_r[22]
+ i_data_2[21]=pconv_2_r[21] i_data_2[20]=pconv_2_r[20]
+ i_data_2[19]=pconv_2_r[19] i_data_2[18]=pconv_2_r[18]
+ i_data_2[17]=pconv_2_r[17] i_data_2[16]=pconv_2_r[16]
+ i_data_2[15]=pconv_2_r[15] i_data_2[14]=pconv_2_r[14]
+ i_data_2[13]=pconv_2_r[13] i_data_2[12]=pconv_2_r[12]
+ i_data_2[11]=pconv_2_r[11] i_data_2[10]=pconv_2_r[10] i_data_2[9]=pconv_2_r[9]
+ i_data_2[8]=pconv_2_r[8] i_data_2[7]=pconv_2_r[7] i_data_2[6]=pconv_2_r[6]
+ i_data_2[5]=pconv_2_r[5] i_data_2[4]=pconv_2_r[4] i_data_2[3]=pconv_2_r[3]
+ i_data_2[2]=pconv_2_r[2] i_data_2[1]=pconv_2_r[1] i_data_2[0]=pconv_2_r[0]
+ o_data[20]=SYNOPSYS_UNCONNECTED__0 o_data[19]=SYNOPSYS_UNCONNECTED__1
+ o_data[18]=conv[18] o_data[17]=conv[17] o_data[16]=conv[16] o_data[15]=conv[15]
+ o_data[14]=conv[14] o_data[13]=conv[13] o_data[12]=conv[12] o_data[11]=conv[11]
+ o_data[10]=conv[10] o_data[9]=conv[9] o_data[8]=conv[8] o_data[7]=conv[7]
+ o_data[6]=conv[6] o_data[5]=conv[5] o_data[4]=conv[4] o_data[3]=conv[3]
+ o_data[2]=conv[2] o_data[1]=conv[1] o_data[0]=conv[0]
XpMaxPool pMaxPool_1 $PINS i_data_0[20]=n2078 i_data_0[19]=n2078
+ i_data_0[18]=buffer_conv[39] i_data_0[17]=buffer_conv[38]
+ i_data_0[16]=buffer_conv[37] i_data_0[15]=buffer_conv[36]
+ i_data_0[14]=buffer_conv[35] i_data_0[13]=buffer_conv[34]
+ i_data_0[12]=buffer_conv[33] i_data_0[11]=buffer_conv[32]
+ i_data_0[10]=buffer_conv[31] i_data_0[9]=buffer_conv[30]
+ i_data_0[8]=buffer_conv[29] i_data_0[7]=buffer_conv[28]
+ i_data_0[6]=buffer_conv[27] i_data_0[5]=buffer_conv[26]
+ i_data_0[4]=buffer_conv[25] i_data_0[3]=buffer_conv[24]
+ i_data_0[2]=buffer_conv[23] i_data_0[1]=buffer_conv[22]
+ i_data_0[0]=buffer_conv[21] i_data_1[20]=n2078 i_data_1[19]=n2078
+ i_data_1[18]=conv_1_r[18] i_data_1[17]=conv_1_r[17] i_data_1[16]=conv_1_r[16]
+ i_data_1[15]=conv_1_r[15] i_data_1[14]=conv_1_r[14] i_data_1[13]=conv_1_r[13]
+ i_data_1[12]=conv_1_r[12] i_data_1[11]=conv_1_r[11] i_data_1[10]=conv_1_r[10]
+ i_data_1[9]=conv_1_r[9] i_data_1[8]=conv_1_r[8] i_data_1[7]=conv_1_r[7]
+ i_data_1[6]=conv_1_r[6] i_data_1[5]=conv_1_r[5] i_data_1[4]=conv_1_r[4]
+ i_data_1[3]=conv_1_r[3] i_data_1[2]=conv_1_r[2] i_data_1[1]=conv_1_r[1]
+ i_data_1[0]=conv_1_r[0] o_data[20]=SYNOPSYS_UNCONNECTED__2
+ o_data[19]=SYNOPSYS_UNCONNECTED__3 o_data[18]=pmp[18] o_data[17]=pmp[17]
+ o_data[16]=pmp[16] o_data[15]=pmp[15] o_data[14]=pmp[14] o_data[13]=pmp[13]
+ o_data[12]=pmp[12] o_data[11]=pmp[11] o_data[10]=pmp[10] o_data[9]=pmp[9]
+ o_data[8]=pmp[8] o_data[7]=pmp[7] o_data[6]=pmp[6] o_data[5]=pmp[5]
+ o_data[4]=pmp[4] o_data[3]=pmp[3] o_data[2]=pmp[2] o_data[1]=pmp[1]
+ o_data[0]=pmp[0]
XMaxPool pMaxPool_0 $PINS i_data_0[20]=n2078 i_data_0[19]=n2078
+ i_data_0[18]=buffer_pmp[39] i_data_0[17]=buffer_pmp[38]
+ i_data_0[16]=buffer_pmp[37] i_data_0[15]=buffer_pmp[36]
+ i_data_0[14]=buffer_pmp[35] i_data_0[13]=buffer_pmp[34]
+ i_data_0[12]=buffer_pmp[33] i_data_0[11]=buffer_pmp[32]
+ i_data_0[10]=buffer_pmp[31] i_data_0[9]=buffer_pmp[30]
+ i_data_0[8]=buffer_pmp[29] i_data_0[7]=buffer_pmp[28]
+ i_data_0[6]=buffer_pmp[27] i_data_0[5]=buffer_pmp[26]
+ i_data_0[4]=buffer_pmp[25] i_data_0[3]=buffer_pmp[24]
+ i_data_0[2]=buffer_pmp[23] i_data_0[1]=buffer_pmp[22]
+ i_data_0[0]=buffer_pmp[21] i_data_1[20]=n2078 i_data_1[19]=n2078
+ i_data_1[18]=pmp_1_r[18] i_data_1[17]=pmp_1_r[17] i_data_1[16]=pmp_1_r[16]
+ i_data_1[15]=pmp_1_r[15] i_data_1[14]=pmp_1_r[14] i_data_1[13]=pmp_1_r[13]
+ i_data_1[12]=pmp_1_r[12] i_data_1[11]=pmp_1_r[11] i_data_1[10]=pmp_1_r[10]
+ i_data_1[9]=pmp_1_r[9] i_data_1[8]=pmp_1_r[8] i_data_1[7]=pmp_1_r[7]
+ i_data_1[6]=pmp_1_r[6] i_data_1[5]=pmp_1_r[5] i_data_1[4]=pmp_1_r[4]
+ i_data_1[3]=pmp_1_r[3] i_data_1[2]=pmp_1_r[2] i_data_1[1]=pmp_1_r[1]
+ i_data_1[0]=pmp_1_r[0] o_data[20]=SYNOPSYS_UNCONNECTED__4
+ o_data[19]=SYNOPSYS_UNCONNECTED__5 o_data[18]=SYNOPSYS_UNCONNECTED__6
+ o_data[17]=SYNOPSYS_UNCONNECTED__7 o_data[16]=SYNOPSYS_UNCONNECTED__8
+ o_data[15]=SYNOPSYS_UNCONNECTED__9 o_data[14]=o_data_temp[14]
+ o_data[13]=o_data_temp[13] o_data[12]=o_data_temp[12]
+ o_data[11]=o_data_temp[11] o_data[10]=o_data_temp[10] o_data[9]=o_data_temp[9]
+ o_data[8]=o_data_temp[8] o_data[7]=o_data_temp[7] o_data[6]=o_data_temp[6]
+ o_data[5]=o_data_temp[5] o_data[4]=o_data_temp[4] o_data[3]=o_data_temp[3]
+ o_data[2]=o_data_temp[2] o_data[1]=o_data_temp[1] o_data[0]=o_data_temp[0]
Xpconv_0_r_reg[23] QDFFRBN $PINS Q=pconv_0_r[23] D=pconv_0_w[24] CK=CTS_28
+ RB=FE_OFN643_i_reset_n_i
Xpconv_0_r_reg[22] QDFFRBN $PINS Q=pconv_0_r[22] D=pconv_0_w[22] CK=CTS_49
+ RB=FE_OFN387_i_reset_n_i
Xpconv_0_r_reg[21] QDFFRBN $PINS Q=pconv_0_r[21] D=pconv_0_w[21] CK=CTS_49
+ RB=FE_OFN387_i_reset_n_i
Xpconv_0_r_reg[20] QDFFRBN $PINS Q=pconv_0_r[20] D=pconv_0_w[20] CK=CTS_49
+ RB=FE_OFN387_i_reset_n_i
Xpconv_0_r_reg[19] QDFFRBN $PINS Q=pconv_0_r[19] D=pconv_0_w[19] CK=CTS_49
+ RB=FE_OFN387_i_reset_n_i
Xpconv_0_r_reg[18] QDFFRBN $PINS Q=pconv_0_r[18] D=pconv_0_w[18] CK=CTS_49
+ RB=FE_OFN1025_i_reset_n_i
Xpconv_0_r_reg[17] QDFFRBN $PINS Q=pconv_0_r[17] D=pconv_0_w[17] CK=CTS_49
+ RB=FE_OFN356_i_reset_n_i
Xpconv_0_r_reg[16] QDFFRBN $PINS Q=pconv_0_r[16] D=pconv_0_w[16] CK=CTS_49
+ RB=FE_OFN356_i_reset_n_i
Xpconv_0_r_reg[15] QDFFRBN $PINS Q=pconv_0_r[15] D=pconv_0_w[15] CK=CTS_49
+ RB=FE_OFN356_i_reset_n_i
Xpconv_0_r_reg[14] QDFFRBN $PINS Q=pconv_0_r[14] D=pconv_0_w[14] CK=CTS_49
+ RB=FE_OFN356_i_reset_n_i
Xpconv_0_r_reg[13] QDFFRBN $PINS Q=pconv_0_r[13] D=pconv_0_w[13] CK=CTS_49
+ RB=FE_OFN387_i_reset_n_i
Xpconv_0_r_reg[12] QDFFRBN $PINS Q=pconv_0_r[12] D=pconv_0_w[12] CK=CTS_49
+ RB=FE_OFN535_i_reset_n_i
Xpconv_0_r_reg[11] QDFFRBN $PINS Q=pconv_0_r[11] D=pconv_0_w[11] CK=CTS_49
+ RB=FE_OFN446_i_reset_n_i
Xpconv_0_r_reg[10] QDFFRBN $PINS Q=pconv_0_r[10] D=pconv_0_w[10] CK=CTS_49
+ RB=FE_OFN648_i_reset_n_i
Xpconv_0_r_reg[9] QDFFRBN $PINS Q=pconv_0_r[9] D=pconv_0_w[9] CK=CTS_49
+ RB=FE_OFN648_i_reset_n_i
Xpconv_0_r_reg[8] QDFFRBN $PINS Q=pconv_0_r[8] D=pconv_0_w[8] CK=CTS_49
+ RB=FE_OFN536_i_reset_n_i
Xpconv_0_r_reg[7] QDFFRBN $PINS Q=pconv_0_r[7] D=pconv_0_w[7] CK=CTS_49
+ RB=FE_OFN535_i_reset_n_i
Xpconv_0_r_reg[6] QDFFRBN $PINS Q=pconv_0_r[6] D=pconv_0_w[6] CK=CTS_28
+ RB=FE_OFN638_i_reset_n_i
Xpconv_0_r_reg[5] QDFFRBN $PINS Q=pconv_0_r[5] D=pconv_0_w[5] CK=CTS_28
+ RB=FE_OFN442_i_reset_n_i
Xpconv_0_r_reg[4] QDFFRBN $PINS Q=pconv_0_r[4] D=pconv_0_w[4] CK=CTS_28
+ RB=FE_OFN638_i_reset_n_i
Xpconv_0_r_reg[3] QDFFRBN $PINS Q=pconv_0_r[3] D=pconv_0_w[3] CK=CTS_34
+ RB=FE_OFN640_i_reset_n_i
Xpconv_0_r_reg[2] QDFFRBN $PINS Q=pconv_0_r[2] D=pconv_0_w[2] CK=CTS_34
+ RB=FE_OFN640_i_reset_n_i
Xpconv_0_r_reg[1] QDFFRBN $PINS Q=pconv_0_r[1] D=pconv_0_w[1] CK=CTS_34
+ RB=FE_OFN640_i_reset_n_i
Xpconv_0_r_reg[0] QDFFRBN $PINS Q=pconv_0_r[0] D=pconv_0_w[0] CK=CTS_34
+ RB=FE_OFN526_i_reset_n_i
Xpconv_1_r_reg[23] QDFFRBN $PINS Q=pconv_1_r[23] D=pconv_1_w[24] CK=CTS_52
+ RB=FE_OFN650_i_reset_n_i
Xpconv_1_r_reg[22] QDFFRBN $PINS Q=pconv_1_r[22] D=pconv_1_w[22] CK=CTS_52
+ RB=FE_OFN652_i_reset_n_i
Xpconv_1_r_reg[21] QDFFRBN $PINS Q=pconv_1_r[21] D=pconv_1_w[21] CK=CTS_52
+ RB=FE_OFN775_i_reset_n_i
Xpconv_1_r_reg[19] QDFFRBN $PINS Q=pconv_1_r[19] D=pconv_1_w[19] CK=CTS_52
+ RB=FE_OFN777_i_reset_n_i
Xpconv_1_r_reg[18] QDFFRBN $PINS Q=pconv_1_r[18] D=pconv_1_w[18] CK=CTS_52
+ RB=FE_OFN538_i_reset_n_i
Xpconv_1_r_reg[17] QDFFRBN $PINS Q=pconv_1_r[17] D=pconv_1_w[17] CK=CTS_52
+ RB=FE_OFN652_i_reset_n_i
Xpconv_1_r_reg[16] QDFFRBN $PINS Q=pconv_1_r[16] D=pconv_1_w[16] CK=CTS_52
+ RB=FE_OFN775_i_reset_n_i
Xpconv_1_r_reg[15] QDFFRBN $PINS Q=pconv_1_r[15] D=pconv_1_w[15] CK=CTS_52
+ RB=FE_OFN651_i_reset_n_i
Xpconv_1_r_reg[14] QDFFRBN $PINS Q=pconv_1_r[14] D=pconv_1_w[14] CK=CTS_52
+ RB=FE_OFN775_i_reset_n_i
Xpconv_1_r_reg[13] QDFFRBN $PINS Q=pconv_1_r[13] D=pconv_1_w[13] CK=CTS_52
+ RB=FE_OFN775_i_reset_n_i
Xpconv_1_r_reg[12] QDFFRBN $PINS Q=pconv_1_r[12] D=pconv_1_w[12] CK=CTS_52
+ RB=FE_OFN775_i_reset_n_i
Xpconv_1_r_reg[11] QDFFRBN $PINS Q=pconv_1_r[11] D=pconv_1_w[11] CK=CTS_52
+ RB=FE_OFN775_i_reset_n_i
Xpconv_1_r_reg[10] QDFFRBN $PINS Q=pconv_1_r[10] D=pconv_1_w[10] CK=CTS_49
+ RB=FE_OFN648_i_reset_n_i
Xpconv_1_r_reg[9] QDFFRBN $PINS Q=pconv_1_r[9] D=pconv_1_w[9] CK=CTS_49
+ RB=FE_OFN648_i_reset_n_i
Xpconv_1_r_reg[8] QDFFRBN $PINS Q=pconv_1_r[8] D=pconv_1_w[8] CK=CTS_49
+ RB=FE_OFN648_i_reset_n_i
Xpconv_1_r_reg[7] QDFFRBN $PINS Q=pconv_1_r[7] D=pconv_1_w[7] CK=CTS_49
+ RB=FE_OFN648_i_reset_n_i
Xpconv_1_r_reg[6] QDFFRBN $PINS Q=pconv_1_r[6] D=pconv_1_w[6] CK=CTS_49
+ RB=FE_OFN446_i_reset_n_i
Xpconv_1_r_reg[5] QDFFRBN $PINS Q=pconv_1_r[5] D=pconv_1_w[5] CK=CTS_49
+ RB=FE_OFN534_i_reset_n_i
Xpconv_1_r_reg[4] QDFFRBN $PINS Q=pconv_1_r[4] D=pconv_1_w[4] CK=CTS_49
+ RB=FE_OFN446_i_reset_n_i
Xpconv_1_r_reg[3] QDFFRBN $PINS Q=pconv_1_r[3] D=pconv_1_w[3] CK=CTS_49
+ RB=FE_OFN535_i_reset_n_i
Xpconv_1_r_reg[2] QDFFRBN $PINS Q=pconv_1_r[2] D=pconv_1_w[2] CK=CTS_49
+ RB=FE_OFN535_i_reset_n_i
Xpconv_1_r_reg[1] QDFFRBN $PINS Q=pconv_1_r[1] D=pconv_1_w[1] CK=CTS_49
+ RB=FE_OFN536_i_reset_n_i
Xpconv_1_r_reg[0] QDFFRBN $PINS Q=pconv_1_r[0] D=pconv_1_w[0] CK=CTS_49
+ RB=FE_OFN536_i_reset_n_i
Xpconv_2_r_reg[23] QDFFRBN $PINS Q=pconv_2_r[23] D=pconv_2_w[24] CK=CTS_49
+ RB=FE_OFN1028_i_reset_n_i
Xpconv_2_r_reg[22] QDFFRBN $PINS Q=pconv_2_r[22] D=pconv_2_w[22] CK=CTS_49
+ RB=FE_OFN1065_i_reset_n_i
Xpconv_2_r_reg[21] QDFFRBN $PINS Q=pconv_2_r[21] D=pconv_2_w[21] CK=CTS_49
+ RB=FE_OFN1065_i_reset_n_i
Xpconv_2_r_reg[20] QDFFRBN $PINS Q=pconv_2_r[20] D=pconv_2_w[20] CK=CTS_46
+ RB=FE_OFN1028_i_reset_n_i
Xpconv_2_r_reg[19] QDFFRBN $PINS Q=pconv_2_r[19] D=pconv_2_w[19] CK=CTS_46
+ RB=FE_OFN1028_i_reset_n_i
Xpconv_2_r_reg[18] QDFFRBN $PINS Q=pconv_2_r[18] D=pconv_2_w[18] CK=CTS_46
+ RB=FE_OFN1028_i_reset_n_i
Xpconv_2_r_reg[17] QDFFRBN $PINS Q=pconv_2_r[17] D=pconv_2_w[17] CK=CTS_49
+ RB=FE_OFN1065_i_reset_n_i
Xpconv_2_r_reg[16] QDFFRBN $PINS Q=pconv_2_r[16] D=pconv_2_w[16] CK=CTS_49
+ RB=FE_OFN1065_i_reset_n_i
Xpconv_2_r_reg[15] QDFFRBN $PINS Q=pconv_2_r[15] D=pconv_2_w[15] CK=CTS_49
+ RB=FE_OFN1065_i_reset_n_i
Xpconv_2_r_reg[14] QDFFRBN $PINS Q=pconv_2_r[14] D=pconv_2_w[14] CK=CTS_49
+ RB=FE_OFN1065_i_reset_n_i
Xpconv_2_r_reg[13] QDFFRBN $PINS Q=pconv_2_r[13] D=pconv_2_w[13] CK=CTS_24
+ RB=FE_OFN1025_i_reset_n_i
Xpconv_2_r_reg[12] QDFFRBN $PINS Q=pconv_2_r[12] D=pconv_2_w[12] CK=CTS_49
+ RB=FE_OFN1025_i_reset_n_i
Xpconv_2_r_reg[11] QDFFRBN $PINS Q=pconv_2_r[11] D=pconv_2_w[11] CK=CTS_49
+ RB=FE_OFN1025_i_reset_n_i
Xpconv_2_r_reg[10] QDFFRBN $PINS Q=pconv_2_r[10] D=pconv_2_w[10] CK=CTS_24
+ RB=FE_OFN955_i_reset_n_i
Xpconv_2_r_reg[9] QDFFRBN $PINS Q=pconv_2_r[9] D=pconv_2_w[9] CK=CTS_49
+ RB=FE_OFN1025_i_reset_n_i
Xpconv_2_r_reg[8] QDFFRBN $PINS Q=pconv_2_r[8] D=pconv_2_w[8] CK=CTS_24
+ RB=FE_OFN955_i_reset_n_i
Xpconv_2_r_reg[7] QDFFRBN $PINS Q=pconv_2_r[7] D=pconv_2_w[7] CK=CTS_24
+ RB=FE_OFN955_i_reset_n_i
Xpconv_2_r_reg[6] QDFFRBN $PINS Q=pconv_2_r[6] D=pconv_2_w[6] CK=CTS_24
+ RB=FE_OFN955_i_reset_n_i
Xpconv_2_r_reg[5] QDFFRBN $PINS Q=pconv_2_r[5] D=pconv_2_w[5] CK=CTS_24
+ RB=FE_OFN955_i_reset_n_i
Xpconv_2_r_reg[4] QDFFRBN $PINS Q=pconv_2_r[4] D=pconv_2_w[4] CK=CTS_24
+ RB=FE_OFN954_i_reset_n_i
Xpconv_2_r_reg[3] QDFFRBN $PINS Q=pconv_2_r[3] D=pconv_2_w[3] CK=CTS_24
+ RB=FE_OFN954_i_reset_n_i
Xpconv_2_r_reg[2] QDFFRBN $PINS Q=pconv_2_r[2] D=pconv_2_w[2] CK=CTS_24
+ RB=FE_OFN874_i_reset_n_i
Xpconv_2_r_reg[1] QDFFRBN $PINS Q=pconv_2_r[1] D=pconv_2_w[1] CK=CTS_24
+ RB=FE_OFN874_i_reset_n_i
Xpconv_2_r_reg[0] QDFFRBN $PINS Q=pconv_2_r[0] D=pconv_2_w[0] CK=CTS_24
+ RB=FE_OFN874_i_reset_n_i
Xbuffer_conv_reg[18] QDFFRBN $PINS Q=buffer_conv[18] D=conv[18] CK=CTS_69
+ RB=FE_OFN919_i_reset_n_i
Xbuffer_conv_reg[39] QDFFRBN $PINS Q=buffer_conv[39] D=buffer_conv[18]
+ CK=CTS_69 RB=FE_OFN800_i_reset_n_i
Xbuffer_conv_reg[60] QDFFRBN $PINS Q=buffer_conv[60] D=buffer_conv[39]
+ CK=CTS_69 RB=FE_OFN800_i_reset_n_i
Xbuffer_conv_reg[17] QDFFRBN $PINS Q=buffer_conv[17] D=conv[17] CK=CTS_69
+ RB=FE_OFN919_i_reset_n_i
Xbuffer_conv_reg[38] QDFFRBN $PINS Q=buffer_conv[38] D=buffer_conv[17]
+ CK=CTS_69 RB=FE_OFN919_i_reset_n_i
Xbuffer_conv_reg[59] QDFFRBN $PINS Q=buffer_conv[59] D=buffer_conv[38]
+ CK=CTS_69 RB=FE_OFN922_i_reset_n_i
Xbuffer_conv_reg[16] QDFFRBN $PINS Q=buffer_conv[16] D=conv[16] CK=CTS_69
+ RB=FE_OFN919_i_reset_n_i
Xbuffer_conv_reg[37] QDFFRBN $PINS Q=buffer_conv[37] D=buffer_conv[16]
+ CK=CTS_69 RB=FE_OFN919_i_reset_n_i
Xbuffer_conv_reg[58] QDFFRBN $PINS Q=buffer_conv[58] D=buffer_conv[37]
+ CK=CTS_69 RB=FE_OFN800_i_reset_n_i
Xbuffer_conv_reg[15] QDFFRBN $PINS Q=buffer_conv[15] D=conv[15] CK=CTS_69
+ RB=FE_OFN1076_i_reset_n_i
Xbuffer_conv_reg[36] QDFFRBN $PINS Q=buffer_conv[36] D=buffer_conv[15]
+ CK=CTS_69 RB=FE_OFN1076_i_reset_n_i
Xbuffer_conv_reg[57] QDFFRBN $PINS Q=buffer_conv[57] D=buffer_conv[36]
+ CK=CTS_69 RB=FE_OFN1076_i_reset_n_i
Xbuffer_conv_reg[14] QDFFRBN $PINS Q=buffer_conv[14] D=conv[14] CK=CTS_44
+ RB=FE_OFN1075_i_reset_n_i
Xbuffer_conv_reg[35] QDFFRBN $PINS Q=buffer_conv[35] D=buffer_conv[14]
+ CK=CTS_44 RB=FE_OFN1040_i_reset_n_i
Xbuffer_conv_reg[56] QDFFRBN $PINS Q=buffer_conv[56] D=buffer_conv[35]
+ CK=CTS_69 RB=FE_OFN1040_i_reset_n_i
Xbuffer_conv_reg[13] QDFFRBN $PINS Q=buffer_conv[13] D=conv[13] CK=CTS_46
+ RB=FE_OFN624_i_reset_n_i
Xbuffer_conv_reg[34] QDFFRBN $PINS Q=buffer_conv[34] D=buffer_conv[13]
+ CK=CTS_46 RB=FE_OFN624_i_reset_n_i
Xbuffer_conv_reg[55] QDFFRBN $PINS Q=buffer_conv[55] D=buffer_conv[34]
+ CK=CTS_44 RB=FE_OFN967_i_reset_n_i
Xbuffer_conv_reg[12] QDFFRBN $PINS Q=buffer_conv[12] D=conv[12] CK=CTS_46
+ RB=FE_OFN624_i_reset_n_i
Xbuffer_conv_reg[33] QDFFRBN $PINS Q=buffer_conv[33] D=buffer_conv[12]
+ CK=CTS_44 RB=FE_OFN1075_i_reset_n_i
Xbuffer_conv_reg[54] QDFFRBN $PINS Q=buffer_conv[54] D=buffer_conv[33]
+ CK=CTS_44 RB=FE_OFN967_i_reset_n_i
Xbuffer_conv_reg[11] QDFFRBN $PINS Q=buffer_conv[11] D=conv[11] CK=CTS_44
+ RB=FE_OFN624_i_reset_n_i
Xbuffer_conv_reg[32] QDFFRBN $PINS Q=buffer_conv[32] D=buffer_conv[11]
+ CK=CTS_44 RB=FE_OFN884_i_reset_n_i
Xbuffer_conv_reg[53] QDFFRBN $PINS Q=buffer_conv[53] D=buffer_conv[32]
+ CK=CTS_44 RB=FE_OFN1042_i_reset_n_i
Xbuffer_conv_reg[10] QDFFRBN $PINS Q=buffer_conv[10] D=conv[10] CK=CTS_44
+ RB=FE_OFN624_i_reset_n_i
Xbuffer_conv_reg[31] QDFFRBN $PINS Q=buffer_conv[31] D=buffer_conv[10]
+ CK=CTS_44 RB=FE_OFN884_i_reset_n_i
Xbuffer_conv_reg[52] QDFFRBN $PINS Q=buffer_conv[52] D=buffer_conv[31]
+ CK=CTS_44 RB=FE_OFN969_i_reset_n_i
Xbuffer_conv_reg[9] QDFFRBN $PINS Q=buffer_conv[9] D=conv[9] CK=CTS_64
+ RB=FE_OFN1079_i_reset_n_i
Xbuffer_conv_reg[30] QDFFRBN $PINS Q=buffer_conv[30] D=buffer_conv[9] CK=CTS_64
+ RB=FE_OFN1079_i_reset_n_i
Xbuffer_conv_reg[51] QDFFRBN $PINS Q=buffer_conv[51] D=buffer_conv[30]
+ CK=CTS_64 RB=FE_OFN552_i_reset_n_i
Xbuffer_conv_reg[8] QDFFRBN $PINS Q=buffer_conv[8] D=conv[8] CK=CTS_64
+ RB=FE_OFN396_i_reset_n_i
Xbuffer_conv_reg[29] QDFFRBN $PINS Q=buffer_conv[29] D=buffer_conv[8] CK=CTS_64
+ RB=FE_OFN359_i_reset_n_i
Xbuffer_conv_reg[50] QDFFRBN $PINS Q=buffer_conv[50] D=buffer_conv[29]
+ CK=CTS_64 RB=FE_OFN359_i_reset_n_i
Xbuffer_conv_reg[7] QDFFRBN $PINS Q=buffer_conv[7] D=conv[7] CK=CTS_44
+ RB=FE_OFN1078_i_reset_n_i
Xbuffer_conv_reg[28] QDFFRBN $PINS Q=buffer_conv[28] D=buffer_conv[7] CK=CTS_44
+ RB=FE_OFN1078_i_reset_n_i
Xbuffer_conv_reg[49] QDFFRBN $PINS Q=buffer_conv[49] D=buffer_conv[28]
+ CK=CTS_44 RB=FE_OFN1078_i_reset_n_i
Xbuffer_conv_reg[6] QDFFRBN $PINS Q=buffer_conv[6] D=conv[6] CK=CTS_69
+ RB=FE_OFN1076_i_reset_n_i
Xbuffer_conv_reg[27] QDFFRBN $PINS Q=buffer_conv[27] D=buffer_conv[6] CK=CTS_69
+ RB=FE_OFN1076_i_reset_n_i
Xbuffer_conv_reg[48] QDFFRBN $PINS Q=buffer_conv[48] D=buffer_conv[27]
+ CK=CTS_69 RB=FE_OFN919_i_reset_n_i
Xbuffer_conv_reg[5] QDFFRBN $PINS Q=buffer_conv[5] D=conv[5] CK=CTS_64
+ RB=FE_OFN457_i_reset_n_i
Xbuffer_conv_reg[26] QDFFRBN $PINS Q=buffer_conv[26] D=buffer_conv[5] CK=CTS_64
+ RB=FE_OFN396_i_reset_n_i
Xbuffer_conv_reg[47] QDFFRBN $PINS Q=buffer_conv[47] D=buffer_conv[26]
+ CK=CTS_64 RB=FE_OFN396_i_reset_n_i
Xbuffer_conv_reg[4] QDFFRBN $PINS Q=buffer_conv[4] D=conv[4] CK=CTS_64
+ RB=FE_OFN553_i_reset_n_i
Xbuffer_conv_reg[25] QDFFRBN $PINS Q=buffer_conv[25] D=buffer_conv[4] CK=CTS_64
+ RB=FE_OFN671_i_reset_n_i
Xbuffer_conv_reg[46] QDFFRBN $PINS Q=buffer_conv[46] D=buffer_conv[25]
+ CK=CTS_64 RB=FE_OFN553_i_reset_n_i
Xbuffer_conv_reg[3] QDFFRBN $PINS Q=buffer_conv[3] D=conv[3] CK=CTS_69
+ RB=FE_OFN551_i_reset_n_i
Xbuffer_conv_reg[24] QDFFRBN $PINS Q=buffer_conv[24] D=buffer_conv[3] CK=CTS_69
+ RB=FE_OFN800_i_reset_n_i
Xbuffer_conv_reg[45] QDFFRBN $PINS Q=buffer_conv[45] D=buffer_conv[24]
+ CK=CTS_69 RB=FE_OFN669_i_reset_n_i
Xbuffer_conv_reg[2] QDFFRBN $PINS Q=buffer_conv[2] D=conv[2] CK=CTS_69
+ RB=FE_OFN776_i_reset_n_i
Xbuffer_conv_reg[23] QDFFRBN $PINS Q=buffer_conv[23] D=buffer_conv[2] CK=CTS_69
+ RB=FE_OFN395_i_reset_n_i
Xbuffer_conv_reg[44] QDFFRBN $PINS Q=buffer_conv[44] D=buffer_conv[23]
+ CK=CTS_69 RB=FE_OFN668_i_reset_n_i
Xbuffer_conv_reg[1] QDFFRBN $PINS Q=buffer_conv[1] D=conv[1] CK=CTS_69
+ RB=FE_OFN776_i_reset_n_i
Xbuffer_conv_reg[22] QDFFRBN $PINS Q=buffer_conv[22] D=buffer_conv[1] CK=CTS_69
+ RB=FE_OFN395_i_reset_n_i
Xbuffer_conv_reg[43] QDFFRBN $PINS Q=buffer_conv[43] D=buffer_conv[22]
+ CK=CTS_69 RB=FE_OFN668_i_reset_n_i
Xbuffer_conv_reg[0] QDFFRBN $PINS Q=buffer_conv[0] D=conv[0] CK=CTS_69
+ RB=FE_OFN652_i_reset_n_i
Xbuffer_conv_reg[21] QDFFRBN $PINS Q=buffer_conv[21] D=buffer_conv[0] CK=CTS_69
+ RB=FE_OFN652_i_reset_n_i
Xbuffer_conv_reg[42] QDFFRBN $PINS Q=buffer_conv[42] D=buffer_conv[21]
+ CK=CTS_69 RB=FE_OFN395_i_reset_n_i
Xconv_1_r_reg[18] QDFFRBN $PINS Q=conv_1_r[18] D=buffer_conv[60] CK=CTS_69
+ RB=FE_OFN922_i_reset_n_i
Xconv_1_r_reg[17] QDFFRBN $PINS Q=conv_1_r[17] D=buffer_conv[59] CK=CTS_69
+ RB=FE_OFN922_i_reset_n_i
Xconv_1_r_reg[16] QDFFRBN $PINS Q=conv_1_r[16] D=buffer_conv[58] CK=CTS_69
+ RB=FE_OFN800_i_reset_n_i
Xconv_1_r_reg[15] QDFFRBN $PINS Q=conv_1_r[15] D=buffer_conv[57] CK=CTS_69
+ RB=FE_OFN1076_i_reset_n_i
Xconv_1_r_reg[14] QDFFRBN $PINS Q=conv_1_r[14] D=buffer_conv[56] CK=CTS_44
+ RB=FE_OFN1040_i_reset_n_i
Xconv_1_r_reg[13] QDFFRBN $PINS Q=conv_1_r[13] D=buffer_conv[55] CK=CTS_44
+ RB=FE_OFN967_i_reset_n_i
Xconv_1_r_reg[12] QDFFRBN $PINS Q=conv_1_r[12] D=buffer_conv[54] CK=CTS_44
+ RB=FE_OFN1040_i_reset_n_i
Xconv_1_r_reg[11] QDFFRBN $PINS Q=conv_1_r[11] D=buffer_conv[53] CK=CTS_44
+ RB=FE_OFN1042_i_reset_n_i
Xconv_1_r_reg[10] QDFFRBN $PINS Q=conv_1_r[10] D=buffer_conv[52] CK=CTS_44
+ RB=FE_OFN884_i_reset_n_i
Xconv_1_r_reg[9] QDFFRBN $PINS Q=conv_1_r[9] D=buffer_conv[51] CK=CTS_64
+ RB=FE_OFN552_i_reset_n_i
Xconv_1_r_reg[8] QDFFRBN $PINS Q=conv_1_r[8] D=buffer_conv[50] CK=CTS_64
+ RB=FE_OFN359_i_reset_n_i
Xconv_1_r_reg[7] QDFFRBN $PINS Q=conv_1_r[7] D=buffer_conv[49] CK=CTS_44
+ RB=FE_OFN1078_i_reset_n_i
Xconv_1_r_reg[6] QDFFRBN $PINS Q=conv_1_r[6] D=buffer_conv[48] CK=CTS_69
+ RB=FE_OFN359_i_reset_n_i
Xconv_1_r_reg[5] QDFFRBN $PINS Q=conv_1_r[5] D=buffer_conv[47] CK=CTS_64
+ RB=FE_OFN396_i_reset_n_i
Xconv_1_r_reg[4] QDFFRBN $PINS Q=conv_1_r[4] D=buffer_conv[46] CK=CTS_64
+ RB=FE_OFN553_i_reset_n_i
Xconv_1_r_reg[3] QDFFRBN $PINS Q=conv_1_r[3] D=buffer_conv[45] CK=CTS_69
+ RB=FE_OFN668_i_reset_n_i
Xconv_1_r_reg[2] QDFFRBN $PINS Q=conv_1_r[2] D=buffer_conv[44] CK=CTS_69
+ RB=FE_OFN668_i_reset_n_i
Xconv_1_r_reg[1] QDFFRBN $PINS Q=conv_1_r[1] D=buffer_conv[43] CK=CTS_69
+ RB=FE_OFN668_i_reset_n_i
Xconv_1_r_reg[0] QDFFRBN $PINS Q=conv_1_r[0] D=buffer_conv[42] CK=CTS_69
+ RB=FE_OFN456_i_reset_n_i
Xbuffer_pmp_reg[0] QDFFRBN $PINS Q=buffer_pmp[0] D=pmp[0] CK=CTS_69
+ RB=FE_OFN456_i_reset_n_i
Xbuffer_pmp_reg[21] QDFFRBN $PINS Q=buffer_pmp[21] D=buffer_pmp[0] CK=CTS_69
+ RB=FE_OFN456_i_reset_n_i
Xbuffer_pmp_reg[42] QDFFRBN $PINS Q=buffer_pmp[42] D=buffer_pmp[21] CK=CTS_69
+ RB=FE_OFN650_i_reset_n_i
Xbuffer_pmp_reg[63] QDFFRBN $PINS Q=buffer_pmp[63] D=buffer_pmp[42] CK=CTS_69
+ RB=FE_OFN774_i_reset_n_i
Xbuffer_pmp_reg[84] QDFFRBN $PINS Q=buffer_pmp[84] D=buffer_pmp[63] CK=CTS_52
+ RB=FE_OFN774_i_reset_n_i
Xbuffer_pmp_reg[105] QDFFRBN $PINS Q=buffer_pmp[105] D=buffer_pmp[84] CK=CTS_52
+ RB=FE_OFN774_i_reset_n_i
Xbuffer_pmp_reg[126] QDFFRBN $PINS Q=buffer_pmp[126] D=buffer_pmp[105]
+ CK=CTS_52 RB=FE_OFN774_i_reset_n_i
Xbuffer_pmp_reg[147] QDFFRBN $PINS Q=buffer_pmp[147] D=buffer_pmp[126]
+ CK=CTS_52 RB=FE_OFN985_i_reset_n_i
Xbuffer_pmp_reg[168] QDFFRBN $PINS Q=buffer_pmp[168] D=buffer_pmp[147]
+ CK=CTS_60 RB=FE_OFN985_i_reset_n_i
Xbuffer_pmp_reg[189] QDFFRBN $PINS Q=buffer_pmp[189] D=buffer_pmp[168]
+ CK=CTS_52 RB=FE_OFN985_i_reset_n_i
Xbuffer_pmp_reg[210] QDFFRBN $PINS Q=buffer_pmp[210] D=buffer_pmp[189]
+ CK=CTS_52 RB=FE_OFN779_i_reset_n_i
Xbuffer_pmp_reg[231] QDFFRBN $PINS Q=buffer_pmp[231] D=buffer_pmp[210]
+ CK=CTS_52 RB=FE_OFN901_i_reset_n_i
Xbuffer_pmp_reg[252] QDFFRBN $PINS Q=buffer_pmp[252] D=buffer_pmp[231]
+ CK=CTS_52 RB=FE_OFN780_i_reset_n_i
Xbuffer_pmp_reg[273] QDFFRBN $PINS Q=buffer_pmp[273] D=buffer_pmp[252]
+ CK=CTS_52 RB=FE_OFN780_i_reset_n_i
Xbuffer_pmp_reg[294] QDFFRBN $PINS Q=buffer_pmp[294] D=buffer_pmp[273]
+ CK=CTS_52 RB=FE_OFN780_i_reset_n_i
Xbuffer_pmp_reg[315] QDFFRBN $PINS Q=buffer_pmp[315] D=buffer_pmp[294]
+ CK=CTS_52 RB=FE_OFN780_i_reset_n_i
Xbuffer_pmp_reg[336] QDFFRBN $PINS Q=buffer_pmp[336] D=buffer_pmp[315]
+ CK=CTS_52 RB=FE_OFN539_i_reset_n_i
Xbuffer_pmp_reg[357] QDFFRBN $PINS Q=buffer_pmp[357] D=buffer_pmp[336]
+ CK=CTS_52 RB=FE_OFN539_i_reset_n_i
Xbuffer_pmp_reg[378] QDFFRBN $PINS Q=buffer_pmp[378] D=buffer_pmp[357]
+ CK=CTS_52 RB=FE_OFN539_i_reset_n_i
Xbuffer_pmp_reg[399] QDFFRBN $PINS Q=buffer_pmp[399] D=buffer_pmp[378]
+ CK=CTS_52 RB=FE_OFN539_i_reset_n_i
Xbuffer_pmp_reg[420] QDFFRBN $PINS Q=buffer_pmp[420] D=buffer_pmp[399]
+ CK=CTS_52 RB=FE_OFN653_i_reset_n_i
Xbuffer_pmp_reg[441] QDFFRBN $PINS Q=buffer_pmp[441] D=buffer_pmp[420]
+ CK=CTS_52 RB=FE_OFN653_i_reset_n_i
Xbuffer_pmp_reg[462] QDFFRBN $PINS Q=buffer_pmp[462] D=buffer_pmp[441]
+ CK=CTS_52 RB=FE_OFN654_i_reset_n_i
Xbuffer_pmp_reg[483] QDFFRBN $PINS Q=buffer_pmp[483] D=buffer_pmp[462]
+ CK=CTS_52 RB=FE_OFN654_i_reset_n_i
Xbuffer_pmp_reg[504] QDFFRBN $PINS Q=buffer_pmp[504] D=buffer_pmp[483]
+ CK=CTS_52 RB=FE_OFN780_i_reset_n_i
Xbuffer_pmp_reg[525] QDFFRBN $PINS Q=buffer_pmp[525] D=buffer_pmp[504]
+ CK=CTS_52 RB=FE_OFN654_i_reset_n_i
Xbuffer_pmp_reg[546] QDFFRBN $PINS Q=buffer_pmp[546] D=buffer_pmp[525]
+ CK=CTS_52 RB=FE_OFN653_i_reset_n_i
Xbuffer_pmp_reg[567] QDFFRBN $PINS Q=buffer_pmp[567] D=buffer_pmp[546]
+ CK=CTS_51 RB=FE_OFN899_i_reset_n_i
Xbuffer_pmp_reg[588] QDFFRBN $PINS Q=buffer_pmp[588] D=buffer_pmp[567]
+ CK=CTS_51 RB=FE_OFN899_i_reset_n_i
Xbuffer_pmp_reg[609] QDFFRBN $PINS Q=buffer_pmp[609] D=buffer_pmp[588]
+ CK=CTS_51 RB=FE_OFN899_i_reset_n_i
Xbuffer_pmp_reg[630] QDFFRBN $PINS Q=buffer_pmp[630] D=buffer_pmp[609]
+ CK=CTS_51 RB=FE_OFN904_i_reset_n_i
Xbuffer_pmp_reg[651] QDFFRBN $PINS Q=buffer_pmp[651] D=buffer_pmp[630]
+ CK=CTS_51 RB=FE_OFN904_i_reset_n_i
Xbuffer_pmp_reg[672] QDFFRBN $PINS Q=buffer_pmp[672] D=buffer_pmp[651]
+ CK=CTS_66 RB=FE_OFN542_i_reset_n_i
Xbuffer_pmp_reg[693] QDFFRBN $PINS Q=buffer_pmp[693] D=buffer_pmp[672]
+ CK=CTS_66 RB=FE_OFN542_i_reset_n_i
Xbuffer_pmp_reg[714] QDFFRBN $PINS Q=buffer_pmp[714] D=buffer_pmp[693]
+ CK=CTS_66 RB=FE_OFN449_i_reset_n_i
Xbuffer_pmp_reg[735] QDFFRBN $PINS Q=buffer_pmp[735] D=buffer_pmp[714]
+ CK=CTS_51 RB=FE_OFN449_i_reset_n_i
Xbuffer_pmp_reg[756] QDFFRBN $PINS Q=buffer_pmp[756] D=buffer_pmp[735]
+ CK=CTS_51 RB=FE_OFN390_i_reset_n_i
Xbuffer_pmp_reg[777] QDFFRBN $PINS Q=buffer_pmp[777] D=buffer_pmp[756]
+ CK=CTS_51 RB=FE_OFN390_i_reset_n_i
Xbuffer_pmp_reg[798] QDFFRBN $PINS Q=buffer_pmp[798] D=buffer_pmp[777]
+ CK=CTS_51 RB=FE_OFN390_i_reset_n_i
Xbuffer_pmp_reg[819] QDFFRBN $PINS Q=buffer_pmp[819] D=buffer_pmp[798]
+ CK=CTS_51 RB=FE_OFN390_i_reset_n_i
Xbuffer_pmp_reg[840] QDFFRBN $PINS Q=buffer_pmp[840] D=buffer_pmp[819]
+ CK=CTS_51 RB=FE_OFN449_i_reset_n_i
Xbuffer_pmp_reg[861] QDFFRBN $PINS Q=buffer_pmp[861] D=buffer_pmp[840]
+ CK=CTS_66 RB=FE_OFN542_i_reset_n_i
Xbuffer_pmp_reg[882] QDFFRBN $PINS Q=buffer_pmp[882] D=buffer_pmp[861]
+ CK=CTS_66 RB=FE_OFN655_i_reset_n_i
Xbuffer_pmp_reg[903] QDFFRBN $PINS Q=buffer_pmp[903] D=buffer_pmp[882]
+ CK=CTS_66 RB=FE_OFN655_i_reset_n_i
Xbuffer_pmp_reg[924] QDFFRBN $PINS Q=buffer_pmp[924] D=buffer_pmp[903]
+ CK=CTS_66 RB=FE_OFN656_i_reset_n_i
Xbuffer_pmp_reg[945] QDFFRBN $PINS Q=buffer_pmp[945] D=buffer_pmp[924]
+ CK=CTS_66 RB=FE_OFN656_i_reset_n_i
Xbuffer_pmp_reg[966] QDFFRBN $PINS Q=buffer_pmp[966] D=buffer_pmp[945]
+ CK=CTS_66 RB=FE_OFN785_i_reset_n_i
Xbuffer_pmp_reg[987] QDFFRBN $PINS Q=buffer_pmp[987] D=buffer_pmp[966]
+ CK=CTS_66 RB=FE_OFN785_i_reset_n_i
Xbuffer_pmp_reg[1008] QDFFRBN $PINS Q=buffer_pmp[1008] D=buffer_pmp[987]
+ CK=CTS_66 RB=FE_OFN900_i_reset_n_i
Xbuffer_pmp_reg[1029] QDFFRBN $PINS Q=buffer_pmp[1029] D=buffer_pmp[1008]
+ CK=CTS_66 RB=FE_OFN900_i_reset_n_i
Xbuffer_pmp_reg[1050] QDFFRBN $PINS Q=buffer_pmp[1050] D=buffer_pmp[1029]
+ CK=CTS_66 RB=FE_OFN984_i_reset_n_i
Xbuffer_pmp_reg[1071] QDFFRBN $PINS Q=buffer_pmp[1071] D=buffer_pmp[1050]
+ CK=CTS_52 RB=FE_OFN984_i_reset_n_i
Xbuffer_pmp_reg[1092] QDFFRBN $PINS Q=buffer_pmp[1092] D=buffer_pmp[1071]
+ CK=CTS_52 RB=FE_OFN984_i_reset_n_i
Xpmp_1_r_reg[0] QDFFRBN $PINS Q=pmp_1_r[0] D=pmp_1_w[0] CK=CTS_60
+ RB=FE_OFN985_i_reset_n_i
Xbuffer_pmp_reg[1] QDFFRBN $PINS Q=buffer_pmp[1] D=pmp[1] CK=CTS_69
+ RB=FE_OFN551_i_reset_n_i
Xbuffer_pmp_reg[22] QDFFRBN $PINS Q=buffer_pmp[22] D=buffer_pmp[1] CK=CTS_69
+ RB=FE_OFN456_i_reset_n_i
Xbuffer_pmp_reg[43] QDFFRBN $PINS Q=buffer_pmp[43] D=buffer_pmp[22] CK=CTS_69
+ RB=FE_OFN777_i_reset_n_i
Xbuffer_pmp_reg[64] QDFFRBN $PINS Q=buffer_pmp[64] D=buffer_pmp[43] CK=CTS_69
+ RB=FE_OFN777_i_reset_n_i
Xbuffer_pmp_reg[85] QDFFRBN $PINS Q=buffer_pmp[85] D=buffer_pmp[64] CK=CTS_69
+ RB=FE_OFN650_i_reset_n_i
Xbuffer_pmp_reg[106] QDFFRBN $PINS Q=buffer_pmp[106] D=buffer_pmp[85] CK=CTS_52
+ RB=FE_OFN777_i_reset_n_i
Xbuffer_pmp_reg[127] QDFFRBN $PINS Q=buffer_pmp[127] D=buffer_pmp[106]
+ CK=CTS_52 RB=FE_OFN777_i_reset_n_i
Xbuffer_pmp_reg[148] QDFFRBN $PINS Q=buffer_pmp[148] D=buffer_pmp[127]
+ CK=CTS_52 RB=FE_OFN538_i_reset_n_i
Xbuffer_pmp_reg[169] QDFFRBN $PINS Q=buffer_pmp[169] D=buffer_pmp[148]
+ CK=CTS_52 RB=FE_OFN538_i_reset_n_i
Xbuffer_pmp_reg[190] QDFFRBN $PINS Q=buffer_pmp[190] D=buffer_pmp[169]
+ CK=CTS_52 RB=FE_OFN651_i_reset_n_i
Xbuffer_pmp_reg[211] QDFFRBN $PINS Q=buffer_pmp[211] D=buffer_pmp[190]
+ CK=CTS_52 RB=FE_OFN651_i_reset_n_i
Xbuffer_pmp_reg[232] QDFFRBN $PINS Q=buffer_pmp[232] D=buffer_pmp[211]
+ CK=CTS_52 RB=FE_OFN651_i_reset_n_i
Xbuffer_pmp_reg[253] QDFFRBN $PINS Q=buffer_pmp[253] D=buffer_pmp[232]
+ CK=CTS_52 RB=FE_OFN447_i_reset_n_i
Xbuffer_pmp_reg[274] QDFFRBN $PINS Q=buffer_pmp[274] D=buffer_pmp[253]
+ CK=CTS_52 RB=FE_OFN447_i_reset_n_i
Xbuffer_pmp_reg[295] QDFFRBN $PINS Q=buffer_pmp[295] D=buffer_pmp[274]
+ CK=CTS_52 RB=FE_OFN447_i_reset_n_i
Xbuffer_pmp_reg[316] QDFFRBN $PINS Q=buffer_pmp[316] D=buffer_pmp[295]
+ CK=CTS_52 RB=FE_OFN447_i_reset_n_i
Xbuffer_pmp_reg[337] QDFFRBN $PINS Q=buffer_pmp[337] D=buffer_pmp[316]
+ CK=CTS_52 RB=FE_OFN537_i_reset_n_i
Xbuffer_pmp_reg[358] QDFFRBN $PINS Q=buffer_pmp[358] D=buffer_pmp[337]
+ CK=CTS_52 RB=FE_OFN537_i_reset_n_i
Xbuffer_pmp_reg[379] QDFFRBN $PINS Q=buffer_pmp[379] D=buffer_pmp[358]
+ CK=CTS_52 RB=FE_OFN774_i_reset_n_i
Xbuffer_pmp_reg[400] QDFFRBN $PINS Q=buffer_pmp[400] D=buffer_pmp[379]
+ CK=CTS_52 RB=FE_OFN901_i_reset_n_i
Xbuffer_pmp_reg[421] QDFFRBN $PINS Q=buffer_pmp[421] D=buffer_pmp[400]
+ CK=CTS_52 RB=FE_OFN985_i_reset_n_i
Xbuffer_pmp_reg[442] QDFFRBN $PINS Q=buffer_pmp[442] D=buffer_pmp[421]
+ CK=CTS_52 RB=FE_OFN901_i_reset_n_i
Xbuffer_pmp_reg[463] QDFFRBN $PINS Q=buffer_pmp[463] D=buffer_pmp[442]
+ CK=CTS_52 RB=FE_OFN901_i_reset_n_i
Xbuffer_pmp_reg[484] QDFFRBN $PINS Q=buffer_pmp[484] D=buffer_pmp[463]
+ CK=CTS_52 RB=FE_OFN901_i_reset_n_i
Xbuffer_pmp_reg[505] QDFFRBN $PINS Q=buffer_pmp[505] D=buffer_pmp[484]
+ CK=CTS_52 RB=FE_OFN779_i_reset_n_i
Xbuffer_pmp_reg[526] QDFFRBN $PINS Q=buffer_pmp[526] D=buffer_pmp[505]
+ CK=CTS_52 RB=FE_OFN779_i_reset_n_i
Xbuffer_pmp_reg[547] QDFFRBN $PINS Q=buffer_pmp[547] D=buffer_pmp[526]
+ CK=CTS_52 RB=FE_OFN779_i_reset_n_i
Xbuffer_pmp_reg[568] QDFFRBN $PINS Q=buffer_pmp[568] D=buffer_pmp[547]
+ CK=CTS_52 RB=FE_OFN779_i_reset_n_i
Xbuffer_pmp_reg[589] QDFFRBN $PINS Q=buffer_pmp[589] D=buffer_pmp[568]
+ CK=CTS_52 RB=FE_OFN778_i_reset_n_i
Xbuffer_pmp_reg[610] QDFFRBN $PINS Q=buffer_pmp[610] D=buffer_pmp[589]
+ CK=CTS_66 RB=FE_OFN778_i_reset_n_i
Xbuffer_pmp_reg[631] QDFFRBN $PINS Q=buffer_pmp[631] D=buffer_pmp[610]
+ CK=CTS_66 RB=FE_OFN899_i_reset_n_i
Xbuffer_pmp_reg[652] QDFFRBN $PINS Q=buffer_pmp[652] D=buffer_pmp[631]
+ CK=CTS_66 RB=FE_OFN899_i_reset_n_i
Xbuffer_pmp_reg[673] QDFFRBN $PINS Q=buffer_pmp[673] D=buffer_pmp[652]
+ CK=CTS_66 RB=FE_OFN904_i_reset_n_i
Xbuffer_pmp_reg[694] QDFFRBN $PINS Q=buffer_pmp[694] D=buffer_pmp[673]
+ CK=CTS_66 RB=FE_OFN904_i_reset_n_i
Xbuffer_pmp_reg[715] QDFFRBN $PINS Q=buffer_pmp[715] D=buffer_pmp[694]
+ CK=CTS_66 RB=FE_OFN541_i_reset_n_i
Xbuffer_pmp_reg[736] QDFFRBN $PINS Q=buffer_pmp[736] D=buffer_pmp[715]
+ CK=CTS_66 RB=FE_OFN541_i_reset_n_i
Xbuffer_pmp_reg[757] QDFFRBN $PINS Q=buffer_pmp[757] D=buffer_pmp[736]
+ CK=CTS_66 RB=FE_OFN449_i_reset_n_i
Xbuffer_pmp_reg[778] QDFFRBN $PINS Q=buffer_pmp[778] D=buffer_pmp[757]
+ CK=CTS_66 RB=FE_OFN781_i_reset_n_i
Xbuffer_pmp_reg[799] QDFFRBN $PINS Q=buffer_pmp[799] D=buffer_pmp[778]
+ CK=CTS_66 RB=FE_OFN781_i_reset_n_i
Xbuffer_pmp_reg[820] QDFFRBN $PINS Q=buffer_pmp[820] D=buffer_pmp[799]
+ CK=CTS_66 RB=FE_OFN655_i_reset_n_i
Xbuffer_pmp_reg[841] QDFFRBN $PINS Q=buffer_pmp[841] D=buffer_pmp[820]
+ CK=CTS_66 RB=FE_OFN655_i_reset_n_i
Xbuffer_pmp_reg[862] QDFFRBN $PINS Q=buffer_pmp[862] D=buffer_pmp[841]
+ CK=CTS_66 RB=FE_OFN541_i_reset_n_i
Xbuffer_pmp_reg[883] QDFFRBN $PINS Q=buffer_pmp[883] D=buffer_pmp[862]
+ CK=CTS_66 RB=FE_OFN656_i_reset_n_i
Xbuffer_pmp_reg[904] QDFFRBN $PINS Q=buffer_pmp[904] D=buffer_pmp[883]
+ CK=CTS_66 RB=FE_OFN541_i_reset_n_i
Xbuffer_pmp_reg[925] QDFFRBN $PINS Q=buffer_pmp[925] D=buffer_pmp[904]
+ CK=CTS_66 RB=FE_OFN904_i_reset_n_i
Xbuffer_pmp_reg[946] QDFFRBN $PINS Q=buffer_pmp[946] D=buffer_pmp[925]
+ CK=CTS_66 RB=FE_OFN904_i_reset_n_i
Xbuffer_pmp_reg[967] QDFFRBN $PINS Q=buffer_pmp[967] D=buffer_pmp[946]
+ CK=CTS_66 RB=FE_OFN778_i_reset_n_i
Xbuffer_pmp_reg[988] QDFFRBN $PINS Q=buffer_pmp[988] D=buffer_pmp[967]
+ CK=CTS_52 RB=FE_OFN778_i_reset_n_i
Xbuffer_pmp_reg[1009] QDFFRBN $PINS Q=buffer_pmp[1009] D=buffer_pmp[988]
+ CK=CTS_52 RB=FE_OFN900_i_reset_n_i
Xbuffer_pmp_reg[1030] QDFFRBN $PINS Q=buffer_pmp[1030] D=buffer_pmp[1009]
+ CK=CTS_52 RB=FE_OFN984_i_reset_n_i
Xbuffer_pmp_reg[1051] QDFFRBN $PINS Q=buffer_pmp[1051] D=buffer_pmp[1030]
+ CK=CTS_52 RB=FE_OFN984_i_reset_n_i
Xbuffer_pmp_reg[1072] QDFFRBN $PINS Q=buffer_pmp[1072] D=buffer_pmp[1051]
+ CK=CTS_52 RB=FE_OFN984_i_reset_n_i
Xbuffer_pmp_reg[1093] QDFFRBN $PINS Q=buffer_pmp[1093] D=buffer_pmp[1072]
+ CK=CTS_52 RB=FE_OFN985_i_reset_n_i
Xpmp_1_r_reg[1] QDFFRBN $PINS Q=pmp_1_r[1] D=pmp_1_w[1] CK=CTS_60
+ RB=FE_OFN391_i_reset_n_i
Xbuffer_pmp_reg[2] QDFFRBN $PINS Q=buffer_pmp[2] D=pmp[2] CK=CTS_69
+ RB=FE_OFN551_i_reset_n_i
Xbuffer_pmp_reg[23] QDFFRBN $PINS Q=buffer_pmp[23] D=buffer_pmp[2] CK=CTS_69
+ RB=FE_OFN456_i_reset_n_i
Xbuffer_pmp_reg[44] QDFFRBN $PINS Q=buffer_pmp[44] D=buffer_pmp[23] CK=CTS_69
+ RB=FE_OFN1056_i_reset_n_i
Xbuffer_pmp_reg[65] QDFFRBN $PINS Q=buffer_pmp[65] D=buffer_pmp[44] CK=CTS_69
+ RB=FE_OFN774_i_reset_n_i
Xbuffer_pmp_reg[86] QDFFRBN $PINS Q=buffer_pmp[86] D=buffer_pmp[65] CK=CTS_60
+ RB=FE_OFN391_i_reset_n_i
Xbuffer_pmp_reg[107] QDFFRBN $PINS Q=buffer_pmp[107] D=buffer_pmp[86] CK=CTS_60
+ RB=FE_OFN391_i_reset_n_i
Xbuffer_pmp_reg[128] QDFFRBN $PINS Q=buffer_pmp[128] D=buffer_pmp[107]
+ CK=CTS_60 RB=FE_OFN450_i_reset_n_i
Xbuffer_pmp_reg[149] QDFFRBN $PINS Q=buffer_pmp[149] D=buffer_pmp[128]
+ CK=CTS_60 RB=FE_OFN905_i_reset_n_i
Xbuffer_pmp_reg[170] QDFFRBN $PINS Q=buffer_pmp[170] D=buffer_pmp[149]
+ CK=CTS_60 RB=FE_OFN905_i_reset_n_i
Xbuffer_pmp_reg[191] QDFFRBN $PINS Q=buffer_pmp[191] D=buffer_pmp[170]
+ CK=CTS_52 RB=FE_OFN905_i_reset_n_i
Xbuffer_pmp_reg[212] QDFFRBN $PINS Q=buffer_pmp[212] D=buffer_pmp[191]
+ CK=CTS_66 RB=FE_OFN905_i_reset_n_i
Xbuffer_pmp_reg[233] QDFFRBN $PINS Q=buffer_pmp[233] D=buffer_pmp[212]
+ CK=CTS_66 RB=FE_OFN905_i_reset_n_i
Xbuffer_pmp_reg[254] QDFFRBN $PINS Q=buffer_pmp[254] D=buffer_pmp[233]
+ CK=CTS_66 RB=FE_OFN900_i_reset_n_i
Xbuffer_pmp_reg[275] QDFFRBN $PINS Q=buffer_pmp[275] D=buffer_pmp[254]
+ CK=CTS_66 RB=FE_OFN900_i_reset_n_i
Xbuffer_pmp_reg[296] QDFFRBN $PINS Q=buffer_pmp[296] D=buffer_pmp[275]
+ CK=CTS_66 RB=FE_OFN784_i_reset_n_i
Xbuffer_pmp_reg[317] QDFFRBN $PINS Q=buffer_pmp[317] D=buffer_pmp[296]
+ CK=CTS_66 RB=FE_OFN785_i_reset_n_i
Xbuffer_pmp_reg[338] QDFFRBN $PINS Q=buffer_pmp[338] D=buffer_pmp[317]
+ CK=CTS_66 RB=FE_OFN784_i_reset_n_i
Xbuffer_pmp_reg[359] QDFFRBN $PINS Q=buffer_pmp[359] D=buffer_pmp[338]
+ CK=CTS_66 RB=FE_OFN783_i_reset_n_i
Xbuffer_pmp_reg[380] QDFFRBN $PINS Q=buffer_pmp[380] D=buffer_pmp[359]
+ CK=CTS_66 RB=FE_OFN783_i_reset_n_i
Xbuffer_pmp_reg[401] QDFFRBN $PINS Q=buffer_pmp[401] D=buffer_pmp[380]
+ CK=CTS_66 RB=FE_OFN783_i_reset_n_i
Xbuffer_pmp_reg[422] QDFFRBN $PINS Q=buffer_pmp[422] D=buffer_pmp[401]
+ CK=CTS_66 RB=FE_OFN903_i_reset_n_i
Xbuffer_pmp_reg[443] QDFFRBN $PINS Q=buffer_pmp[443] D=buffer_pmp[422]
+ CK=CTS_66 RB=FE_OFN784_i_reset_n_i
Xbuffer_pmp_reg[464] QDFFRBN $PINS Q=buffer_pmp[464] D=buffer_pmp[443]
+ CK=CTS_66 RB=FE_OFN784_i_reset_n_i
Xbuffer_pmp_reg[485] QDFFRBN $PINS Q=buffer_pmp[485] D=buffer_pmp[464]
+ CK=CTS_66 RB=FE_OFN787_i_reset_n_i
Xbuffer_pmp_reg[506] QDFFRBN $PINS Q=buffer_pmp[506] D=buffer_pmp[485]
+ CK=CTS_66 RB=FE_OFN787_i_reset_n_i
Xbuffer_pmp_reg[527] QDFFRBN $PINS Q=buffer_pmp[527] D=buffer_pmp[506]
+ CK=CTS_66 RB=FE_OFN787_i_reset_n_i
Xbuffer_pmp_reg[548] QDFFRBN $PINS Q=buffer_pmp[548] D=buffer_pmp[527]
+ CK=CTS_66 RB=FE_OFN903_i_reset_n_i
Xbuffer_pmp_reg[569] QDFFRBN $PINS Q=buffer_pmp[569] D=buffer_pmp[548]
+ CK=CTS_66 RB=FE_OFN903_i_reset_n_i
Xbuffer_pmp_reg[590] QDFFRBN $PINS Q=buffer_pmp[590] D=buffer_pmp[569]
+ CK=CTS_66 RB=FE_OFN903_i_reset_n_i
Xbuffer_pmp_reg[611] QDFFRBN $PINS Q=buffer_pmp[611] D=buffer_pmp[590]
+ CK=CTS_66 RB=FE_OFN987_i_reset_n_i
Xbuffer_pmp_reg[632] QDFFRBN $PINS Q=buffer_pmp[632] D=buffer_pmp[611]
+ CK=CTS_66 RB=FE_OFN987_i_reset_n_i
Xbuffer_pmp_reg[653] QDFFRBN $PINS Q=buffer_pmp[653] D=buffer_pmp[632]
+ CK=CTS_66 RB=FE_OFN987_i_reset_n_i
Xbuffer_pmp_reg[674] QDFFRBN $PINS Q=buffer_pmp[674] D=buffer_pmp[653]
+ CK=CTS_66 RB=FE_OFN918_i_reset_n_i
Xbuffer_pmp_reg[695] QDFFRBN $PINS Q=buffer_pmp[695] D=buffer_pmp[674]
+ CK=CTS_66 RB=FE_OFN987_i_reset_n_i
Xbuffer_pmp_reg[716] QDFFRBN $PINS Q=buffer_pmp[716] D=buffer_pmp[695]
+ CK=CTS_66 RB=FE_OFN987_i_reset_n_i
Xbuffer_pmp_reg[737] QDFFRBN $PINS Q=buffer_pmp[737] D=buffer_pmp[716]
+ CK=CTS_66 RB=FE_OFN986_i_reset_n_i
Xbuffer_pmp_reg[758] QDFFRBN $PINS Q=buffer_pmp[758] D=buffer_pmp[737]
+ CK=CTS_66 RB=FE_OFN986_i_reset_n_i
Xbuffer_pmp_reg[779] QDFFRBN $PINS Q=buffer_pmp[779] D=buffer_pmp[758]
+ CK=CTS_66 RB=FE_OFN782_i_reset_n_i
Xbuffer_pmp_reg[800] QDFFRBN $PINS Q=buffer_pmp[800] D=buffer_pmp[779]
+ CK=CTS_66 RB=FE_OFN782_i_reset_n_i
Xbuffer_pmp_reg[821] QDFFRBN $PINS Q=buffer_pmp[821] D=buffer_pmp[800]
+ CK=CTS_66 RB=FE_OFN782_i_reset_n_i
Xbuffer_pmp_reg[842] QDFFRBN $PINS Q=buffer_pmp[842] D=buffer_pmp[821]
+ CK=CTS_66 RB=FE_OFN782_i_reset_n_i
Xbuffer_pmp_reg[863] QDFFRBN $PINS Q=buffer_pmp[863] D=buffer_pmp[842]
+ CK=CTS_66 RB=FE_OFN782_i_reset_n_i
Xbuffer_pmp_reg[884] QDFFRBN $PINS Q=buffer_pmp[884] D=buffer_pmp[863]
+ CK=CTS_66 RB=FE_OFN987_i_reset_n_i
Xbuffer_pmp_reg[905] QDFFRBN $PINS Q=buffer_pmp[905] D=buffer_pmp[884]
+ CK=CTS_66 RB=FE_OFN918_i_reset_n_i
Xbuffer_pmp_reg[926] QDFFRBN $PINS Q=buffer_pmp[926] D=buffer_pmp[905]
+ CK=CTS_66 RB=FE_OFN918_i_reset_n_i
Xbuffer_pmp_reg[947] QDFFRBN $PINS Q=buffer_pmp[947] D=buffer_pmp[926]
+ CK=CTS_66 RB=FE_OFN918_i_reset_n_i
Xbuffer_pmp_reg[968] QDFFRBN $PINS Q=buffer_pmp[968] D=buffer_pmp[947]
+ CK=CTS_68 RB=FE_OFN454_i_reset_n_i
Xbuffer_pmp_reg[989] QDFFRBN $PINS Q=buffer_pmp[989] D=buffer_pmp[968]
+ CK=CTS_66 RB=FE_OFN454_i_reset_n_i
Xbuffer_pmp_reg[1010] QDFFRBN $PINS Q=buffer_pmp[1010] D=buffer_pmp[989]
+ CK=CTS_68 RB=FE_OFN454_i_reset_n_i
Xbuffer_pmp_reg[1031] QDFFRBN $PINS Q=buffer_pmp[1031] D=buffer_pmp[1010]
+ CK=CTS_66 RB=FE_OFN455_i_reset_n_i
Xbuffer_pmp_reg[1052] QDFFRBN $PINS Q=buffer_pmp[1052] D=buffer_pmp[1031]
+ CK=CTS_68 RB=FE_OFN787_i_reset_n_i
Xbuffer_pmp_reg[1073] QDFFRBN $PINS Q=buffer_pmp[1073] D=buffer_pmp[1052]
+ CK=CTS_66 RB=FE_OFN905_i_reset_n_i
Xbuffer_pmp_reg[1094] QDFFRBN $PINS Q=buffer_pmp[1094] D=buffer_pmp[1073]
+ CK=CTS_66 RB=FE_OFN658_i_reset_n_i
Xpmp_1_r_reg[2] QDFFRBN $PINS Q=pmp_1_r[2] D=pmp_1_w[2] CK=CTS_60
+ RB=FE_OFN450_i_reset_n_i
Xbuffer_pmp_reg[3] QDFFRBN $PINS Q=buffer_pmp[3] D=pmp[3] CK=CTS_69
+ RB=FE_OFN670_i_reset_n_i
Xbuffer_pmp_reg[24] QDFFRBN $PINS Q=buffer_pmp[24] D=buffer_pmp[3] CK=CTS_69
+ RB=FE_OFN670_i_reset_n_i
Xbuffer_pmp_reg[45] QDFFRBN $PINS Q=buffer_pmp[45] D=buffer_pmp[24] CK=CTS_69
+ RB=FE_OFN670_i_reset_n_i
Xbuffer_pmp_reg[66] QDFFRBN $PINS Q=buffer_pmp[66] D=buffer_pmp[45] CK=CTS_69
+ RB=FE_OFN801_i_reset_n_i
Xbuffer_pmp_reg[87] QDFFRBN $PINS Q=buffer_pmp[87] D=buffer_pmp[66] CK=CTS_69
+ RB=FE_OFN801_i_reset_n_i
Xbuffer_pmp_reg[108] QDFFRBN $PINS Q=buffer_pmp[108] D=buffer_pmp[87] CK=CTS_69
+ RB=FE_OFN801_i_reset_n_i
Xbuffer_pmp_reg[129] QDFFRBN $PINS Q=buffer_pmp[129] D=buffer_pmp[108]
+ CK=CTS_69 RB=FE_OFN801_i_reset_n_i
Xbuffer_pmp_reg[150] QDFFRBN $PINS Q=buffer_pmp[150] D=buffer_pmp[129]
+ CK=CTS_60 RB=FE_OFN920_i_reset_n_i
Xbuffer_pmp_reg[171] QDFFRBN $PINS Q=buffer_pmp[171] D=buffer_pmp[150]
+ CK=CTS_60 RB=FE_OFN920_i_reset_n_i
Xbuffer_pmp_reg[192] QDFFRBN $PINS Q=buffer_pmp[192] D=buffer_pmp[171]
+ CK=CTS_60 RB=FE_OFN786_i_reset_n_i
Xbuffer_pmp_reg[213] QDFFRBN $PINS Q=buffer_pmp[213] D=buffer_pmp[192]
+ CK=CTS_60 RB=FE_OFN786_i_reset_n_i
Xbuffer_pmp_reg[234] QDFFRBN $PINS Q=buffer_pmp[234] D=buffer_pmp[213]
+ CK=CTS_60 RB=FE_OFN786_i_reset_n_i
Xbuffer_pmp_reg[255] QDFFRBN $PINS Q=buffer_pmp[255] D=buffer_pmp[234]
+ CK=CTS_60 RB=FE_OFN920_i_reset_n_i
Xbuffer_pmp_reg[276] QDFFRBN $PINS Q=buffer_pmp[276] D=buffer_pmp[255]
+ CK=CTS_60 RB=FE_OFN920_i_reset_n_i
Xbuffer_pmp_reg[297] QDFFRBN $PINS Q=buffer_pmp[297] D=buffer_pmp[276]
+ CK=CTS_60 RB=FE_OFN1056_i_reset_n_i
Xbuffer_pmp_reg[318] QDFFRBN $PINS Q=buffer_pmp[318] D=buffer_pmp[297]
+ CK=CTS_69 RB=FE_OFN1056_i_reset_n_i
Xbuffer_pmp_reg[339] QDFFRBN $PINS Q=buffer_pmp[339] D=buffer_pmp[318]
+ CK=CTS_60 RB=FE_OFN1056_i_reset_n_i
Xbuffer_pmp_reg[360] QDFFRBN $PINS Q=buffer_pmp[360] D=buffer_pmp[339]
+ CK=CTS_60 RB=FE_OFN1056_i_reset_n_i
Xbuffer_pmp_reg[381] QDFFRBN $PINS Q=buffer_pmp[381] D=buffer_pmp[360]
+ CK=CTS_60 RB=FE_OFN1056_i_reset_n_i
Xbuffer_pmp_reg[402] QDFFRBN $PINS Q=buffer_pmp[402] D=buffer_pmp[381]
+ CK=CTS_60 RB=FE_OFN543_i_reset_n_i
Xbuffer_pmp_reg[423] QDFFRBN $PINS Q=buffer_pmp[423] D=buffer_pmp[402]
+ CK=CTS_60 RB=FE_OFN543_i_reset_n_i
Xbuffer_pmp_reg[444] QDFFRBN $PINS Q=buffer_pmp[444] D=buffer_pmp[423]
+ CK=CTS_60 RB=FE_OFN543_i_reset_n_i
Xbuffer_pmp_reg[465] QDFFRBN $PINS Q=buffer_pmp[465] D=buffer_pmp[444]
+ CK=CTS_60 RB=FE_OFN450_i_reset_n_i
Xbuffer_pmp_reg[486] QDFFRBN $PINS Q=buffer_pmp[486] D=buffer_pmp[465]
+ CK=CTS_60 RB=FE_OFN545_i_reset_n_i
Xbuffer_pmp_reg[507] QDFFRBN $PINS Q=buffer_pmp[507] D=buffer_pmp[486]
+ CK=CTS_60 RB=FE_OFN545_i_reset_n_i
Xbuffer_pmp_reg[528] QDFFRBN $PINS Q=buffer_pmp[528] D=buffer_pmp[507]
+ CK=CTS_60 RB=FE_OFN545_i_reset_n_i
Xbuffer_pmp_reg[549] QDFFRBN $PINS Q=buffer_pmp[549] D=buffer_pmp[528]
+ CK=CTS_60 RB=FE_OFN658_i_reset_n_i
Xbuffer_pmp_reg[570] QDFFRBN $PINS Q=buffer_pmp[570] D=buffer_pmp[549]
+ CK=CTS_68 RB=FE_OFN658_i_reset_n_i
Xbuffer_pmp_reg[591] QDFFRBN $PINS Q=buffer_pmp[591] D=buffer_pmp[570]
+ CK=CTS_68 RB=FE_OFN787_i_reset_n_i
Xbuffer_pmp_reg[612] QDFFRBN $PINS Q=buffer_pmp[612] D=buffer_pmp[591]
+ CK=CTS_68 RB=FE_OFN906_i_reset_n_i
Xbuffer_pmp_reg[633] QDFFRBN $PINS Q=buffer_pmp[633] D=buffer_pmp[612]
+ CK=CTS_68 RB=FE_OFN455_i_reset_n_i
Xbuffer_pmp_reg[654] QDFFRBN $PINS Q=buffer_pmp[654] D=buffer_pmp[633]
+ CK=CTS_68 RB=FE_OFN454_i_reset_n_i
Xbuffer_pmp_reg[675] QDFFRBN $PINS Q=buffer_pmp[675] D=buffer_pmp[654]
+ CK=CTS_68 RB=FE_OFN454_i_reset_n_i
Xbuffer_pmp_reg[696] QDFFRBN $PINS Q=buffer_pmp[696] D=buffer_pmp[675]
+ CK=CTS_68 RB=FE_OFN917_i_reset_n_i
Xbuffer_pmp_reg[717] QDFFRBN $PINS Q=buffer_pmp[717] D=buffer_pmp[696]
+ CK=CTS_68 RB=FE_OFN918_i_reset_n_i
Xbuffer_pmp_reg[738] QDFFRBN $PINS Q=buffer_pmp[738] D=buffer_pmp[717]
+ CK=CTS_68 RB=FE_OFN799_i_reset_n_i
Xbuffer_pmp_reg[759] QDFFRBN $PINS Q=buffer_pmp[759] D=buffer_pmp[738]
+ CK=CTS_68 RB=FE_OFN799_i_reset_n_i
Xbuffer_pmp_reg[780] QDFFRBN $PINS Q=buffer_pmp[780] D=buffer_pmp[759]
+ CK=CTS_68 RB=FE_OFN667_i_reset_n_i
Xbuffer_pmp_reg[801] QDFFRBN $PINS Q=buffer_pmp[801] D=buffer_pmp[780]
+ CK=CTS_68 RB=FE_OFN916_i_reset_n_i
Xbuffer_pmp_reg[822] QDFFRBN $PINS Q=buffer_pmp[822] D=buffer_pmp[801]
+ CK=CTS_68 RB=FE_OFN799_i_reset_n_i
Xbuffer_pmp_reg[843] QDFFRBN $PINS Q=buffer_pmp[843] D=buffer_pmp[822]
+ CK=CTS_68 RB=FE_OFN916_i_reset_n_i
Xbuffer_pmp_reg[864] QDFFRBN $PINS Q=buffer_pmp[864] D=buffer_pmp[843]
+ CK=CTS_68 RB=FE_OFN667_i_reset_n_i
Xbuffer_pmp_reg[885] QDFFRBN $PINS Q=buffer_pmp[885] D=buffer_pmp[864]
+ CK=CTS_68 RB=FE_OFN917_i_reset_n_i
Xbuffer_pmp_reg[906] QDFFRBN $PINS Q=buffer_pmp[906] D=buffer_pmp[885]
+ CK=CTS_68 RB=FE_OFN550_i_reset_n_i
Xbuffer_pmp_reg[927] QDFFRBN $PINS Q=buffer_pmp[927] D=buffer_pmp[906]
+ CK=CTS_68 RB=FE_OFN550_i_reset_n_i
Xbuffer_pmp_reg[948] QDFFRBN $PINS Q=buffer_pmp[948] D=buffer_pmp[927]
+ CK=CTS_68 RB=FE_OFN665_i_reset_n_i
Xbuffer_pmp_reg[969] QDFFRBN $PINS Q=buffer_pmp[969] D=buffer_pmp[948]
+ CK=CTS_68 RB=FE_OFN665_i_reset_n_i
Xbuffer_pmp_reg[990] QDFFRBN $PINS Q=buffer_pmp[990] D=buffer_pmp[969]
+ CK=CTS_68 RB=FE_OFN906_i_reset_n_i
Xbuffer_pmp_reg[1011] QDFFRBN $PINS Q=buffer_pmp[1011] D=buffer_pmp[990]
+ CK=CTS_68 RB=FE_OFN906_i_reset_n_i
Xbuffer_pmp_reg[1032] QDFFRBN $PINS Q=buffer_pmp[1032] D=buffer_pmp[1011]
+ CK=CTS_68 RB=FE_OFN788_i_reset_n_i
Xbuffer_pmp_reg[1053] QDFFRBN $PINS Q=buffer_pmp[1053] D=buffer_pmp[1032]
+ CK=CTS_68 RB=FE_OFN658_i_reset_n_i
Xbuffer_pmp_reg[1074] QDFFRBN $PINS Q=buffer_pmp[1074] D=buffer_pmp[1053]
+ CK=CTS_60 RB=FE_OFN545_i_reset_n_i
Xbuffer_pmp_reg[1095] QDFFRBN $PINS Q=buffer_pmp[1095] D=buffer_pmp[1074]
+ CK=CTS_60 RB=FE_OFN545_i_reset_n_i
Xpmp_1_r_reg[3] QDFFRBN $PINS Q=pmp_1_r[3] D=pmp_1_w[3] CK=CTS_60
+ RB=FE_OFN920_i_reset_n_i
Xbuffer_pmp_reg[4] QDFFRBN $PINS Q=buffer_pmp[4] D=pmp[4] CK=CTS_64
+ RB=FE_OFN671_i_reset_n_i
Xbuffer_pmp_reg[25] QDFFRBN $PINS Q=buffer_pmp[25] D=buffer_pmp[4] CK=CTS_64
+ RB=FE_OFN672_i_reset_n_i
Xbuffer_pmp_reg[46] QDFFRBN $PINS Q=buffer_pmp[46] D=buffer_pmp[25] CK=CTS_64
+ RB=FE_OFN672_i_reset_n_i
Xbuffer_pmp_reg[67] QDFFRBN $PINS Q=buffer_pmp[67] D=buffer_pmp[46] CK=CTS_64
+ RB=FE_OFN672_i_reset_n_i
Xbuffer_pmp_reg[88] QDFFRBN $PINS Q=buffer_pmp[88] D=buffer_pmp[67] CK=CTS_61
+ RB=FE_OFN804_i_reset_n_i
Xbuffer_pmp_reg[109] QDFFRBN $PINS Q=buffer_pmp[109] D=buffer_pmp[88] CK=CTS_61
+ RB=FE_OFN804_i_reset_n_i
Xbuffer_pmp_reg[130] QDFFRBN $PINS Q=buffer_pmp[130] D=buffer_pmp[109]
+ CK=CTS_60 RB=FE_OFN804_i_reset_n_i
Xbuffer_pmp_reg[151] QDFFRBN $PINS Q=buffer_pmp[151] D=buffer_pmp[130]
+ CK=CTS_61 RB=FE_OFN923_i_reset_n_i
Xbuffer_pmp_reg[172] QDFFRBN $PINS Q=buffer_pmp[172] D=buffer_pmp[151]
+ CK=CTS_60 RB=FE_OFN659_i_reset_n_i
Xbuffer_pmp_reg[193] QDFFRBN $PINS Q=buffer_pmp[193] D=buffer_pmp[172]
+ CK=CTS_61 RB=FE_OFN546_i_reset_n_i
Xbuffer_pmp_reg[214] QDFFRBN $PINS Q=buffer_pmp[214] D=buffer_pmp[193]
+ CK=CTS_60 RB=FE_OFN546_i_reset_n_i
Xbuffer_pmp_reg[235] QDFFRBN $PINS Q=buffer_pmp[235] D=buffer_pmp[214]
+ CK=CTS_61 RB=FE_OFN546_i_reset_n_i
Xbuffer_pmp_reg[256] QDFFRBN $PINS Q=buffer_pmp[256] D=buffer_pmp[235]
+ CK=CTS_60 RB=FE_OFN546_i_reset_n_i
Xbuffer_pmp_reg[277] QDFFRBN $PINS Q=buffer_pmp[277] D=buffer_pmp[256]
+ CK=CTS_61 RB=FE_OFN790_i_reset_n_i
Xbuffer_pmp_reg[298] QDFFRBN $PINS Q=buffer_pmp[298] D=buffer_pmp[277]
+ CK=CTS_61 RB=FE_OFN790_i_reset_n_i
Xbuffer_pmp_reg[319] QDFFRBN $PINS Q=buffer_pmp[319] D=buffer_pmp[298]
+ CK=CTS_61 RB=FE_OFN659_i_reset_n_i
Xbuffer_pmp_reg[340] QDFFRBN $PINS Q=buffer_pmp[340] D=buffer_pmp[319]
+ CK=CTS_61 RB=FE_OFN659_i_reset_n_i
Xbuffer_pmp_reg[361] QDFFRBN $PINS Q=buffer_pmp[361] D=buffer_pmp[340]
+ CK=CTS_61 RB=FE_OFN659_i_reset_n_i
Xbuffer_pmp_reg[382] QDFFRBN $PINS Q=buffer_pmp[382] D=buffer_pmp[361]
+ CK=CTS_61 RB=FE_OFN789_i_reset_n_i
Xbuffer_pmp_reg[403] QDFFRBN $PINS Q=buffer_pmp[403] D=buffer_pmp[382]
+ CK=CTS_61 RB=FE_OFN789_i_reset_n_i
Xbuffer_pmp_reg[424] QDFFRBN $PINS Q=buffer_pmp[424] D=buffer_pmp[403]
+ CK=CTS_61 RB=FE_OFN789_i_reset_n_i
Xbuffer_pmp_reg[445] QDFFRBN $PINS Q=buffer_pmp[445] D=buffer_pmp[424]
+ CK=CTS_61 RB=FE_OFN790_i_reset_n_i
Xbuffer_pmp_reg[466] QDFFRBN $PINS Q=buffer_pmp[466] D=buffer_pmp[445]
+ CK=CTS_61 RB=FE_OFN790_i_reset_n_i
Xbuffer_pmp_reg[487] QDFFRBN $PINS Q=buffer_pmp[487] D=buffer_pmp[466]
+ CK=CTS_61 RB=FE_OFN790_i_reset_n_i
Xbuffer_pmp_reg[508] QDFFRBN $PINS Q=buffer_pmp[508] D=buffer_pmp[487]
+ CK=CTS_61 RB=FE_OFN790_i_reset_n_i
Xbuffer_pmp_reg[529] QDFFRBN $PINS Q=buffer_pmp[529] D=buffer_pmp[508]
+ CK=CTS_61 RB=FE_OFN792_i_reset_n_i
Xbuffer_pmp_reg[550] QDFFRBN $PINS Q=buffer_pmp[550] D=buffer_pmp[529]
+ CK=CTS_61 RB=FE_OFN793_i_reset_n_i
Xbuffer_pmp_reg[571] QDFFRBN $PINS Q=buffer_pmp[571] D=buffer_pmp[550]
+ CK=CTS_61 RB=FE_OFN793_i_reset_n_i
Xbuffer_pmp_reg[592] QDFFRBN $PINS Q=buffer_pmp[592] D=buffer_pmp[571]
+ CK=CTS_58 RB=FE_OFN908_i_reset_n_i
Xbuffer_pmp_reg[613] QDFFRBN $PINS Q=buffer_pmp[613] D=buffer_pmp[592]
+ CK=CTS_58 RB=FE_OFN908_i_reset_n_i
Xbuffer_pmp_reg[634] QDFFRBN $PINS Q=buffer_pmp[634] D=buffer_pmp[613]
+ CK=CTS_58 RB=FE_OFN549_i_reset_n_i
Xbuffer_pmp_reg[655] QDFFRBN $PINS Q=buffer_pmp[655] D=buffer_pmp[634]
+ CK=CTS_58 RB=FE_OFN549_i_reset_n_i
Xbuffer_pmp_reg[676] QDFFRBN $PINS Q=buffer_pmp[676] D=buffer_pmp[655]
+ CK=CTS_58 RB=FE_OFN549_i_reset_n_i
Xbuffer_pmp_reg[697] QDFFRBN $PINS Q=buffer_pmp[697] D=buffer_pmp[676]
+ CK=CTS_58 RB=FE_OFN453_i_reset_n_i
Xbuffer_pmp_reg[718] QDFFRBN $PINS Q=buffer_pmp[718] D=buffer_pmp[697]
+ CK=CTS_58 RB=FE_OFN663_i_reset_n_i
Xbuffer_pmp_reg[739] QDFFRBN $PINS Q=buffer_pmp[739] D=buffer_pmp[718]
+ CK=CTS_58 RB=FE_OFN794_i_reset_n_i
Xbuffer_pmp_reg[760] QDFFRBN $PINS Q=buffer_pmp[760] D=buffer_pmp[739]
+ CK=CTS_58 RB=FE_OFN794_i_reset_n_i
Xbuffer_pmp_reg[781] QDFFRBN $PINS Q=buffer_pmp[781] D=buffer_pmp[760]
+ CK=CTS_58 RB=FE_OFN794_i_reset_n_i
Xbuffer_pmp_reg[802] QDFFRBN $PINS Q=buffer_pmp[802] D=buffer_pmp[781]
+ CK=CTS_58 RB=FE_OFN910_i_reset_n_i
Xbuffer_pmp_reg[823] QDFFRBN $PINS Q=buffer_pmp[823] D=buffer_pmp[802]
+ CK=CTS_58 RB=FE_OFN910_i_reset_n_i
Xbuffer_pmp_reg[844] QDFFRBN $PINS Q=buffer_pmp[844] D=buffer_pmp[823]
+ CK=CTS_58 RB=FE_OFN910_i_reset_n_i
Xbuffer_pmp_reg[865] QDFFRBN $PINS Q=buffer_pmp[865] D=buffer_pmp[844]
+ CK=CTS_58 RB=FE_OFN663_i_reset_n_i
Xbuffer_pmp_reg[886] QDFFRBN $PINS Q=buffer_pmp[886] D=buffer_pmp[865]
+ CK=CTS_58 RB=FE_OFN663_i_reset_n_i
Xbuffer_pmp_reg[907] QDFFRBN $PINS Q=buffer_pmp[907] D=buffer_pmp[886]
+ CK=CTS_58 RB=FE_OFN912_i_reset_n_i
Xbuffer_pmp_reg[928] QDFFRBN $PINS Q=buffer_pmp[928] D=buffer_pmp[907]
+ CK=CTS_58 RB=FE_OFN912_i_reset_n_i
Xbuffer_pmp_reg[949] QDFFRBN $PINS Q=buffer_pmp[949] D=buffer_pmp[928]
+ CK=CTS_58 RB=FE_OFN549_i_reset_n_i
Xbuffer_pmp_reg[970] QDFFRBN $PINS Q=buffer_pmp[970] D=buffer_pmp[949]
+ CK=CTS_58 RB=FE_OFN664_i_reset_n_i
Xbuffer_pmp_reg[991] QDFFRBN $PINS Q=buffer_pmp[991] D=buffer_pmp[970]
+ CK=CTS_58 RB=FE_OFN988_i_reset_n_i
Xbuffer_pmp_reg[1012] QDFFRBN $PINS Q=buffer_pmp[1012] D=buffer_pmp[991]
+ CK=CTS_58 RB=FE_OFN988_i_reset_n_i
Xbuffer_pmp_reg[1033] QDFFRBN $PINS Q=buffer_pmp[1033] D=buffer_pmp[1012]
+ CK=CTS_61 RB=FE_OFN793_i_reset_n_i
Xbuffer_pmp_reg[1054] QDFFRBN $PINS Q=buffer_pmp[1054] D=buffer_pmp[1033]
+ CK=CTS_61 RB=FE_OFN793_i_reset_n_i
Xbuffer_pmp_reg[1075] QDFFRBN $PINS Q=buffer_pmp[1075] D=buffer_pmp[1054]
+ CK=CTS_61 RB=FE_OFN909_i_reset_n_i
Xbuffer_pmp_reg[1096] QDFFRBN $PINS Q=buffer_pmp[1096] D=buffer_pmp[1075]
+ CK=CTS_61 RB=FE_OFN792_i_reset_n_i
Xpmp_1_r_reg[4] QDFFRBN $PINS Q=pmp_1_r[4] D=pmp_1_w[4] CK=CTS_61
+ RB=FE_OFN924_i_reset_n_i
Xbuffer_pmp_reg[5] QDFFRBN $PINS Q=buffer_pmp[5] D=pmp[5] CK=CTS_64
+ RB=FE_OFN553_i_reset_n_i
Xbuffer_pmp_reg[26] QDFFRBN $PINS Q=buffer_pmp[26] D=buffer_pmp[5] CK=CTS_64
+ RB=FE_OFN671_i_reset_n_i
Xbuffer_pmp_reg[47] QDFFRBN $PINS Q=buffer_pmp[47] D=buffer_pmp[26] CK=CTS_61
+ RB=FE_OFN1107_i_reset_n_i
Xbuffer_pmp_reg[68] QDFFRBN $PINS Q=buffer_pmp[68] D=buffer_pmp[47] CK=CTS_61
+ RB=FE_OFN1107_i_reset_n_i
Xbuffer_pmp_reg[89] QDFFRBN $PINS Q=buffer_pmp[89] D=buffer_pmp[68] CK=CTS_61
+ RB=FE_OFN1057_i_reset_n_i
Xbuffer_pmp_reg[110] QDFFRBN $PINS Q=buffer_pmp[110] D=buffer_pmp[89] CK=CTS_61
+ RB=FE_OFN1072_i_reset_n_i
Xbuffer_pmp_reg[131] QDFFRBN $PINS Q=buffer_pmp[131] D=buffer_pmp[110]
+ CK=CTS_61 RB=FE_OFN1072_i_reset_n_i
Xbuffer_pmp_reg[152] QDFFRBN $PINS Q=buffer_pmp[152] D=buffer_pmp[131]
+ CK=CTS_61 RB=FE_OFN1072_i_reset_n_i
Xbuffer_pmp_reg[173] QDFFRBN $PINS Q=buffer_pmp[173] D=buffer_pmp[152]
+ CK=CTS_61 RB=FE_OFN1072_i_reset_n_i
Xbuffer_pmp_reg[194] QDFFRBN $PINS Q=buffer_pmp[194] D=buffer_pmp[173]
+ CK=CTS_61 RB=FE_OFN990_i_reset_n_i
Xbuffer_pmp_reg[215] QDFFRBN $PINS Q=buffer_pmp[215] D=buffer_pmp[194]
+ CK=CTS_61 RB=FE_OFN990_i_reset_n_i
Xbuffer_pmp_reg[236] QDFFRBN $PINS Q=buffer_pmp[236] D=buffer_pmp[215]
+ CK=CTS_61 RB=FE_OFN380_i_reset_n_i
Xbuffer_pmp_reg[257] QDFFRBN $PINS Q=buffer_pmp[257] D=buffer_pmp[236]
+ CK=CTS_65 RB=FE_OFN632_i_reset_n_i
Xbuffer_pmp_reg[278] QDFFRBN $PINS Q=buffer_pmp[278] D=buffer_pmp[257]
+ CK=CTS_65 RB=FE_OFN632_i_reset_n_i
Xbuffer_pmp_reg[299] QDFFRBN $PINS Q=buffer_pmp[299] D=buffer_pmp[278]
+ CK=CTS_65 RB=FE_OFN523_i_reset_n_i
Xbuffer_pmp_reg[320] QDFFRBN $PINS Q=buffer_pmp[320] D=buffer_pmp[299]
+ CK=CTS_65 RB=FE_OFN633_i_reset_n_i
Xbuffer_pmp_reg[341] QDFFRBN $PINS Q=buffer_pmp[341] D=buffer_pmp[320]
+ CK=CTS_65 RB=FE_OFN633_i_reset_n_i
Xbuffer_pmp_reg[362] QDFFRBN $PINS Q=buffer_pmp[362] D=buffer_pmp[341]
+ CK=CTS_65 RB=FE_OFN633_i_reset_n_i
Xbuffer_pmp_reg[383] QDFFRBN $PINS Q=buffer_pmp[383] D=buffer_pmp[362]
+ CK=CTS_65 RB=FE_OFN633_i_reset_n_i
Xbuffer_pmp_reg[404] QDFFRBN $PINS Q=buffer_pmp[404] D=buffer_pmp[383]
+ CK=CTS_65 RB=FE_OFN633_i_reset_n_i
Xbuffer_pmp_reg[425] QDFFRBN $PINS Q=buffer_pmp[425] D=buffer_pmp[404]
+ CK=CTS_65 RB=FE_OFN522_i_reset_n_i
Xbuffer_pmp_reg[446] QDFFRBN $PINS Q=buffer_pmp[446] D=buffer_pmp[425]
+ CK=CTS_65 RB=FE_OFN522_i_reset_n_i
Xbuffer_pmp_reg[467] QDFFRBN $PINS Q=buffer_pmp[467] D=buffer_pmp[446]
+ CK=CTS_65 RB=FE_OFN523_i_reset_n_i
Xbuffer_pmp_reg[488] QDFFRBN $PINS Q=buffer_pmp[488] D=buffer_pmp[467]
+ CK=CTS_65 RB=FE_OFN380_i_reset_n_i
Xbuffer_pmp_reg[509] QDFFRBN $PINS Q=buffer_pmp[509] D=buffer_pmp[488]
+ CK=CTS_61 RB=FE_OFN380_i_reset_n_i
Xbuffer_pmp_reg[530] QDFFRBN $PINS Q=buffer_pmp[530] D=buffer_pmp[509]
+ CK=CTS_61 RB=FE_OFN380_i_reset_n_i
Xbuffer_pmp_reg[551] QDFFRBN $PINS Q=buffer_pmp[551] D=buffer_pmp[530]
+ CK=CTS_61 RB=FE_OFN761_i_reset_n_i
Xbuffer_pmp_reg[572] QDFFRBN $PINS Q=buffer_pmp[572] D=buffer_pmp[551]
+ CK=CTS_61 RB=FE_OFN761_i_reset_n_i
Xbuffer_pmp_reg[593] QDFFRBN $PINS Q=buffer_pmp[593] D=buffer_pmp[572]
+ CK=CTS_65 RB=FE_OFN631_i_reset_n_i
Xbuffer_pmp_reg[614] QDFFRBN $PINS Q=buffer_pmp[614] D=buffer_pmp[593]
+ CK=CTS_61 RB=FE_OFN762_i_reset_n_i
Xbuffer_pmp_reg[635] QDFFRBN $PINS Q=buffer_pmp[635] D=buffer_pmp[614]
+ CK=CTS_65 RB=FE_OFN763_i_reset_n_i
Xbuffer_pmp_reg[656] QDFFRBN $PINS Q=buffer_pmp[656] D=buffer_pmp[635]
+ CK=CTS_65 RB=FE_OFN763_i_reset_n_i
Xbuffer_pmp_reg[677] QDFFRBN $PINS Q=buffer_pmp[677] D=buffer_pmp[656]
+ CK=CTS_65 RB=FE_OFN891_i_reset_n_i
Xbuffer_pmp_reg[698] QDFFRBN $PINS Q=buffer_pmp[698] D=buffer_pmp[677]
+ CK=CTS_58 RB=FE_OFN891_i_reset_n_i
Xbuffer_pmp_reg[719] QDFFRBN $PINS Q=buffer_pmp[719] D=buffer_pmp[698]
+ CK=CTS_58 RB=FE_OFN976_i_reset_n_i
Xbuffer_pmp_reg[740] QDFFRBN $PINS Q=buffer_pmp[740] D=buffer_pmp[719]
+ CK=CTS_58 RB=FE_OFN976_i_reset_n_i
Xbuffer_pmp_reg[761] QDFFRBN $PINS Q=buffer_pmp[761] D=buffer_pmp[740]
+ CK=CTS_58 RB=FE_OFN1089_i_reset_n_i
Xbuffer_pmp_reg[782] QDFFRBN $PINS Q=buffer_pmp[782] D=buffer_pmp[761]
+ CK=CTS_58 RB=FE_OFN1089_i_reset_n_i
Xbuffer_pmp_reg[803] QDFFRBN $PINS Q=buffer_pmp[803] D=buffer_pmp[782]
+ CK=CTS_58 RB=FE_OFN1090_i_reset_n_i
Xbuffer_pmp_reg[824] QDFFRBN $PINS Q=buffer_pmp[824] D=buffer_pmp[803]
+ CK=CTS_58 RB=FE_OFN1089_i_reset_n_i
Xbuffer_pmp_reg[845] QDFFRBN $PINS Q=buffer_pmp[845] D=buffer_pmp[824]
+ CK=CTS_58 RB=FE_OFN976_i_reset_n_i
Xbuffer_pmp_reg[866] QDFFRBN $PINS Q=buffer_pmp[866] D=buffer_pmp[845]
+ CK=CTS_58 RB=FE_OFN976_i_reset_n_i
Xbuffer_pmp_reg[887] QDFFRBN $PINS Q=buffer_pmp[887] D=buffer_pmp[866]
+ CK=CTS_58 RB=FE_OFN976_i_reset_n_i
Xbuffer_pmp_reg[908] QDFFRBN $PINS Q=buffer_pmp[908] D=buffer_pmp[887]
+ CK=CTS_58 RB=FE_OFN891_i_reset_n_i
Xbuffer_pmp_reg[929] QDFFRBN $PINS Q=buffer_pmp[929] D=buffer_pmp[908]
+ CK=CTS_65 RB=FE_OFN763_i_reset_n_i
Xbuffer_pmp_reg[950] QDFFRBN $PINS Q=buffer_pmp[950] D=buffer_pmp[929]
+ CK=CTS_58 RB=FE_OFN763_i_reset_n_i
Xbuffer_pmp_reg[971] QDFFRBN $PINS Q=buffer_pmp[971] D=buffer_pmp[950]
+ CK=CTS_65 RB=FE_OFN763_i_reset_n_i
Xbuffer_pmp_reg[992] QDFFRBN $PINS Q=buffer_pmp[992] D=buffer_pmp[971]
+ CK=CTS_65 RB=FE_OFN631_i_reset_n_i
Xbuffer_pmp_reg[1013] QDFFRBN $PINS Q=buffer_pmp[1013] D=buffer_pmp[992]
+ CK=CTS_65 RB=FE_OFN631_i_reset_n_i
Xbuffer_pmp_reg[1034] QDFFRBN $PINS Q=buffer_pmp[1034] D=buffer_pmp[1013]
+ CK=CTS_65 RB=FE_OFN522_i_reset_n_i
Xbuffer_pmp_reg[1055] QDFFRBN $PINS Q=buffer_pmp[1055] D=buffer_pmp[1034]
+ CK=CTS_65 RB=FE_OFN522_i_reset_n_i
Xbuffer_pmp_reg[1076] QDFFRBN $PINS Q=buffer_pmp[1076] D=buffer_pmp[1055]
+ CK=CTS_65 RB=FE_OFN632_i_reset_n_i
Xbuffer_pmp_reg[1097] QDFFRBN $PINS Q=buffer_pmp[1097] D=buffer_pmp[1076]
+ CK=CTS_65 RB=FE_OFN380_i_reset_n_i
Xpmp_1_r_reg[5] QDFFRBN $PINS Q=pmp_1_r[5] D=pmp_1_w[5] CK=CTS_61
+ RB=FE_OFN1057_i_reset_n_i
Xbuffer_pmp_reg[6] QDFFRBN $PINS Q=buffer_pmp[6] D=pmp[6] CK=CTS_64
+ RB=FE_OFN1079_i_reset_n_i
Xbuffer_pmp_reg[27] QDFFRBN $PINS Q=buffer_pmp[27] D=buffer_pmp[6] CK=CTS_64
+ RB=FE_OFN1079_i_reset_n_i
Xbuffer_pmp_reg[48] QDFFRBN $PINS Q=buffer_pmp[48] D=buffer_pmp[27] CK=CTS_64
+ RB=FE_OFN751_i_reset_n_i
Xbuffer_pmp_reg[69] QDFFRBN $PINS Q=buffer_pmp[69] D=buffer_pmp[48] CK=CTS_64
+ RB=FE_OFN751_i_reset_n_i
Xbuffer_pmp_reg[90] QDFFRBN $PINS Q=buffer_pmp[90] D=buffer_pmp[69] CK=CTS_64
+ RB=FE_OFN959_i_reset_n_i
Xbuffer_pmp_reg[111] QDFFRBN $PINS Q=buffer_pmp[111] D=buffer_pmp[90] CK=CTS_64
+ RB=FE_OFN1032_i_reset_n_i
Xbuffer_pmp_reg[132] QDFFRBN $PINS Q=buffer_pmp[132] D=buffer_pmp[111]
+ CK=CTS_62 RB=FE_OFN880_i_reset_n_i
Xbuffer_pmp_reg[153] QDFFRBN $PINS Q=buffer_pmp[153] D=buffer_pmp[132]
+ CK=CTS_64 RB=FE_OFN959_i_reset_n_i
Xbuffer_pmp_reg[174] QDFFRBN $PINS Q=buffer_pmp[174] D=buffer_pmp[153]
+ CK=CTS_44 RB=FE_OFN959_i_reset_n_i
Xbuffer_pmp_reg[195] QDFFRBN $PINS Q=buffer_pmp[195] D=buffer_pmp[174]
+ CK=CTS_44 RB=FE_OFN959_i_reset_n_i
Xbuffer_pmp_reg[216] QDFFRBN $PINS Q=buffer_pmp[216] D=buffer_pmp[195]
+ CK=CTS_44 RB=FE_OFN1097_i_reset_n_i
Xbuffer_pmp_reg[237] QDFFRBN $PINS Q=buffer_pmp[237] D=buffer_pmp[216]
+ CK=CTS_44 RB=FE_OFN1077_i_reset_n_i
Xbuffer_pmp_reg[258] QDFFRBN $PINS Q=buffer_pmp[258] D=buffer_pmp[237]
+ CK=CTS_44 RB=FE_OFN1097_i_reset_n_i
Xbuffer_pmp_reg[279] QDFFRBN $PINS Q=buffer_pmp[279] D=buffer_pmp[258]
+ CK=CTS_44 RB=FE_OFN1097_i_reset_n_i
Xbuffer_pmp_reg[300] QDFFRBN $PINS Q=buffer_pmp[300] D=buffer_pmp[279]
+ CK=CTS_44 RB=FE_OFN1066_i_reset_n_i
Xbuffer_pmp_reg[321] QDFFRBN $PINS Q=buffer_pmp[321] D=buffer_pmp[300]
+ CK=CTS_44 RB=FE_OFN1097_i_reset_n_i
Xbuffer_pmp_reg[342] QDFFRBN $PINS Q=buffer_pmp[342] D=buffer_pmp[321]
+ CK=CTS_43 RB=FE_OFN1066_i_reset_n_i
Xbuffer_pmp_reg[363] QDFFRBN $PINS Q=buffer_pmp[363] D=buffer_pmp[342]
+ CK=CTS_43 RB=FE_OFN1066_i_reset_n_i
Xbuffer_pmp_reg[384] QDFFRBN $PINS Q=buffer_pmp[384] D=buffer_pmp[363]
+ CK=CTS_43 RB=FE_OFN1030_i_reset_n_i
Xbuffer_pmp_reg[405] QDFFRBN $PINS Q=buffer_pmp[405] D=buffer_pmp[384]
+ CK=CTS_43 RB=FE_OFN1030_i_reset_n_i
Xbuffer_pmp_reg[426] QDFFRBN $PINS Q=buffer_pmp[426] D=buffer_pmp[405]
+ CK=CTS_43 RB=FE_OFN1030_i_reset_n_i
Xbuffer_pmp_reg[447] QDFFRBN $PINS Q=buffer_pmp[447] D=buffer_pmp[426]
+ CK=CTS_43 RB=FE_OFN1067_i_reset_n_i
Xbuffer_pmp_reg[468] QDFFRBN $PINS Q=buffer_pmp[468] D=buffer_pmp[447]
+ CK=CTS_43 RB=FE_OFN1066_i_reset_n_i
Xbuffer_pmp_reg[489] QDFFRBN $PINS Q=buffer_pmp[489] D=buffer_pmp[468]
+ CK=CTS_43 RB=FE_OFN1096_i_reset_n_i
Xbuffer_pmp_reg[510] QDFFRBN $PINS Q=buffer_pmp[510] D=buffer_pmp[489]
+ CK=CTS_43 RB=FE_OFN1070_i_reset_n_i
Xbuffer_pmp_reg[531] QDFFRBN $PINS Q=buffer_pmp[531] D=buffer_pmp[510]
+ CK=CTS_43 RB=FE_OFN1032_i_reset_n_i
Xbuffer_pmp_reg[552] QDFFRBN $PINS Q=buffer_pmp[552] D=buffer_pmp[531]
+ CK=CTS_43 RB=FE_OFN1070_i_reset_n_i
Xbuffer_pmp_reg[573] QDFFRBN $PINS Q=buffer_pmp[573] D=buffer_pmp[552]
+ CK=CTS_43 RB=FE_OFN1070_i_reset_n_i
Xbuffer_pmp_reg[594] QDFFRBN $PINS Q=buffer_pmp[594] D=buffer_pmp[573]
+ CK=CTS_43 RB=FE_OFN1096_i_reset_n_i
Xbuffer_pmp_reg[615] QDFFRBN $PINS Q=buffer_pmp[615] D=buffer_pmp[594]
+ CK=CTS_43 RB=FE_OFN1099_i_reset_n_i
Xbuffer_pmp_reg[636] QDFFRBN $PINS Q=buffer_pmp[636] D=buffer_pmp[615]
+ CK=CTS_43 RB=FE_OFN1099_i_reset_n_i
Xbuffer_pmp_reg[657] QDFFRBN $PINS Q=buffer_pmp[657] D=buffer_pmp[636]
+ CK=CTS_43 RB=FE_OFN1110_i_reset_n_i
Xbuffer_pmp_reg[678] QDFFRBN $PINS Q=buffer_pmp[678] D=buffer_pmp[657]
+ CK=CTS_43 RB=FE_OFN1110_i_reset_n_i
Xbuffer_pmp_reg[699] QDFFRBN $PINS Q=buffer_pmp[699] D=buffer_pmp[678]
+ CK=CTS_43 RB=FE_OFN1110_i_reset_n_i
Xbuffer_pmp_reg[720] QDFFRBN $PINS Q=buffer_pmp[720] D=buffer_pmp[699]
+ CK=CTS_43 RB=FE_OFN1110_i_reset_n_i
Xbuffer_pmp_reg[741] QDFFRBN $PINS Q=buffer_pmp[741] D=buffer_pmp[720]
+ CK=CTS_43 RB=FE_OFN1110_i_reset_n_i
Xbuffer_pmp_reg[762] QDFFRBN $PINS Q=buffer_pmp[762] D=buffer_pmp[741]
+ CK=CTS_43 RB=FE_OFN1100_i_reset_n_i
Xbuffer_pmp_reg[783] QDFFRBN $PINS Q=buffer_pmp[783] D=buffer_pmp[762]
+ CK=CTS_43 RB=FE_OFN1100_i_reset_n_i
Xbuffer_pmp_reg[804] QDFFRBN $PINS Q=buffer_pmp[804] D=buffer_pmp[783]
+ CK=CTS_43 RB=FE_OFN1100_i_reset_n_i
Xbuffer_pmp_reg[825] QDFFRBN $PINS Q=buffer_pmp[825] D=buffer_pmp[804]
+ CK=CTS_43 RB=FE_OFN1100_i_reset_n_i
Xbuffer_pmp_reg[846] QDFFRBN $PINS Q=buffer_pmp[846] D=buffer_pmp[825]
+ CK=CTS_43 RB=FE_OFN1070_i_reset_n_i
Xbuffer_pmp_reg[867] QDFFRBN $PINS Q=buffer_pmp[867] D=buffer_pmp[846]
+ CK=CTS_43 RB=FE_OFN1096_i_reset_n_i
Xbuffer_pmp_reg[888] QDFFRBN $PINS Q=buffer_pmp[888] D=buffer_pmp[867]
+ CK=CTS_43 RB=FE_OFN1110_i_reset_n_i
Xbuffer_pmp_reg[909] QDFFRBN $PINS Q=buffer_pmp[909] D=buffer_pmp[888]
+ CK=CTS_43 RB=FE_OFN1099_i_reset_n_i
Xbuffer_pmp_reg[930] QDFFRBN $PINS Q=buffer_pmp[930] D=buffer_pmp[909]
+ CK=CTS_43 RB=FE_OFN1099_i_reset_n_i
Xbuffer_pmp_reg[951] QDFFRBN $PINS Q=buffer_pmp[951] D=buffer_pmp[930]
+ CK=CTS_43 RB=FE_OFN1067_i_reset_n_i
Xbuffer_pmp_reg[972] QDFFRBN $PINS Q=buffer_pmp[972] D=buffer_pmp[951]
+ CK=CTS_43 RB=FE_OFN1099_i_reset_n_i
Xbuffer_pmp_reg[993] QDFFRBN $PINS Q=buffer_pmp[993] D=buffer_pmp[972]
+ CK=CTS_43 RB=FE_OFN1067_i_reset_n_i
Xbuffer_pmp_reg[1014] QDFFRBN $PINS Q=buffer_pmp[1014] D=buffer_pmp[993]
+ CK=CTS_43 RB=FE_OFN1096_i_reset_n_i
Xbuffer_pmp_reg[1035] QDFFRBN $PINS Q=buffer_pmp[1035] D=buffer_pmp[1014]
+ CK=CTS_43 RB=FE_OFN1070_i_reset_n_i
Xbuffer_pmp_reg[1056] QDFFRBN $PINS Q=buffer_pmp[1056] D=buffer_pmp[1035]
+ CK=CTS_43 RB=FE_OFN1070_i_reset_n_i
Xbuffer_pmp_reg[1077] QDFFRBN $PINS Q=buffer_pmp[1077] D=buffer_pmp[1056]
+ CK=CTS_62 RB=FE_OFN1032_i_reset_n_i
Xbuffer_pmp_reg[1098] QDFFRBN $PINS Q=buffer_pmp[1098] D=buffer_pmp[1077]
+ CK=CTS_43 RB=FE_OFN1032_i_reset_n_i
Xpmp_1_r_reg[6] QDFFRBN $PINS Q=pmp_1_r[6] D=pmp_1_w[6] CK=CTS_64
+ RB=FE_OFN959_i_reset_n_i
Xbuffer_pmp_reg[7] QDFFRBN $PINS Q=buffer_pmp[7] D=pmp[7] CK=CTS_44
+ RB=FE_OFN1042_i_reset_n_i
Xbuffer_pmp_reg[28] QDFFRBN $PINS Q=buffer_pmp[28] D=buffer_pmp[7] CK=CTS_44
+ RB=FE_OFN1042_i_reset_n_i
Xbuffer_pmp_reg[49] QDFFRBN $PINS Q=buffer_pmp[49] D=buffer_pmp[28] CK=CTS_44
+ RB=FE_OFN1077_i_reset_n_i
Xbuffer_pmp_reg[70] QDFFRBN $PINS Q=buffer_pmp[70] D=buffer_pmp[49] CK=CTS_44
+ RB=FE_OFN1077_i_reset_n_i
Xbuffer_pmp_reg[91] QDFFRBN $PINS Q=buffer_pmp[91] D=buffer_pmp[70] CK=CTS_44
+ RB=FE_OFN1077_i_reset_n_i
Xbuffer_pmp_reg[112] QDFFRBN $PINS Q=buffer_pmp[112] D=buffer_pmp[91] CK=CTS_44
+ RB=FE_OFN1077_i_reset_n_i
Xbuffer_pmp_reg[133] QDFFRBN $PINS Q=buffer_pmp[133] D=buffer_pmp[112]
+ CK=CTS_44 RB=FE_OFN1041_i_reset_n_i
Xbuffer_pmp_reg[154] QDFFRBN $PINS Q=buffer_pmp[154] D=buffer_pmp[133]
+ CK=CTS_44 RB=FE_OFN877_i_reset_n_i
Xbuffer_pmp_reg[175] QDFFRBN $PINS Q=buffer_pmp[175] D=buffer_pmp[154]
+ CK=CTS_44 RB=FE_OFN1077_i_reset_n_i
Xbuffer_pmp_reg[196] QDFFRBN $PINS Q=buffer_pmp[196] D=buffer_pmp[175]
+ CK=CTS_44 RB=FE_OFN1041_i_reset_n_i
Xbuffer_pmp_reg[217] QDFFRBN $PINS Q=buffer_pmp[217] D=buffer_pmp[196]
+ CK=CTS_44 RB=FE_OFN969_i_reset_n_i
Xbuffer_pmp_reg[238] QDFFRBN $PINS Q=buffer_pmp[238] D=buffer_pmp[217]
+ CK=CTS_44 RB=FE_OFN969_i_reset_n_i
Xbuffer_pmp_reg[259] QDFFRBN $PINS Q=buffer_pmp[259] D=buffer_pmp[238]
+ CK=CTS_44 RB=FE_OFN969_i_reset_n_i
Xbuffer_pmp_reg[280] QDFFRBN $PINS Q=buffer_pmp[280] D=buffer_pmp[259]
+ CK=CTS_44 RB=FE_OFN966_i_reset_n_i
Xbuffer_pmp_reg[301] QDFFRBN $PINS Q=buffer_pmp[301] D=buffer_pmp[280]
+ CK=CTS_44 RB=FE_OFN966_i_reset_n_i
Xbuffer_pmp_reg[322] QDFFRBN $PINS Q=buffer_pmp[322] D=buffer_pmp[301]
+ CK=CTS_44 RB=FE_OFN877_i_reset_n_i
Xbuffer_pmp_reg[343] QDFFRBN $PINS Q=buffer_pmp[343] D=buffer_pmp[322]
+ CK=CTS_44 RB=FE_OFN966_i_reset_n_i
Xbuffer_pmp_reg[364] QDFFRBN $PINS Q=buffer_pmp[364] D=buffer_pmp[343]
+ CK=CTS_44 RB=FE_OFN619_i_reset_n_i
Xbuffer_pmp_reg[385] QDFFRBN $PINS Q=buffer_pmp[385] D=buffer_pmp[364]
+ CK=CTS_44 RB=FE_OFN750_i_reset_n_i
Xbuffer_pmp_reg[406] QDFFRBN $PINS Q=buffer_pmp[406] D=buffer_pmp[385]
+ CK=CTS_44 RB=FE_OFN750_i_reset_n_i
Xbuffer_pmp_reg[427] QDFFRBN $PINS Q=buffer_pmp[427] D=buffer_pmp[406]
+ CK=CTS_44 RB=FE_OFN877_i_reset_n_i
Xbuffer_pmp_reg[448] QDFFRBN $PINS Q=buffer_pmp[448] D=buffer_pmp[427]
+ CK=CTS_44 RB=FE_OFN877_i_reset_n_i
Xbuffer_pmp_reg[469] QDFFRBN $PINS Q=buffer_pmp[469] D=buffer_pmp[448]
+ CK=CTS_44 RB=FE_OFN877_i_reset_n_i
Xbuffer_pmp_reg[490] QDFFRBN $PINS Q=buffer_pmp[490] D=buffer_pmp[469]
+ CK=CTS_44 RB=FE_OFN750_i_reset_n_i
Xbuffer_pmp_reg[511] QDFFRBN $PINS Q=buffer_pmp[511] D=buffer_pmp[490]
+ CK=CTS_44 RB=FE_OFN879_i_reset_n_i
Xbuffer_pmp_reg[532] QDFFRBN $PINS Q=buffer_pmp[532] D=buffer_pmp[511]
+ CK=CTS_43 RB=FE_OFN879_i_reset_n_i
Xbuffer_pmp_reg[553] QDFFRBN $PINS Q=buffer_pmp[553] D=buffer_pmp[532]
+ CK=CTS_43 RB=FE_OFN1030_i_reset_n_i
Xbuffer_pmp_reg[574] QDFFRBN $PINS Q=buffer_pmp[574] D=buffer_pmp[553]
+ CK=CTS_43 RB=FE_OFN1031_i_reset_n_i
Xbuffer_pmp_reg[595] QDFFRBN $PINS Q=buffer_pmp[595] D=buffer_pmp[574]
+ CK=CTS_43 RB=FE_OFN1068_i_reset_n_i
Xbuffer_pmp_reg[616] QDFFRBN $PINS Q=buffer_pmp[616] D=buffer_pmp[595]
+ CK=CTS_43 RB=FE_OFN1068_i_reset_n_i
Xbuffer_pmp_reg[637] QDFFRBN $PINS Q=buffer_pmp[637] D=buffer_pmp[616]
+ CK=CTS_43 RB=FE_OFN1098_i_reset_n_i
Xbuffer_pmp_reg[658] QDFFRBN $PINS Q=buffer_pmp[658] D=buffer_pmp[637]
+ CK=CTS_43 RB=FE_OFN1098_i_reset_n_i
Xbuffer_pmp_reg[679] QDFFRBN $PINS Q=buffer_pmp[679] D=buffer_pmp[658]
+ CK=CTS_43 RB=FE_OFN1109_i_reset_n_i
Xbuffer_pmp_reg[700] QDFFRBN $PINS Q=buffer_pmp[700] D=buffer_pmp[679]
+ CK=CTS_47 RB=FE_OFN1109_i_reset_n_i
Xbuffer_pmp_reg[721] QDFFRBN $PINS Q=buffer_pmp[721] D=buffer_pmp[700]
+ CK=CTS_47 RB=FE_OFN1085_i_reset_n_i
Xbuffer_pmp_reg[742] QDFFRBN $PINS Q=buffer_pmp[742] D=buffer_pmp[721]
+ CK=CTS_47 RB=FE_OFN1085_i_reset_n_i
Xbuffer_pmp_reg[763] QDFFRBN $PINS Q=buffer_pmp[763] D=buffer_pmp[742]
+ CK=CTS_47 RB=FE_OFN1046_i_reset_n_i
Xbuffer_pmp_reg[784] QDFFRBN $PINS Q=buffer_pmp[784] D=buffer_pmp[763]
+ CK=CTS_47 RB=FE_OFN1047_i_reset_n_i
Xbuffer_pmp_reg[805] QDFFRBN $PINS Q=buffer_pmp[805] D=buffer_pmp[784]
+ CK=CTS_47 RB=FE_OFN1046_i_reset_n_i
Xbuffer_pmp_reg[826] QDFFRBN $PINS Q=buffer_pmp[826] D=buffer_pmp[805]
+ CK=CTS_47 RB=FE_OFN1046_i_reset_n_i
Xbuffer_pmp_reg[847] QDFFRBN $PINS Q=buffer_pmp[847] D=buffer_pmp[826]
+ CK=CTS_47 RB=FE_OFN1046_i_reset_n_i
Xbuffer_pmp_reg[868] QDFFRBN $PINS Q=buffer_pmp[868] D=buffer_pmp[847]
+ CK=CTS_47 RB=FE_OFN1104_i_reset_n_i
Xbuffer_pmp_reg[889] QDFFRBN $PINS Q=buffer_pmp[889] D=buffer_pmp[868]
+ CK=CTS_43 RB=FE_OFN1104_i_reset_n_i
Xbuffer_pmp_reg[910] QDFFRBN $PINS Q=buffer_pmp[910] D=buffer_pmp[889]
+ CK=CTS_43 RB=FE_OFN1109_i_reset_n_i
Xbuffer_pmp_reg[931] QDFFRBN $PINS Q=buffer_pmp[931] D=buffer_pmp[910]
+ CK=CTS_43 RB=FE_OFN1109_i_reset_n_i
Xbuffer_pmp_reg[952] QDFFRBN $PINS Q=buffer_pmp[952] D=buffer_pmp[931]
+ CK=CTS_43 RB=FE_OFN1068_i_reset_n_i
Xbuffer_pmp_reg[973] QDFFRBN $PINS Q=buffer_pmp[973] D=buffer_pmp[952]
+ CK=CTS_43 RB=FE_OFN1068_i_reset_n_i
Xbuffer_pmp_reg[994] QDFFRBN $PINS Q=buffer_pmp[994] D=buffer_pmp[973]
+ CK=CTS_43 RB=FE_OFN1098_i_reset_n_i
Xbuffer_pmp_reg[1015] QDFFRBN $PINS Q=buffer_pmp[1015] D=buffer_pmp[994]
+ CK=CTS_43 RB=FE_OFN1031_i_reset_n_i
Xbuffer_pmp_reg[1036] QDFFRBN $PINS Q=buffer_pmp[1036] D=buffer_pmp[1015]
+ CK=CTS_43 RB=FE_OFN879_i_reset_n_i
Xbuffer_pmp_reg[1057] QDFFRBN $PINS Q=buffer_pmp[1057] D=buffer_pmp[1036]
+ CK=CTS_43 RB=FE_OFN879_i_reset_n_i
Xbuffer_pmp_reg[1078] QDFFRBN $PINS Q=buffer_pmp[1078] D=buffer_pmp[1057]
+ CK=CTS_43 RB=FE_OFN879_i_reset_n_i
Xbuffer_pmp_reg[1099] QDFFRBN $PINS Q=buffer_pmp[1099] D=buffer_pmp[1078]
+ CK=CTS_44 RB=FE_OFN877_i_reset_n_i
Xpmp_1_r_reg[7] QDFFRBN $PINS Q=pmp_1_r[7] D=pmp_1_w[7] CK=CTS_44
+ RB=FE_OFN1097_i_reset_n_i
Xbuffer_pmp_reg[8] QDFFRBN $PINS Q=buffer_pmp[8] D=pmp[8] CK=CTS_64
+ RB=FE_OFN552_i_reset_n_i
Xbuffer_pmp_reg[29] QDFFRBN $PINS Q=buffer_pmp[29] D=buffer_pmp[8] CK=CTS_64
+ RB=FE_OFN457_i_reset_n_i
Xbuffer_pmp_reg[50] QDFFRBN $PINS Q=buffer_pmp[50] D=buffer_pmp[29] CK=CTS_64
+ RB=FE_OFN1121_i_reset_n_i
Xbuffer_pmp_reg[71] QDFFRBN $PINS Q=buffer_pmp[71] D=buffer_pmp[50] CK=CTS_64
+ RB=FE_OFN1121_i_reset_n_i
Xbuffer_pmp_reg[92] QDFFRBN $PINS Q=buffer_pmp[92] D=buffer_pmp[71] CK=CTS_64
+ RB=FE_OFN1121_i_reset_n_i
Xbuffer_pmp_reg[113] QDFFRBN $PINS Q=buffer_pmp[113] D=buffer_pmp[92] CK=CTS_64
+ RB=FE_OFN1121_i_reset_n_i
Xbuffer_pmp_reg[134] QDFFRBN $PINS Q=buffer_pmp[134] D=buffer_pmp[113]
+ CK=CTS_64 RB=FE_OFN1108_i_reset_n_i
Xbuffer_pmp_reg[155] QDFFRBN $PINS Q=buffer_pmp[155] D=buffer_pmp[134]
+ CK=CTS_64 RB=FE_OFN1108_i_reset_n_i
Xbuffer_pmp_reg[176] QDFFRBN $PINS Q=buffer_pmp[176] D=buffer_pmp[155]
+ CK=CTS_64 RB=FE_OFN1108_i_reset_n_i
Xbuffer_pmp_reg[197] QDFFRBN $PINS Q=buffer_pmp[197] D=buffer_pmp[176]
+ CK=CTS_64 RB=FE_OFN1107_i_reset_n_i
Xbuffer_pmp_reg[218] QDFFRBN $PINS Q=buffer_pmp[218] D=buffer_pmp[197]
+ CK=CTS_64 RB=FE_OFN1057_i_reset_n_i
Xbuffer_pmp_reg[239] QDFFRBN $PINS Q=buffer_pmp[239] D=buffer_pmp[218]
+ CK=CTS_64 RB=FE_OFN1057_i_reset_n_i
Xbuffer_pmp_reg[260] QDFFRBN $PINS Q=buffer_pmp[260] D=buffer_pmp[239]
+ CK=CTS_64 RB=FE_OFN753_i_reset_n_i
Xbuffer_pmp_reg[281] QDFFRBN $PINS Q=buffer_pmp[281] D=buffer_pmp[260]
+ CK=CTS_64 RB=FE_OFN753_i_reset_n_i
Xbuffer_pmp_reg[302] QDFFRBN $PINS Q=buffer_pmp[302] D=buffer_pmp[281]
+ CK=CTS_64 RB=FE_OFN753_i_reset_n_i
Xbuffer_pmp_reg[323] QDFFRBN $PINS Q=buffer_pmp[323] D=buffer_pmp[302]
+ CK=CTS_64 RB=FE_OFN753_i_reset_n_i
Xbuffer_pmp_reg[344] QDFFRBN $PINS Q=buffer_pmp[344] D=buffer_pmp[323]
+ CK=CTS_65 RB=FE_OFN753_i_reset_n_i
Xbuffer_pmp_reg[365] QDFFRBN $PINS Q=buffer_pmp[365] D=buffer_pmp[344]
+ CK=CTS_62 RB=FE_OFN622_i_reset_n_i
Xbuffer_pmp_reg[386] QDFFRBN $PINS Q=buffer_pmp[386] D=buffer_pmp[365]
+ CK=CTS_62 RB=FE_OFN622_i_reset_n_i
Xbuffer_pmp_reg[407] QDFFRBN $PINS Q=buffer_pmp[407] D=buffer_pmp[386]
+ CK=CTS_65 RB=FE_OFN622_i_reset_n_i
Xbuffer_pmp_reg[428] QDFFRBN $PINS Q=buffer_pmp[428] D=buffer_pmp[407]
+ CK=CTS_65 RB=FE_OFN963_i_reset_n_i
Xbuffer_pmp_reg[449] QDFFRBN $PINS Q=buffer_pmp[449] D=buffer_pmp[428]
+ CK=CTS_65 RB=FE_OFN963_i_reset_n_i
Xbuffer_pmp_reg[470] QDFFRBN $PINS Q=buffer_pmp[470] D=buffer_pmp[449]
+ CK=CTS_65 RB=FE_OFN963_i_reset_n_i
Xbuffer_pmp_reg[491] QDFFRBN $PINS Q=buffer_pmp[491] D=buffer_pmp[470]
+ CK=CTS_65 RB=FE_OFN963_i_reset_n_i
Xbuffer_pmp_reg[512] QDFFRBN $PINS Q=buffer_pmp[512] D=buffer_pmp[491]
+ CK=CTS_65 RB=FE_OFN1036_i_reset_n_i
Xbuffer_pmp_reg[533] QDFFRBN $PINS Q=buffer_pmp[533] D=buffer_pmp[512]
+ CK=CTS_61 RB=FE_OFN1036_i_reset_n_i
Xbuffer_pmp_reg[554] QDFFRBN $PINS Q=buffer_pmp[554] D=buffer_pmp[533]
+ CK=CTS_65 RB=FE_OFN1036_i_reset_n_i
Xbuffer_pmp_reg[575] QDFFRBN $PINS Q=buffer_pmp[575] D=buffer_pmp[554]
+ CK=CTS_65 RB=FE_OFN1037_i_reset_n_i
Xbuffer_pmp_reg[596] QDFFRBN $PINS Q=buffer_pmp[596] D=buffer_pmp[575]
+ CK=CTS_65 RB=FE_OFN1037_i_reset_n_i
Xbuffer_pmp_reg[617] QDFFRBN $PINS Q=buffer_pmp[617] D=buffer_pmp[596]
+ CK=CTS_65 RB=FE_OFN1038_i_reset_n_i
Xbuffer_pmp_reg[638] QDFFRBN $PINS Q=buffer_pmp[638] D=buffer_pmp[617]
+ CK=CTS_65 RB=FE_OFN1038_i_reset_n_i
Xbuffer_pmp_reg[659] QDFFRBN $PINS Q=buffer_pmp[659] D=buffer_pmp[638]
+ CK=CTS_65 RB=FE_OFN892_i_reset_n_i
Xbuffer_pmp_reg[680] QDFFRBN $PINS Q=buffer_pmp[680] D=buffer_pmp[659]
+ CK=CTS_65 RB=FE_OFN892_i_reset_n_i
Xbuffer_pmp_reg[701] QDFFRBN $PINS Q=buffer_pmp[701] D=buffer_pmp[680]
+ CK=CTS_65 RB=FE_OFN764_i_reset_n_i
Xbuffer_pmp_reg[722] QDFFRBN $PINS Q=buffer_pmp[722] D=buffer_pmp[701]
+ CK=CTS_65 RB=FE_OFN977_i_reset_n_i
Xbuffer_pmp_reg[743] QDFFRBN $PINS Q=buffer_pmp[743] D=buffer_pmp[722]
+ CK=CTS_65 RB=FE_OFN977_i_reset_n_i
Xbuffer_pmp_reg[764] QDFFRBN $PINS Q=buffer_pmp[764] D=buffer_pmp[743]
+ CK=CTS_65 RB=FE_OFN977_i_reset_n_i
Xbuffer_pmp_reg[785] QDFFRBN $PINS Q=buffer_pmp[785] D=buffer_pmp[764]
+ CK=CTS_65 RB=FE_OFN977_i_reset_n_i
Xbuffer_pmp_reg[806] QDFFRBN $PINS Q=buffer_pmp[806] D=buffer_pmp[785]
+ CK=CTS_65 RB=FE_OFN891_i_reset_n_i
Xbuffer_pmp_reg[827] QDFFRBN $PINS Q=buffer_pmp[827] D=buffer_pmp[806]
+ CK=CTS_65 RB=FE_OFN977_i_reset_n_i
Xbuffer_pmp_reg[848] QDFFRBN $PINS Q=buffer_pmp[848] D=buffer_pmp[827]
+ CK=CTS_65 RB=FE_OFN764_i_reset_n_i
Xbuffer_pmp_reg[869] QDFFRBN $PINS Q=buffer_pmp[869] D=buffer_pmp[848]
+ CK=CTS_65 RB=FE_OFN764_i_reset_n_i
Xbuffer_pmp_reg[890] QDFFRBN $PINS Q=buffer_pmp[890] D=buffer_pmp[869]
+ CK=CTS_65 RB=FE_OFN764_i_reset_n_i
Xbuffer_pmp_reg[911] QDFFRBN $PINS Q=buffer_pmp[911] D=buffer_pmp[890]
+ CK=CTS_65 RB=FE_OFN892_i_reset_n_i
Xbuffer_pmp_reg[932] QDFFRBN $PINS Q=buffer_pmp[932] D=buffer_pmp[911]
+ CK=CTS_65 RB=FE_OFN892_i_reset_n_i
Xbuffer_pmp_reg[953] QDFFRBN $PINS Q=buffer_pmp[953] D=buffer_pmp[932]
+ CK=CTS_65 RB=FE_OFN892_i_reset_n_i
Xbuffer_pmp_reg[974] QDFFRBN $PINS Q=buffer_pmp[974] D=buffer_pmp[953]
+ CK=CTS_65 RB=FE_OFN892_i_reset_n_i
Xbuffer_pmp_reg[995] QDFFRBN $PINS Q=buffer_pmp[995] D=buffer_pmp[974]
+ CK=CTS_65 RB=FE_OFN632_i_reset_n_i
Xbuffer_pmp_reg[1016] QDFFRBN $PINS Q=buffer_pmp[1016] D=buffer_pmp[995]
+ CK=CTS_65 RB=FE_OFN632_i_reset_n_i
Xbuffer_pmp_reg[1037] QDFFRBN $PINS Q=buffer_pmp[1037] D=buffer_pmp[1016]
+ CK=CTS_65 RB=FE_OFN1036_i_reset_n_i
Xbuffer_pmp_reg[1058] QDFFRBN $PINS Q=buffer_pmp[1058] D=buffer_pmp[1037]
+ CK=CTS_65 RB=FE_OFN1036_i_reset_n_i
Xbuffer_pmp_reg[1079] QDFFRBN $PINS Q=buffer_pmp[1079] D=buffer_pmp[1058]
+ CK=CTS_61 RB=FE_OFN1072_i_reset_n_i
Xbuffer_pmp_reg[1100] QDFFRBN $PINS Q=buffer_pmp[1100] D=buffer_pmp[1079]
+ CK=CTS_61 RB=FE_OFN1072_i_reset_n_i
Xpmp_1_r_reg[8] QDFFRBN $PINS Q=pmp_1_r[8] D=pmp_1_w[8] CK=CTS_64
+ RB=FE_OFN1108_i_reset_n_i
Xbuffer_pmp_reg[9] QDFFRBN $PINS Q=buffer_pmp[9] D=pmp[9] CK=CTS_64
+ RB=FE_OFN457_i_reset_n_i
Xbuffer_pmp_reg[30] QDFFRBN $PINS Q=buffer_pmp[30] D=buffer_pmp[9] CK=CTS_64
+ RB=FE_OFN457_i_reset_n_i
Xbuffer_pmp_reg[51] QDFFRBN $PINS Q=buffer_pmp[51] D=buffer_pmp[30] CK=CTS_64
+ RB=FE_OFN752_i_reset_n_i
Xbuffer_pmp_reg[72] QDFFRBN $PINS Q=buffer_pmp[72] D=buffer_pmp[51] CK=CTS_64
+ RB=FE_OFN752_i_reset_n_i
Xbuffer_pmp_reg[93] QDFFRBN $PINS Q=buffer_pmp[93] D=buffer_pmp[72] CK=CTS_64
+ RB=FE_OFN881_i_reset_n_i
Xbuffer_pmp_reg[114] QDFFRBN $PINS Q=buffer_pmp[114] D=buffer_pmp[93] CK=CTS_64
+ RB=FE_OFN960_i_reset_n_i
Xbuffer_pmp_reg[135] QDFFRBN $PINS Q=buffer_pmp[135] D=buffer_pmp[114]
+ CK=CTS_64 RB=FE_OFN960_i_reset_n_i
Xbuffer_pmp_reg[156] QDFFRBN $PINS Q=buffer_pmp[156] D=buffer_pmp[135]
+ CK=CTS_64 RB=FE_OFN960_i_reset_n_i
Xbuffer_pmp_reg[177] QDFFRBN $PINS Q=buffer_pmp[177] D=buffer_pmp[156]
+ CK=CTS_64 RB=FE_OFN1121_i_reset_n_i
Xbuffer_pmp_reg[198] QDFFRBN $PINS Q=buffer_pmp[198] D=buffer_pmp[177]
+ CK=CTS_64 RB=FE_OFN1121_i_reset_n_i
Xbuffer_pmp_reg[219] QDFFRBN $PINS Q=buffer_pmp[219] D=buffer_pmp[198]
+ CK=CTS_64 RB=FE_OCPN9774_FE_OFN516_i_reset_n_i
Xbuffer_pmp_reg[240] QDFFRBN $PINS Q=buffer_pmp[240] D=buffer_pmp[219]
+ CK=CTS_62 RB=FE_OCPN9774_FE_OFN516_i_reset_n_i
Xbuffer_pmp_reg[261] QDFFRBN $PINS Q=buffer_pmp[261] D=buffer_pmp[240]
+ CK=CTS_62 RB=FE_OCPN9774_FE_OFN516_i_reset_n_i
Xbuffer_pmp_reg[282] QDFFRBN $PINS Q=buffer_pmp[282] D=buffer_pmp[261]
+ CK=CTS_64 RB=FE_OFN622_i_reset_n_i
Xbuffer_pmp_reg[303] QDFFRBN $PINS Q=buffer_pmp[303] D=buffer_pmp[282]
+ CK=CTS_62 RB=FE_OFN754_i_reset_n_i
Xbuffer_pmp_reg[324] QDFFRBN $PINS Q=buffer_pmp[324] D=buffer_pmp[303]
+ CK=CTS_62 RB=FE_OFN754_i_reset_n_i
Xbuffer_pmp_reg[345] QDFFRBN $PINS Q=buffer_pmp[345] D=buffer_pmp[324]
+ CK=CTS_62 RB=FE_OFN754_i_reset_n_i
Xbuffer_pmp_reg[366] QDFFRBN $PINS Q=buffer_pmp[366] D=buffer_pmp[345]
+ CK=CTS_62 RB=FE_OCPN9774_FE_OFN516_i_reset_n_i
Xbuffer_pmp_reg[387] QDFFRBN $PINS Q=buffer_pmp[387] D=buffer_pmp[366]
+ CK=CTS_62 RB=FE_OFN1114_i_reset_n_i
Xbuffer_pmp_reg[408] QDFFRBN $PINS Q=buffer_pmp[408] D=buffer_pmp[387]
+ CK=CTS_62 RB=FE_OFN1114_i_reset_n_i
Xbuffer_pmp_reg[429] QDFFRBN $PINS Q=buffer_pmp[429] D=buffer_pmp[408]
+ CK=CTS_62 RB=FE_OFN1114_i_reset_n_i
Xbuffer_pmp_reg[450] QDFFRBN $PINS Q=buffer_pmp[450] D=buffer_pmp[429]
+ CK=CTS_62 RB=FE_OFN1113_i_reset_n_i
Xbuffer_pmp_reg[471] QDFFRBN $PINS Q=buffer_pmp[471] D=buffer_pmp[450]
+ CK=CTS_62 RB=FE_OFN1113_i_reset_n_i
Xbuffer_pmp_reg[492] QDFFRBN $PINS Q=buffer_pmp[492] D=buffer_pmp[471]
+ CK=CTS_62 RB=FE_OFN1113_i_reset_n_i
Xbuffer_pmp_reg[513] QDFFRBN $PINS Q=buffer_pmp[513] D=buffer_pmp[492]
+ CK=CTS_62 RB=FE_OFN1114_i_reset_n_i
Xbuffer_pmp_reg[534] QDFFRBN $PINS Q=buffer_pmp[534] D=buffer_pmp[513]
+ CK=CTS_62 RB=FE_OFN1115_i_reset_n_i
Xbuffer_pmp_reg[555] QDFFRBN $PINS Q=buffer_pmp[555] D=buffer_pmp[534]
+ CK=CTS_62 RB=FE_OFN1115_i_reset_n_i
Xbuffer_pmp_reg[576] QDFFRBN $PINS Q=buffer_pmp[576] D=buffer_pmp[555]
+ CK=CTS_62 RB=FE_OFN962_i_reset_n_i
Xbuffer_pmp_reg[597] QDFFRBN $PINS Q=buffer_pmp[597] D=buffer_pmp[576]
+ CK=CTS_62 RB=FE_OFN962_i_reset_n_i
Xbuffer_pmp_reg[618] QDFFRBN $PINS Q=buffer_pmp[618] D=buffer_pmp[597]
+ CK=CTS_62 RB=FE_OFN962_i_reset_n_i
Xbuffer_pmp_reg[639] QDFFRBN $PINS Q=buffer_pmp[639] D=buffer_pmp[618]
+ CK=CTS_65 RB=FE_OFN964_i_reset_n_i
Xbuffer_pmp_reg[660] QDFFRBN $PINS Q=buffer_pmp[660] D=buffer_pmp[639]
+ CK=CTS_65 RB=FE_OFN964_i_reset_n_i
Xbuffer_pmp_reg[681] QDFFRBN $PINS Q=buffer_pmp[681] D=buffer_pmp[660]
+ CK=CTS_65 RB=FE_OFN1037_i_reset_n_i
Xbuffer_pmp_reg[702] QDFFRBN $PINS Q=buffer_pmp[702] D=buffer_pmp[681]
+ CK=CTS_65 RB=FE_OFN964_i_reset_n_i
Xbuffer_pmp_reg[723] QDFFRBN $PINS Q=buffer_pmp[723] D=buffer_pmp[702]
+ CK=CTS_65 RB=FE_OFN1038_i_reset_n_i
Xbuffer_pmp_reg[744] QDFFRBN $PINS Q=buffer_pmp[744] D=buffer_pmp[723]
+ CK=CTS_65 RB=FE_OFN1073_i_reset_n_i
Xbuffer_pmp_reg[765] QDFFRBN $PINS Q=buffer_pmp[765] D=buffer_pmp[744]
+ CK=CTS_65 RB=FE_OFN1074_i_reset_n_i
Xbuffer_pmp_reg[786] QDFFRBN $PINS Q=buffer_pmp[786] D=buffer_pmp[765]
+ CK=CTS_62 RB=FE_OFN1074_i_reset_n_i
Xbuffer_pmp_reg[807] QDFFRBN $PINS Q=buffer_pmp[807] D=buffer_pmp[786]
+ CK=CTS_62 RB=FE_OFN1074_i_reset_n_i
Xbuffer_pmp_reg[828] QDFFRBN $PINS Q=buffer_pmp[828] D=buffer_pmp[807]
+ CK=CTS_65 RB=FE_OFN1074_i_reset_n_i
Xbuffer_pmp_reg[849] QDFFRBN $PINS Q=buffer_pmp[849] D=buffer_pmp[828]
+ CK=CTS_65 RB=FE_OFN1073_i_reset_n_i
Xbuffer_pmp_reg[870] QDFFRBN $PINS Q=buffer_pmp[870] D=buffer_pmp[849]
+ CK=CTS_65 RB=FE_OFN1038_i_reset_n_i
Xbuffer_pmp_reg[891] QDFFRBN $PINS Q=buffer_pmp[891] D=buffer_pmp[870]
+ CK=CTS_65 RB=FE_OFN1038_i_reset_n_i
Xbuffer_pmp_reg[912] QDFFRBN $PINS Q=buffer_pmp[912] D=buffer_pmp[891]
+ CK=CTS_65 RB=FE_OFN1037_i_reset_n_i
Xbuffer_pmp_reg[933] QDFFRBN $PINS Q=buffer_pmp[933] D=buffer_pmp[912]
+ CK=CTS_65 RB=FE_OFN1037_i_reset_n_i
Xbuffer_pmp_reg[954] QDFFRBN $PINS Q=buffer_pmp[954] D=buffer_pmp[933]
+ CK=CTS_65 RB=FE_OFN963_i_reset_n_i
Xbuffer_pmp_reg[975] QDFFRBN $PINS Q=buffer_pmp[975] D=buffer_pmp[954]
+ CK=CTS_65 RB=FE_OFN882_i_reset_n_i
Xbuffer_pmp_reg[996] QDFFRBN $PINS Q=buffer_pmp[996] D=buffer_pmp[975]
+ CK=CTS_65 RB=FE_OFN882_i_reset_n_i
Xbuffer_pmp_reg[1017] QDFFRBN $PINS Q=buffer_pmp[1017] D=buffer_pmp[996]
+ CK=CTS_62 RB=FE_OFN882_i_reset_n_i
Xbuffer_pmp_reg[1038] QDFFRBN $PINS Q=buffer_pmp[1038] D=buffer_pmp[1017]
+ CK=CTS_62 RB=FE_OFN962_i_reset_n_i
Xbuffer_pmp_reg[1059] QDFFRBN $PINS Q=buffer_pmp[1059] D=buffer_pmp[1038]
+ CK=CTS_62 RB=FE_OFN754_i_reset_n_i
Xbuffer_pmp_reg[1080] QDFFRBN $PINS Q=buffer_pmp[1080] D=buffer_pmp[1059]
+ CK=CTS_62 RB=FE_OFN754_i_reset_n_i
Xbuffer_pmp_reg[1101] QDFFRBN $PINS Q=buffer_pmp[1101] D=buffer_pmp[1080]
+ CK=CTS_62 RB=FE_OCPN9774_FE_OFN516_i_reset_n_i
Xpmp_1_r_reg[9] QDFFRBN $PINS Q=pmp_1_r[9] D=pmp_1_w[9] CK=CTS_64
+ RB=FE_OFN960_i_reset_n_i
Xbuffer_pmp_reg[10] QDFFRBN $PINS Q=buffer_pmp[10] D=pmp[10] CK=CTS_44
+ RB=FE_OFN755_i_reset_n_i
Xbuffer_pmp_reg[31] QDFFRBN $PINS Q=buffer_pmp[31] D=buffer_pmp[10] CK=CTS_44
+ RB=FE_OFN883_i_reset_n_i
Xbuffer_pmp_reg[52] QDFFRBN $PINS Q=buffer_pmp[52] D=buffer_pmp[31] CK=CTS_44
+ RB=FE_OFN966_i_reset_n_i
Xbuffer_pmp_reg[73] QDFFRBN $PINS Q=buffer_pmp[73] D=buffer_pmp[52] CK=CTS_46
+ RB=FE_OFN619_i_reset_n_i
Xbuffer_pmp_reg[94] QDFFRBN $PINS Q=buffer_pmp[94] D=buffer_pmp[73] CK=CTS_44
+ RB=FE_OFN1119_i_reset_n_i
Xbuffer_pmp_reg[115] QDFFRBN $PINS Q=buffer_pmp[115] D=buffer_pmp[94] CK=CTS_44
+ RB=FE_OFN1106_i_reset_n_i
Xbuffer_pmp_reg[136] QDFFRBN $PINS Q=buffer_pmp[136] D=buffer_pmp[115]
+ CK=CTS_43 RB=FE_OFN1086_i_reset_n_i
Xbuffer_pmp_reg[157] QDFFRBN $PINS Q=buffer_pmp[157] D=buffer_pmp[136]
+ CK=CTS_43 RB=FE_OFN1029_i_reset_n_i
Xbuffer_pmp_reg[178] QDFFRBN $PINS Q=buffer_pmp[178] D=buffer_pmp[157]
+ CK=CTS_43 RB=FE_OFN1029_i_reset_n_i
Xbuffer_pmp_reg[199] QDFFRBN $PINS Q=buffer_pmp[199] D=buffer_pmp[178]
+ CK=CTS_43 RB=FE_OFN1029_i_reset_n_i
Xbuffer_pmp_reg[220] QDFFRBN $PINS Q=buffer_pmp[220] D=buffer_pmp[199]
+ CK=CTS_43 RB=FE_OFN1031_i_reset_n_i
Xbuffer_pmp_reg[241] QDFFRBN $PINS Q=buffer_pmp[241] D=buffer_pmp[220]
+ CK=CTS_43 RB=FE_OFN1069_i_reset_n_i
Xbuffer_pmp_reg[262] QDFFRBN $PINS Q=buffer_pmp[262] D=buffer_pmp[241]
+ CK=CTS_43 RB=FE_OFN1069_i_reset_n_i
Xbuffer_pmp_reg[283] QDFFRBN $PINS Q=buffer_pmp[283] D=buffer_pmp[262]
+ CK=CTS_43 RB=FE_OFN1069_i_reset_n_i
Xbuffer_pmp_reg[304] QDFFRBN $PINS Q=buffer_pmp[304] D=buffer_pmp[283]
+ CK=CTS_43 RB=FE_OFN1069_i_reset_n_i
Xbuffer_pmp_reg[325] QDFFRBN $PINS Q=buffer_pmp[325] D=buffer_pmp[304]
+ CK=CTS_47 RB=FE_OFN1104_i_reset_n_i
Xbuffer_pmp_reg[346] QDFFRBN $PINS Q=buffer_pmp[346] D=buffer_pmp[325]
+ CK=CTS_43 RB=FE_OFN1047_i_reset_n_i
Xbuffer_pmp_reg[367] QDFFRBN $PINS Q=buffer_pmp[367] D=buffer_pmp[346]
+ CK=CTS_43 RB=FE_OFN1069_i_reset_n_i
Xbuffer_pmp_reg[388] QDFFRBN $PINS Q=buffer_pmp[388] D=buffer_pmp[367]
+ CK=CTS_43 RB=FE_OFN1069_i_reset_n_i
Xbuffer_pmp_reg[409] QDFFRBN $PINS Q=buffer_pmp[409] D=buffer_pmp[388]
+ CK=CTS_47 RB=FE_OFN1047_i_reset_n_i
Xbuffer_pmp_reg[430] QDFFRBN $PINS Q=buffer_pmp[430] D=buffer_pmp[409]
+ CK=CTS_47 RB=FE_OFN1047_i_reset_n_i
Xbuffer_pmp_reg[451] QDFFRBN $PINS Q=buffer_pmp[451] D=buffer_pmp[430]
+ CK=CTS_47 RB=FE_OFN1047_i_reset_n_i
Xbuffer_pmp_reg[472] QDFFRBN $PINS Q=buffer_pmp[472] D=buffer_pmp[451]
+ CK=CTS_47 RB=FE_OFN888_i_reset_n_i
Xbuffer_pmp_reg[493] QDFFRBN $PINS Q=buffer_pmp[493] D=buffer_pmp[472]
+ CK=CTS_47 RB=FE_OFN888_i_reset_n_i
Xbuffer_pmp_reg[514] QDFFRBN $PINS Q=buffer_pmp[514] D=buffer_pmp[493]
+ CK=CTS_47 RB=FE_OFN888_i_reset_n_i
Xbuffer_pmp_reg[535] QDFFRBN $PINS Q=buffer_pmp[535] D=buffer_pmp[514]
+ CK=CTS_47 RB=FE_OFN758_i_reset_n_i
Xbuffer_pmp_reg[556] QDFFRBN $PINS Q=buffer_pmp[556] D=buffer_pmp[535]
+ CK=CTS_47 RB=FE_OFN972_i_reset_n_i
Xbuffer_pmp_reg[577] QDFFRBN $PINS Q=buffer_pmp[577] D=buffer_pmp[556]
+ CK=CTS_47 RB=FE_OFN1105_i_reset_n_i
Xbuffer_pmp_reg[598] QDFFRBN $PINS Q=buffer_pmp[598] D=buffer_pmp[577]
+ CK=CTS_47 RB=FE_OFN1118_i_reset_n_i
Xbuffer_pmp_reg[619] QDFFRBN $PINS Q=buffer_pmp[619] D=buffer_pmp[598]
+ CK=CTS_47 RB=FE_OFN1118_i_reset_n_i
Xbuffer_pmp_reg[640] QDFFRBN $PINS Q=buffer_pmp[640] D=buffer_pmp[619]
+ CK=CTS_47 RB=FE_OFN1118_i_reset_n_i
Xbuffer_pmp_reg[661] QDFFRBN $PINS Q=buffer_pmp[661] D=buffer_pmp[640]
+ CK=CTS_56 RB=FE_OFN1088_i_reset_n_i
Xbuffer_pmp_reg[682] QDFFRBN $PINS Q=buffer_pmp[682] D=buffer_pmp[661]
+ CK=CTS_47 RB=FE_OFN1088_i_reset_n_i
Xbuffer_pmp_reg[703] QDFFRBN $PINS Q=buffer_pmp[703] D=buffer_pmp[682]
+ CK=CTS_56 RB=FE_OFN1088_i_reset_n_i
Xbuffer_pmp_reg[724] QDFFRBN $PINS Q=buffer_pmp[724] D=buffer_pmp[703]
+ CK=CTS_56 RB=FE_OFN1088_i_reset_n_i
Xbuffer_pmp_reg[745] QDFFRBN $PINS Q=buffer_pmp[745] D=buffer_pmp[724]
+ CK=CTS_56 RB=FE_OFN1088_i_reset_n_i
Xbuffer_pmp_reg[766] QDFFRBN $PINS Q=buffer_pmp[766] D=buffer_pmp[745]
+ CK=CTS_56 RB=FE_OFN1087_i_reset_n_i
Xbuffer_pmp_reg[787] QDFFRBN $PINS Q=buffer_pmp[787] D=buffer_pmp[766]
+ CK=CTS_56 RB=FE_OFN1087_i_reset_n_i
Xbuffer_pmp_reg[808] QDFFRBN $PINS Q=buffer_pmp[808] D=buffer_pmp[787]
+ CK=CTS_56 RB=FE_OFN1087_i_reset_n_i
Xbuffer_pmp_reg[829] QDFFRBN $PINS Q=buffer_pmp[829] D=buffer_pmp[808]
+ CK=CTS_56 RB=FE_OFN1087_i_reset_n_i
Xbuffer_pmp_reg[850] QDFFRBN $PINS Q=buffer_pmp[850] D=buffer_pmp[829]
+ CK=CTS_56 RB=FE_OFN1087_i_reset_n_i
Xbuffer_pmp_reg[871] QDFFRBN $PINS Q=buffer_pmp[871] D=buffer_pmp[850]
+ CK=CTS_56 RB=FE_OFN1087_i_reset_n_i
Xbuffer_pmp_reg[892] QDFFRBN $PINS Q=buffer_pmp[892] D=buffer_pmp[871]
+ CK=CTS_56 RB=FE_OFN1049_i_reset_n_i
Xbuffer_pmp_reg[913] QDFFRBN $PINS Q=buffer_pmp[913] D=buffer_pmp[892]
+ CK=CTS_56 RB=FE_OFN1049_i_reset_n_i
Xbuffer_pmp_reg[934] QDFFRBN $PINS Q=buffer_pmp[934] D=buffer_pmp[913]
+ CK=CTS_56 RB=FE_OFN1049_i_reset_n_i
Xbuffer_pmp_reg[955] QDFFRBN $PINS Q=buffer_pmp[955] D=buffer_pmp[934]
+ CK=CTS_47 RB=FE_OFN1088_i_reset_n_i
Xbuffer_pmp_reg[976] QDFFRBN $PINS Q=buffer_pmp[976] D=buffer_pmp[955]
+ CK=CTS_47 RB=FE_OFN887_i_reset_n_i
Xbuffer_pmp_reg[997] QDFFRBN $PINS Q=buffer_pmp[997] D=buffer_pmp[976]
+ CK=CTS_47 RB=FE_OFN887_i_reset_n_i
Xbuffer_pmp_reg[1018] QDFFRBN $PINS Q=buffer_pmp[1018] D=buffer_pmp[997]
+ CK=CTS_47 RB=FE_OFN886_i_reset_n_i
Xbuffer_pmp_reg[1039] QDFFRBN $PINS Q=buffer_pmp[1039] D=buffer_pmp[1018]
+ CK=CTS_47 RB=FE_OFN886_i_reset_n_i
Xbuffer_pmp_reg[1060] QDFFRBN $PINS Q=buffer_pmp[1060] D=buffer_pmp[1039]
+ CK=CTS_47 RB=FE_OFN758_i_reset_n_i
Xbuffer_pmp_reg[1081] QDFFRBN $PINS Q=buffer_pmp[1081] D=buffer_pmp[1060]
+ CK=CTS_47 RB=FE_OFN627_i_reset_n_i
Xbuffer_pmp_reg[1102] QDFFRBN $PINS Q=buffer_pmp[1102] D=buffer_pmp[1081]
+ CK=CTS_47 RB=FE_OFN519_i_reset_n_i
Xpmp_1_r_reg[10] QDFFRBN $PINS Q=pmp_1_r[10] D=pmp_1_w[10] CK=CTS_47
+ RB=FE_OFN757_i_reset_n_i
Xbuffer_pmp_reg[11] QDFFRBN $PINS Q=buffer_pmp[11] D=pmp[11] CK=CTS_44
+ RB=FE_OFN755_i_reset_n_i
Xbuffer_pmp_reg[32] QDFFRBN $PINS Q=buffer_pmp[32] D=buffer_pmp[11] CK=CTS_46
+ RB=FE_OFN965_i_reset_n_i
Xbuffer_pmp_reg[53] QDFFRBN $PINS Q=buffer_pmp[53] D=buffer_pmp[32] CK=CTS_46
+ RB=FE_OFN957_i_reset_n_i
Xbuffer_pmp_reg[74] QDFFRBN $PINS Q=buffer_pmp[74] D=buffer_pmp[53] CK=CTS_46
+ RB=FE_OFN876_i_reset_n_i
Xbuffer_pmp_reg[95] QDFFRBN $PINS Q=buffer_pmp[95] D=buffer_pmp[74] CK=CTS_46
+ RB=FE_OFN876_i_reset_n_i
Xbuffer_pmp_reg[116] QDFFRBN $PINS Q=buffer_pmp[116] D=buffer_pmp[95] CK=CTS_46
+ RB=FE_OFN749_i_reset_n_i
Xbuffer_pmp_reg[137] QDFFRBN $PINS Q=buffer_pmp[137] D=buffer_pmp[116]
+ CK=CTS_46 RB=FE_OFN749_i_reset_n_i
Xbuffer_pmp_reg[158] QDFFRBN $PINS Q=buffer_pmp[158] D=buffer_pmp[137]
+ CK=CTS_46 RB=FE_OFN749_i_reset_n_i
Xbuffer_pmp_reg[179] QDFFRBN $PINS Q=buffer_pmp[179] D=buffer_pmp[158]
+ CK=CTS_46 RB=FE_OFN956_i_reset_n_i
Xbuffer_pmp_reg[200] QDFFRBN $PINS Q=buffer_pmp[200] D=buffer_pmp[179]
+ CK=CTS_46 RB=FE_OFN956_i_reset_n_i
Xbuffer_pmp_reg[221] QDFFRBN $PINS Q=buffer_pmp[221] D=buffer_pmp[200]
+ CK=CTS_46 RB=FE_OFN519_i_reset_n_i
Xbuffer_pmp_reg[242] QDFFRBN $PINS Q=buffer_pmp[242] D=buffer_pmp[221]
+ CK=CTS_46 RB=FE_OFN433_i_reset_n_i
Xbuffer_pmp_reg[263] QDFFRBN $PINS Q=buffer_pmp[263] D=buffer_pmp[242]
+ CK=CTS_46 RB=FE_OFN886_i_reset_n_i
Xbuffer_pmp_reg[284] QDFFRBN $PINS Q=buffer_pmp[284] D=buffer_pmp[263]
+ CK=CTS_47 RB=FE_OFN886_i_reset_n_i
Xbuffer_pmp_reg[305] QDFFRBN $PINS Q=buffer_pmp[305] D=buffer_pmp[284]
+ CK=CTS_47 RB=FE_OFN886_i_reset_n_i
Xbuffer_pmp_reg[326] QDFFRBN $PINS Q=buffer_pmp[326] D=buffer_pmp[305]
+ CK=CTS_47 RB=FE_OFN1050_i_reset_n_i
Xbuffer_pmp_reg[347] QDFFRBN $PINS Q=buffer_pmp[347] D=buffer_pmp[326]
+ CK=CTS_47 RB=FE_OFN1050_i_reset_n_i
Xbuffer_pmp_reg[368] QDFFRBN $PINS Q=buffer_pmp[368] D=buffer_pmp[347]
+ CK=CTS_47 RB=FE_OFN1050_i_reset_n_i
Xbuffer_pmp_reg[389] QDFFRBN $PINS Q=buffer_pmp[389] D=buffer_pmp[368]
+ CK=CTS_47 RB=FE_OFN1049_i_reset_n_i
Xbuffer_pmp_reg[410] QDFFRBN $PINS Q=buffer_pmp[410] D=buffer_pmp[389]
+ CK=CTS_56 RB=FE_OFN974_i_reset_n_i
Xbuffer_pmp_reg[431] QDFFRBN $PINS Q=buffer_pmp[431] D=buffer_pmp[410]
+ CK=CTS_56 RB=FE_OFN1048_i_reset_n_i
Xbuffer_pmp_reg[452] QDFFRBN $PINS Q=buffer_pmp[452] D=buffer_pmp[431]
+ CK=CTS_56 RB=FE_OFN1048_i_reset_n_i
Xbuffer_pmp_reg[473] QDFFRBN $PINS Q=buffer_pmp[473] D=buffer_pmp[452]
+ CK=CTS_56 RB=FE_OFN760_i_reset_n_i
Xbuffer_pmp_reg[494] QDFFRBN $PINS Q=buffer_pmp[494] D=buffer_pmp[473]
+ CK=CTS_56 RB=FE_OFN629_i_reset_n_i
Xbuffer_pmp_reg[515] QDFFRBN $PINS Q=buffer_pmp[515] D=buffer_pmp[494]
+ CK=CTS_56 RB=FE_OFN760_i_reset_n_i
Xbuffer_pmp_reg[536] QDFFRBN $PINS Q=buffer_pmp[536] D=buffer_pmp[515]
+ CK=CTS_56 RB=FE_OFN628_i_reset_n_i
Xbuffer_pmp_reg[557] QDFFRBN $PINS Q=buffer_pmp[557] D=buffer_pmp[536]
+ CK=CTS_56 RB=FE_OFN628_i_reset_n_i
Xbuffer_pmp_reg[578] QDFFRBN $PINS Q=buffer_pmp[578] D=buffer_pmp[557]
+ CK=CTS_56 RB=FE_OFN628_i_reset_n_i
Xbuffer_pmp_reg[599] QDFFRBN $PINS Q=buffer_pmp[599] D=buffer_pmp[578]
+ CK=CTS_53 RB=FE_OFN1116_i_reset_n_i
Xbuffer_pmp_reg[620] QDFFRBN $PINS Q=buffer_pmp[620] D=buffer_pmp[599]
+ CK=CTS_53 RB=FE_OFN1083_i_reset_n_i
Xbuffer_pmp_reg[641] QDFFRBN $PINS Q=buffer_pmp[641] D=buffer_pmp[620]
+ CK=CTS_53 RB=FE_OFN1083_i_reset_n_i
Xbuffer_pmp_reg[662] QDFFRBN $PINS Q=buffer_pmp[662] D=buffer_pmp[641]
+ CK=CTS_53 RB=FE_OFN1044_i_reset_n_i
Xbuffer_pmp_reg[683] QDFFRBN $PINS Q=buffer_pmp[683] D=buffer_pmp[662]
+ CK=CTS_53 RB=FE_OFN1044_i_reset_n_i
Xbuffer_pmp_reg[704] QDFFRBN $PINS Q=buffer_pmp[704] D=buffer_pmp[683]
+ CK=CTS_53 RB=FE_OFN971_i_reset_n_i
Xbuffer_pmp_reg[725] QDFFRBN $PINS Q=buffer_pmp[725] D=buffer_pmp[704]
+ CK=CTS_53 RB=FE_OFN885_i_reset_n_i
Xbuffer_pmp_reg[746] QDFFRBN $PINS Q=buffer_pmp[746] D=buffer_pmp[725]
+ CK=CTS_53 RB=FE_OFN625_i_reset_n_i
Xbuffer_pmp_reg[767] QDFFRBN $PINS Q=buffer_pmp[767] D=buffer_pmp[746]
+ CK=CTS_53 RB=FE_OFN625_i_reset_n_i
Xbuffer_pmp_reg[788] QDFFRBN $PINS Q=buffer_pmp[788] D=buffer_pmp[767]
+ CK=CTS_53 RB=FE_OFN756_i_reset_n_i
Xbuffer_pmp_reg[809] QDFFRBN $PINS Q=buffer_pmp[809] D=buffer_pmp[788]
+ CK=CTS_53 RB=FE_OFN756_i_reset_n_i
Xbuffer_pmp_reg[830] QDFFRBN $PINS Q=buffer_pmp[830] D=buffer_pmp[809]
+ CK=CTS_53 RB=FE_OFN756_i_reset_n_i
Xbuffer_pmp_reg[851] QDFFRBN $PINS Q=buffer_pmp[851] D=buffer_pmp[830]
+ CK=CTS_53 RB=FE_OFN756_i_reset_n_i
Xbuffer_pmp_reg[872] QDFFRBN $PINS Q=buffer_pmp[872] D=buffer_pmp[851]
+ CK=CTS_53 RB=FE_OFN756_i_reset_n_i
Xbuffer_pmp_reg[893] QDFFRBN $PINS Q=buffer_pmp[893] D=buffer_pmp[872]
+ CK=CTS_53 RB=FE_OFN885_i_reset_n_i
Xbuffer_pmp_reg[914] QDFFRBN $PINS Q=buffer_pmp[914] D=buffer_pmp[893]
+ CK=CTS_53 RB=FE_OFN1080_i_reset_n_i
Xbuffer_pmp_reg[935] QDFFRBN $PINS Q=buffer_pmp[935] D=buffer_pmp[914]
+ CK=CTS_53 RB=FE_OFN1043_i_reset_n_i
Xbuffer_pmp_reg[956] QDFFRBN $PINS Q=buffer_pmp[956] D=buffer_pmp[935]
+ CK=CTS_53 RB=FE_OFN1082_i_reset_n_i
Xbuffer_pmp_reg[977] QDFFRBN $PINS Q=buffer_pmp[977] D=buffer_pmp[956]
+ CK=CTS_53 RB=FE_OFN1082_i_reset_n_i
Xbuffer_pmp_reg[998] QDFFRBN $PINS Q=buffer_pmp[998] D=buffer_pmp[977]
+ CK=CTS_53 RB=FE_OFN1084_i_reset_n_i
Xbuffer_pmp_reg[1019] QDFFRBN $PINS Q=buffer_pmp[1019] D=buffer_pmp[998]
+ CK=CTS_53 RB=FE_OFN1083_i_reset_n_i
Xbuffer_pmp_reg[1040] QDFFRBN $PINS Q=buffer_pmp[1040] D=buffer_pmp[1019]
+ CK=CTS_53 RB=FE_OFN1116_i_reset_n_i
Xbuffer_pmp_reg[1061] QDFFRBN $PINS Q=buffer_pmp[1061] D=buffer_pmp[1040]
+ CK=CTS_56 RB=FE_OFN1116_i_reset_n_i
Xbuffer_pmp_reg[1082] QDFFRBN $PINS Q=buffer_pmp[1082] D=buffer_pmp[1061]
+ CK=CTS_56 RB=FE_OFN520_i_reset_n_i
Xbuffer_pmp_reg[1103] QDFFRBN $PINS Q=buffer_pmp[1103] D=buffer_pmp[1082]
+ CK=CTS_56 RB=FE_OFN520_i_reset_n_i
Xpmp_1_r_reg[11] QDFFRBN $PINS Q=pmp_1_r[11] D=pmp_1_w[11] CK=CTS_56
+ RB=FE_OFN1051_i_reset_n_i
Xbuffer_pmp_reg[12] QDFFRBN $PINS Q=buffer_pmp[12] D=pmp[12] CK=CTS_46
+ RB=FE_OFN1028_i_reset_n_i
Xbuffer_pmp_reg[33] QDFFRBN $PINS Q=buffer_pmp[33] D=buffer_pmp[12] CK=CTS_46
+ RB=FE_OCPN9776_FE_OFN514_i_reset_n_i
Xbuffer_pmp_reg[54] QDFFRBN $PINS Q=buffer_pmp[54] D=buffer_pmp[33] CK=CTS_46
+ RB=FE_OFN957_i_reset_n_i
Xbuffer_pmp_reg[75] QDFFRBN $PINS Q=buffer_pmp[75] D=buffer_pmp[54] CK=CTS_46
+ RB=FE_OFN957_i_reset_n_i
Xbuffer_pmp_reg[96] QDFFRBN $PINS Q=buffer_pmp[96] D=buffer_pmp[75] CK=CTS_46
+ RB=FE_OFN1027_i_reset_n_i
Xbuffer_pmp_reg[117] QDFFRBN $PINS Q=buffer_pmp[117] D=buffer_pmp[96] CK=CTS_46
+ RB=FE_OFN1027_i_reset_n_i
Xbuffer_pmp_reg[138] QDFFRBN $PINS Q=buffer_pmp[138] D=buffer_pmp[117]
+ CK=CTS_46 RB=FE_OFN1027_i_reset_n_i
Xbuffer_pmp_reg[159] QDFFRBN $PINS Q=buffer_pmp[159] D=buffer_pmp[138]
+ CK=CTS_46 RB=FE_OFN618_i_reset_n_i
Xbuffer_pmp_reg[180] QDFFRBN $PINS Q=buffer_pmp[180] D=buffer_pmp[159]
+ CK=CTS_46 RB=FE_OFN956_i_reset_n_i
Xbuffer_pmp_reg[201] QDFFRBN $PINS Q=buffer_pmp[201] D=buffer_pmp[180]
+ CK=CTS_46 RB=FE_OFN1026_i_reset_n_i
Xbuffer_pmp_reg[222] QDFFRBN $PINS Q=buffer_pmp[222] D=buffer_pmp[201]
+ CK=CTS_46 RB=FE_OFN1026_i_reset_n_i
Xbuffer_pmp_reg[243] QDFFRBN $PINS Q=buffer_pmp[243] D=buffer_pmp[222]
+ CK=CTS_56 RB=FE_OFN1051_i_reset_n_i
Xbuffer_pmp_reg[264] QDFFRBN $PINS Q=buffer_pmp[264] D=buffer_pmp[243]
+ CK=CTS_56 RB=FE_OFN1051_i_reset_n_i
Xbuffer_pmp_reg[285] QDFFRBN $PINS Q=buffer_pmp[285] D=buffer_pmp[264]
+ CK=CTS_56 RB=FE_OFN975_i_reset_n_i
Xbuffer_pmp_reg[306] QDFFRBN $PINS Q=buffer_pmp[306] D=buffer_pmp[285]
+ CK=CTS_56 RB=FE_OFN975_i_reset_n_i
Xbuffer_pmp_reg[327] QDFFRBN $PINS Q=buffer_pmp[327] D=buffer_pmp[306]
+ CK=CTS_56 RB=FE_OFN975_i_reset_n_i
Xbuffer_pmp_reg[348] QDFFRBN $PINS Q=buffer_pmp[348] D=buffer_pmp[327]
+ CK=CTS_56 RB=FE_OFN890_i_reset_n_i
Xbuffer_pmp_reg[369] QDFFRBN $PINS Q=buffer_pmp[369] D=buffer_pmp[348]
+ CK=CTS_56 RB=FE_OFN974_i_reset_n_i
Xbuffer_pmp_reg[390] QDFFRBN $PINS Q=buffer_pmp[390] D=buffer_pmp[369]
+ CK=CTS_56 RB=FE_OFN889_i_reset_n_i
Xbuffer_pmp_reg[411] QDFFRBN $PINS Q=buffer_pmp[411] D=buffer_pmp[390]
+ CK=CTS_56 RB=FE_OFN889_i_reset_n_i
Xbuffer_pmp_reg[432] QDFFRBN $PINS Q=buffer_pmp[432] D=buffer_pmp[411]
+ CK=CTS_56 RB=FE_OFN760_i_reset_n_i
Xbuffer_pmp_reg[453] QDFFRBN $PINS Q=buffer_pmp[453] D=buffer_pmp[432]
+ CK=CTS_56 RB=FE_OFN629_i_reset_n_i
Xbuffer_pmp_reg[474] QDFFRBN $PINS Q=buffer_pmp[474] D=buffer_pmp[453]
+ CK=CTS_56 RB=FE_OFN629_i_reset_n_i
Xbuffer_pmp_reg[495] QDFFRBN $PINS Q=buffer_pmp[495] D=buffer_pmp[474]
+ CK=CTS_56 RB=FE_OFN521_i_reset_n_i
Xbuffer_pmp_reg[516] QDFFRBN $PINS Q=buffer_pmp[516] D=buffer_pmp[495]
+ CK=CTS_56 RB=FE_OFN521_i_reset_n_i
Xbuffer_pmp_reg[537] QDFFRBN $PINS Q=buffer_pmp[537] D=buffer_pmp[516]
+ CK=CTS_56 RB=FE_OFN521_i_reset_n_i
Xbuffer_pmp_reg[558] QDFFRBN $PINS Q=buffer_pmp[558] D=buffer_pmp[537]
+ CK=CTS_56 RB=FE_OFN520_i_reset_n_i
Xbuffer_pmp_reg[579] QDFFRBN $PINS Q=buffer_pmp[579] D=buffer_pmp[558]
+ CK=CTS_53 RB=FE_OFN1116_i_reset_n_i
Xbuffer_pmp_reg[600] QDFFRBN $PINS Q=buffer_pmp[600] D=buffer_pmp[579]
+ CK=CTS_53 RB=FE_OFN1117_i_reset_n_i
Xbuffer_pmp_reg[621] QDFFRBN $PINS Q=buffer_pmp[621] D=buffer_pmp[600]
+ CK=CTS_53 RB=FE_OFN1083_i_reset_n_i
Xbuffer_pmp_reg[642] QDFFRBN $PINS Q=buffer_pmp[642] D=buffer_pmp[621]
+ CK=CTS_53 RB=FE_OFN1081_i_reset_n_i
Xbuffer_pmp_reg[663] QDFFRBN $PINS Q=buffer_pmp[663] D=buffer_pmp[642]
+ CK=CTS_53 RB=FE_OFN1044_i_reset_n_i
Xbuffer_pmp_reg[684] QDFFRBN $PINS Q=buffer_pmp[684] D=buffer_pmp[663]
+ CK=CTS_53 RB=FE_OFN1081_i_reset_n_i
Xbuffer_pmp_reg[705] QDFFRBN $PINS Q=buffer_pmp[705] D=buffer_pmp[684]
+ CK=CTS_53 RB=FE_OFN625_i_reset_n_i
Xbuffer_pmp_reg[726] QDFFRBN $PINS Q=buffer_pmp[726] D=buffer_pmp[705]
+ CK=CTS_53 RB=FE_OFN625_i_reset_n_i
Xbuffer_pmp_reg[747] QDFFRBN $PINS Q=buffer_pmp[747] D=buffer_pmp[726]
+ CK=CTS_53 RB=FE_OFN518_i_reset_n_i
Xbuffer_pmp_reg[768] QDFFRBN $PINS Q=buffer_pmp[768] D=buffer_pmp[747]
+ CK=CTS_53 RB=FE_OFN518_i_reset_n_i
Xbuffer_pmp_reg[789] QDFFRBN $PINS Q=buffer_pmp[789] D=buffer_pmp[768]
+ CK=CTS_55 RB=FE_OFN518_i_reset_n_i
Xbuffer_pmp_reg[810] QDFFRBN $PINS Q=buffer_pmp[810] D=buffer_pmp[789]
+ CK=CTS_55 RB=FE_OFN432_i_reset_n_i
Xbuffer_pmp_reg[831] QDFFRBN $PINS Q=buffer_pmp[831] D=buffer_pmp[810]
+ CK=CTS_55 RB=FE_OFN432_i_reset_n_i
Xbuffer_pmp_reg[852] QDFFRBN $PINS Q=buffer_pmp[852] D=buffer_pmp[831]
+ CK=CTS_55 RB=FE_OFN432_i_reset_n_i
Xbuffer_pmp_reg[873] QDFFRBN $PINS Q=buffer_pmp[873] D=buffer_pmp[852]
+ CK=CTS_55 RB=FE_OFN518_i_reset_n_i
Xbuffer_pmp_reg[894] QDFFRBN $PINS Q=buffer_pmp[894] D=buffer_pmp[873]
+ CK=CTS_53 RB=FE_OFN518_i_reset_n_i
Xbuffer_pmp_reg[915] QDFFRBN $PINS Q=buffer_pmp[915] D=buffer_pmp[894]
+ CK=CTS_53 RB=FE_OFN625_i_reset_n_i
Xbuffer_pmp_reg[936] QDFFRBN $PINS Q=buffer_pmp[936] D=buffer_pmp[915]
+ CK=CTS_53 RB=FE_OFN1081_i_reset_n_i
Xbuffer_pmp_reg[957] QDFFRBN $PINS Q=buffer_pmp[957] D=buffer_pmp[936]
+ CK=CTS_53 RB=FE_OFN1081_i_reset_n_i
Xbuffer_pmp_reg[978] QDFFRBN $PINS Q=buffer_pmp[978] D=buffer_pmp[957]
+ CK=CTS_53 RB=FE_OFN1081_i_reset_n_i
Xbuffer_pmp_reg[999] QDFFRBN $PINS Q=buffer_pmp[999] D=buffer_pmp[978]
+ CK=CTS_53 RB=FE_OFN1081_i_reset_n_i
Xbuffer_pmp_reg[1020] QDFFRBN $PINS Q=buffer_pmp[1020] D=buffer_pmp[999]
+ CK=CTS_53 RB=FE_OFN1117_i_reset_n_i
Xbuffer_pmp_reg[1041] QDFFRBN $PINS Q=buffer_pmp[1041] D=buffer_pmp[1020]
+ CK=CTS_53 RB=FE_OFN1117_i_reset_n_i
Xbuffer_pmp_reg[1062] QDFFRBN $PINS Q=buffer_pmp[1062] D=buffer_pmp[1041]
+ CK=CTS_53 RB=FE_OFN1116_i_reset_n_i
Xbuffer_pmp_reg[1083] QDFFRBN $PINS Q=buffer_pmp[1083] D=buffer_pmp[1062]
+ CK=CTS_56 RB=FE_OFN520_i_reset_n_i
Xbuffer_pmp_reg[1104] QDFFRBN $PINS Q=buffer_pmp[1104] D=buffer_pmp[1083]
+ CK=CTS_56 RB=FE_OFN520_i_reset_n_i
Xpmp_1_r_reg[12] QDFFRBN $PINS Q=pmp_1_r[12] D=pmp_1_w[12] CK=CTS_46
+ RB=FE_OFN1026_i_reset_n_i
Xbuffer_pmp_reg[13] QDFFRBN $PINS Q=buffer_pmp[13] D=pmp[13] CK=CTS_44
+ RB=FE_OFN755_i_reset_n_i
Xbuffer_pmp_reg[34] QDFFRBN $PINS Q=buffer_pmp[34] D=buffer_pmp[13] CK=CTS_46
+ RB=FE_OFN965_i_reset_n_i
Xbuffer_pmp_reg[55] QDFFRBN $PINS Q=buffer_pmp[55] D=buffer_pmp[34] CK=CTS_46
+ RB=FE_OFN957_i_reset_n_i
Xbuffer_pmp_reg[76] QDFFRBN $PINS Q=buffer_pmp[76] D=buffer_pmp[55] CK=CTS_46
+ RB=FE_OFN1028_i_reset_n_i
Xbuffer_pmp_reg[97] QDFFRBN $PINS Q=buffer_pmp[97] D=buffer_pmp[76] CK=CTS_46
+ RB=FE_OFN1027_i_reset_n_i
Xbuffer_pmp_reg[118] QDFFRBN $PINS Q=buffer_pmp[118] D=buffer_pmp[97] CK=CTS_46
+ RB=FE_OFN1027_i_reset_n_i
Xbuffer_pmp_reg[139] QDFFRBN $PINS Q=buffer_pmp[139] D=buffer_pmp[118]
+ CK=CTS_46 RB=FE_OFN1027_i_reset_n_i
Xbuffer_pmp_reg[160] QDFFRBN $PINS Q=buffer_pmp[160] D=buffer_pmp[139]
+ CK=CTS_46 RB=FE_OFN749_i_reset_n_i
Xbuffer_pmp_reg[181] QDFFRBN $PINS Q=buffer_pmp[181] D=buffer_pmp[160]
+ CK=CTS_46 RB=FE_OFN618_i_reset_n_i
Xbuffer_pmp_reg[202] QDFFRBN $PINS Q=buffer_pmp[202] D=buffer_pmp[181]
+ CK=CTS_46 RB=FE_OFN956_i_reset_n_i
Xbuffer_pmp_reg[223] QDFFRBN $PINS Q=buffer_pmp[223] D=buffer_pmp[202]
+ CK=CTS_46 RB=FE_OFN1026_i_reset_n_i
Xbuffer_pmp_reg[244] QDFFRBN $PINS Q=buffer_pmp[244] D=buffer_pmp[223]
+ CK=CTS_46 RB=FE_OFN433_i_reset_n_i
Xbuffer_pmp_reg[265] QDFFRBN $PINS Q=buffer_pmp[265] D=buffer_pmp[244]
+ CK=CTS_46 RB=FE_OFN433_i_reset_n_i
Xbuffer_pmp_reg[286] QDFFRBN $PINS Q=buffer_pmp[286] D=buffer_pmp[265]
+ CK=CTS_56 RB=FE_OFN1051_i_reset_n_i
Xbuffer_pmp_reg[307] QDFFRBN $PINS Q=buffer_pmp[307] D=buffer_pmp[286]
+ CK=CTS_56 RB=FE_OFN1051_i_reset_n_i
Xbuffer_pmp_reg[328] QDFFRBN $PINS Q=buffer_pmp[328] D=buffer_pmp[307]
+ CK=CTS_56 RB=FE_OFN1051_i_reset_n_i
Xbuffer_pmp_reg[349] QDFFRBN $PINS Q=buffer_pmp[349] D=buffer_pmp[328]
+ CK=CTS_56 RB=FE_OFN1050_i_reset_n_i
Xbuffer_pmp_reg[370] QDFFRBN $PINS Q=buffer_pmp[370] D=buffer_pmp[349]
+ CK=CTS_56 RB=FE_OFN1050_i_reset_n_i
Xbuffer_pmp_reg[391] QDFFRBN $PINS Q=buffer_pmp[391] D=buffer_pmp[370]
+ CK=CTS_56 RB=FE_OFN1050_i_reset_n_i
Xbuffer_pmp_reg[412] QDFFRBN $PINS Q=buffer_pmp[412] D=buffer_pmp[391]
+ CK=CTS_56 RB=FE_OFN974_i_reset_n_i
Xbuffer_pmp_reg[433] QDFFRBN $PINS Q=buffer_pmp[433] D=buffer_pmp[412]
+ CK=CTS_56 RB=FE_OFN974_i_reset_n_i
Xbuffer_pmp_reg[454] QDFFRBN $PINS Q=buffer_pmp[454] D=buffer_pmp[433]
+ CK=CTS_56 RB=FE_OFN890_i_reset_n_i
Xbuffer_pmp_reg[475] QDFFRBN $PINS Q=buffer_pmp[475] D=buffer_pmp[454]
+ CK=CTS_56 RB=FE_OFN890_i_reset_n_i
Xbuffer_pmp_reg[496] QDFFRBN $PINS Q=buffer_pmp[496] D=buffer_pmp[475]
+ CK=CTS_56 RB=FE_OFN890_i_reset_n_i
Xbuffer_pmp_reg[517] QDFFRBN $PINS Q=buffer_pmp[517] D=buffer_pmp[496]
+ CK=CTS_56 RB=FE_OFN760_i_reset_n_i
Xbuffer_pmp_reg[538] QDFFRBN $PINS Q=buffer_pmp[538] D=buffer_pmp[517]
+ CK=CTS_56 RB=FE_OFN629_i_reset_n_i
Xbuffer_pmp_reg[559] QDFFRBN $PINS Q=buffer_pmp[559] D=buffer_pmp[538]
+ CK=CTS_56 RB=FE_OFN759_i_reset_n_i
Xbuffer_pmp_reg[580] QDFFRBN $PINS Q=buffer_pmp[580] D=buffer_pmp[559]
+ CK=CTS_53 RB=FE_OFN759_i_reset_n_i
Xbuffer_pmp_reg[601] QDFFRBN $PINS Q=buffer_pmp[601] D=buffer_pmp[580]
+ CK=CTS_53 RB=FE_OFN759_i_reset_n_i
Xbuffer_pmp_reg[622] QDFFRBN $PINS Q=buffer_pmp[622] D=buffer_pmp[601]
+ CK=CTS_53 RB=FE_OFN1082_i_reset_n_i
Xbuffer_pmp_reg[643] QDFFRBN $PINS Q=buffer_pmp[643] D=buffer_pmp[622]
+ CK=CTS_53 RB=FE_OFN1082_i_reset_n_i
Xbuffer_pmp_reg[664] QDFFRBN $PINS Q=buffer_pmp[664] D=buffer_pmp[643]
+ CK=CTS_53 RB=FE_OFN1082_i_reset_n_i
Xbuffer_pmp_reg[685] QDFFRBN $PINS Q=buffer_pmp[685] D=buffer_pmp[664]
+ CK=CTS_53 RB=FE_OFN1082_i_reset_n_i
Xbuffer_pmp_reg[706] QDFFRBN $PINS Q=buffer_pmp[706] D=buffer_pmp[685]
+ CK=CTS_53 RB=FE_OFN1080_i_reset_n_i
Xbuffer_pmp_reg[727] QDFFRBN $PINS Q=buffer_pmp[727] D=buffer_pmp[706]
+ CK=CTS_53 RB=FE_OFN1080_i_reset_n_i
Xbuffer_pmp_reg[748] QDFFRBN $PINS Q=buffer_pmp[748] D=buffer_pmp[727]
+ CK=CTS_53 RB=FE_OFN1080_i_reset_n_i
Xbuffer_pmp_reg[769] QDFFRBN $PINS Q=buffer_pmp[769] D=buffer_pmp[748]
+ CK=CTS_53 RB=FE_OFN1080_i_reset_n_i
Xbuffer_pmp_reg[790] QDFFRBN $PINS Q=buffer_pmp[790] D=buffer_pmp[769]
+ CK=CTS_53 RB=FE_OFN1080_i_reset_n_i
Xbuffer_pmp_reg[811] QDFFRBN $PINS Q=buffer_pmp[811] D=buffer_pmp[790]
+ CK=CTS_53 RB=FE_OFN970_i_reset_n_i
Xbuffer_pmp_reg[832] QDFFRBN $PINS Q=buffer_pmp[832] D=buffer_pmp[811]
+ CK=CTS_53 RB=FE_OFN970_i_reset_n_i
Xbuffer_pmp_reg[853] QDFFRBN $PINS Q=buffer_pmp[853] D=buffer_pmp[832]
+ CK=CTS_53 RB=FE_OFN885_i_reset_n_i
Xbuffer_pmp_reg[874] QDFFRBN $PINS Q=buffer_pmp[874] D=buffer_pmp[853]
+ CK=CTS_53 RB=FE_OFN885_i_reset_n_i
Xbuffer_pmp_reg[895] QDFFRBN $PINS Q=buffer_pmp[895] D=buffer_pmp[874]
+ CK=CTS_53 RB=FE_OFN971_i_reset_n_i
Xbuffer_pmp_reg[916] QDFFRBN $PINS Q=buffer_pmp[916] D=buffer_pmp[895]
+ CK=CTS_53 RB=FE_OFN1043_i_reset_n_i
Xbuffer_pmp_reg[937] QDFFRBN $PINS Q=buffer_pmp[937] D=buffer_pmp[916]
+ CK=CTS_53 RB=FE_OFN971_i_reset_n_i
Xbuffer_pmp_reg[958] QDFFRBN $PINS Q=buffer_pmp[958] D=buffer_pmp[937]
+ CK=CTS_53 RB=FE_OFN1045_i_reset_n_i
Xbuffer_pmp_reg[979] QDFFRBN $PINS Q=buffer_pmp[979] D=buffer_pmp[958]
+ CK=CTS_53 RB=FE_OFN1045_i_reset_n_i
Xbuffer_pmp_reg[1000] QDFFRBN $PINS Q=buffer_pmp[1000] D=buffer_pmp[979]
+ CK=CTS_53 RB=FE_OFN1084_i_reset_n_i
Xbuffer_pmp_reg[1021] QDFFRBN $PINS Q=buffer_pmp[1021] D=buffer_pmp[1000]
+ CK=CTS_53 RB=FE_OFN1084_i_reset_n_i
Xbuffer_pmp_reg[1042] QDFFRBN $PINS Q=buffer_pmp[1042] D=buffer_pmp[1021]
+ CK=CTS_56 RB=FE_OFN759_i_reset_n_i
Xbuffer_pmp_reg[1063] QDFFRBN $PINS Q=buffer_pmp[1063] D=buffer_pmp[1042]
+ CK=CTS_56 RB=FE_OFN434_i_reset_n_i
Xbuffer_pmp_reg[1084] QDFFRBN $PINS Q=buffer_pmp[1084] D=buffer_pmp[1063]
+ CK=CTS_56 RB=FE_OFN628_i_reset_n_i
Xbuffer_pmp_reg[1105] QDFFRBN $PINS Q=buffer_pmp[1105] D=buffer_pmp[1084]
+ CK=CTS_56 RB=FE_OFN628_i_reset_n_i
Xpmp_1_r_reg[13] QDFFRBN $PINS Q=pmp_1_r[13] D=pmp_1_w[13] CK=CTS_56
+ RB=FE_OFN1026_i_reset_n_i
Xbuffer_pmp_reg[14] QDFFRBN $PINS Q=buffer_pmp[14] D=pmp[14] CK=CTS_44
+ RB=FE_OFN1075_i_reset_n_i
Xbuffer_pmp_reg[35] QDFFRBN $PINS Q=buffer_pmp[35] D=buffer_pmp[14] CK=CTS_46
+ RB=FE_OCPN9776_FE_OFN514_i_reset_n_i
Xbuffer_pmp_reg[56] QDFFRBN $PINS Q=buffer_pmp[56] D=buffer_pmp[35] CK=CTS_46
+ RB=FE_OCPN9776_FE_OFN514_i_reset_n_i
Xbuffer_pmp_reg[77] QDFFRBN $PINS Q=buffer_pmp[77] D=buffer_pmp[56] CK=CTS_46
+ RB=FE_OFN965_i_reset_n_i
Xbuffer_pmp_reg[98] QDFFRBN $PINS Q=buffer_pmp[98] D=buffer_pmp[77] CK=CTS_46
+ RB=FE_OFN965_i_reset_n_i
Xbuffer_pmp_reg[119] QDFFRBN $PINS Q=buffer_pmp[119] D=buffer_pmp[98] CK=CTS_44
+ RB=FE_OFN883_i_reset_n_i
Xbuffer_pmp_reg[140] QDFFRBN $PINS Q=buffer_pmp[140] D=buffer_pmp[119]
+ CK=CTS_44 RB=FE_OFN966_i_reset_n_i
Xbuffer_pmp_reg[161] QDFFRBN $PINS Q=buffer_pmp[161] D=buffer_pmp[140]
+ CK=CTS_44 RB=FE_OFN966_i_reset_n_i
Xbuffer_pmp_reg[182] QDFFRBN $PINS Q=buffer_pmp[182] D=buffer_pmp[161]
+ CK=CTS_44 RB=FE_OFN619_i_reset_n_i
Xbuffer_pmp_reg[203] QDFFRBN $PINS Q=buffer_pmp[203] D=buffer_pmp[182]
+ CK=CTS_46 RB=FE_OFN619_i_reset_n_i
Xbuffer_pmp_reg[224] QDFFRBN $PINS Q=buffer_pmp[224] D=buffer_pmp[203]
+ CK=CTS_44 RB=FE_OFN1119_i_reset_n_i
Xbuffer_pmp_reg[245] QDFFRBN $PINS Q=buffer_pmp[245] D=buffer_pmp[224]
+ CK=CTS_43 RB=FE_OFN1119_i_reset_n_i
Xbuffer_pmp_reg[266] QDFFRBN $PINS Q=buffer_pmp[266] D=buffer_pmp[245]
+ CK=CTS_44 RB=FE_OFN1106_i_reset_n_i
Xbuffer_pmp_reg[287] QDFFRBN $PINS Q=buffer_pmp[287] D=buffer_pmp[266]
+ CK=CTS_43 RB=FE_OFN1086_i_reset_n_i
Xbuffer_pmp_reg[308] QDFFRBN $PINS Q=buffer_pmp[308] D=buffer_pmp[287]
+ CK=CTS_43 RB=FE_OFN1106_i_reset_n_i
Xbuffer_pmp_reg[329] QDFFRBN $PINS Q=buffer_pmp[329] D=buffer_pmp[308]
+ CK=CTS_43 RB=FE_OFN1086_i_reset_n_i
Xbuffer_pmp_reg[350] QDFFRBN $PINS Q=buffer_pmp[350] D=buffer_pmp[329]
+ CK=CTS_47 RB=FE_OFN1086_i_reset_n_i
Xbuffer_pmp_reg[371] QDFFRBN $PINS Q=buffer_pmp[371] D=buffer_pmp[350]
+ CK=CTS_47 RB=FE_OFN1086_i_reset_n_i
Xbuffer_pmp_reg[392] QDFFRBN $PINS Q=buffer_pmp[392] D=buffer_pmp[371]
+ CK=CTS_47 RB=FE_OFN1106_i_reset_n_i
Xbuffer_pmp_reg[413] QDFFRBN $PINS Q=buffer_pmp[413] D=buffer_pmp[392]
+ CK=CTS_47 RB=FE_OFN1106_i_reset_n_i
Xbuffer_pmp_reg[434] QDFFRBN $PINS Q=buffer_pmp[434] D=buffer_pmp[413]
+ CK=CTS_47 RB=FE_OFN1119_i_reset_n_i
Xbuffer_pmp_reg[455] QDFFRBN $PINS Q=buffer_pmp[455] D=buffer_pmp[434]
+ CK=CTS_47 RB=FE_OFN1119_i_reset_n_i
Xbuffer_pmp_reg[476] QDFFRBN $PINS Q=buffer_pmp[476] D=buffer_pmp[455]
+ CK=CTS_47 RB=FE_OFN1119_i_reset_n_i
Xbuffer_pmp_reg[497] QDFFRBN $PINS Q=buffer_pmp[497] D=buffer_pmp[476]
+ CK=CTS_46 RB=FE_OFN757_i_reset_n_i
Xbuffer_pmp_reg[518] QDFFRBN $PINS Q=buffer_pmp[518] D=buffer_pmp[497]
+ CK=CTS_46 RB=FE_OFN757_i_reset_n_i
Xbuffer_pmp_reg[539] QDFFRBN $PINS Q=buffer_pmp[539] D=buffer_pmp[518]
+ CK=CTS_46 RB=FE_OFN757_i_reset_n_i
Xbuffer_pmp_reg[560] QDFFRBN $PINS Q=buffer_pmp[560] D=buffer_pmp[539]
+ CK=CTS_46 RB=FE_OFN757_i_reset_n_i
Xbuffer_pmp_reg[581] QDFFRBN $PINS Q=buffer_pmp[581] D=buffer_pmp[560]
+ CK=CTS_47 RB=FE_OFN757_i_reset_n_i
Xbuffer_pmp_reg[602] QDFFRBN $PINS Q=buffer_pmp[602] D=buffer_pmp[581]
+ CK=CTS_46 RB=FE_OFN626_i_reset_n_i
Xbuffer_pmp_reg[623] QDFFRBN $PINS Q=buffer_pmp[623] D=buffer_pmp[602]
+ CK=CTS_47 RB=FE_OFN627_i_reset_n_i
Xbuffer_pmp_reg[644] QDFFRBN $PINS Q=buffer_pmp[644] D=buffer_pmp[623]
+ CK=CTS_47 RB=FE_OFN627_i_reset_n_i
Xbuffer_pmp_reg[665] QDFFRBN $PINS Q=buffer_pmp[665] D=buffer_pmp[644]
+ CK=CTS_47 RB=FE_OFN888_i_reset_n_i
Xbuffer_pmp_reg[686] QDFFRBN $PINS Q=buffer_pmp[686] D=buffer_pmp[665]
+ CK=CTS_47 RB=FE_OFN888_i_reset_n_i
Xbuffer_pmp_reg[707] QDFFRBN $PINS Q=buffer_pmp[707] D=buffer_pmp[686]
+ CK=CTS_47 RB=FE_OFN972_i_reset_n_i
Xbuffer_pmp_reg[728] QDFFRBN $PINS Q=buffer_pmp[728] D=buffer_pmp[707]
+ CK=CTS_47 RB=FE_OFN1105_i_reset_n_i
Xbuffer_pmp_reg[749] QDFFRBN $PINS Q=buffer_pmp[749] D=buffer_pmp[728]
+ CK=CTS_47 RB=FE_OFN1105_i_reset_n_i
Xbuffer_pmp_reg[770] QDFFRBN $PINS Q=buffer_pmp[770] D=buffer_pmp[749]
+ CK=CTS_47 RB=FE_OFN1085_i_reset_n_i
Xbuffer_pmp_reg[791] QDFFRBN $PINS Q=buffer_pmp[791] D=buffer_pmp[770]
+ CK=CTS_47 RB=FE_OFN1085_i_reset_n_i
Xbuffer_pmp_reg[812] QDFFRBN $PINS Q=buffer_pmp[812] D=buffer_pmp[791]
+ CK=CTS_47 RB=FE_OFN1105_i_reset_n_i
Xbuffer_pmp_reg[833] QDFFRBN $PINS Q=buffer_pmp[833] D=buffer_pmp[812]
+ CK=CTS_47 RB=FE_OFN1118_i_reset_n_i
Xbuffer_pmp_reg[854] QDFFRBN $PINS Q=buffer_pmp[854] D=buffer_pmp[833]
+ CK=CTS_47 RB=FE_OFN1118_i_reset_n_i
Xbuffer_pmp_reg[875] QDFFRBN $PINS Q=buffer_pmp[875] D=buffer_pmp[854]
+ CK=CTS_47 RB=FE_OFN1118_i_reset_n_i
Xbuffer_pmp_reg[896] QDFFRBN $PINS Q=buffer_pmp[896] D=buffer_pmp[875]
+ CK=CTS_47 RB=FE_OFN972_i_reset_n_i
Xbuffer_pmp_reg[917] QDFFRBN $PINS Q=buffer_pmp[917] D=buffer_pmp[896]
+ CK=CTS_47 RB=FE_OFN887_i_reset_n_i
Xbuffer_pmp_reg[938] QDFFRBN $PINS Q=buffer_pmp[938] D=buffer_pmp[917]
+ CK=CTS_47 RB=FE_OFN972_i_reset_n_i
Xbuffer_pmp_reg[959] QDFFRBN $PINS Q=buffer_pmp[959] D=buffer_pmp[938]
+ CK=CTS_47 RB=FE_OFN758_i_reset_n_i
Xbuffer_pmp_reg[980] QDFFRBN $PINS Q=buffer_pmp[980] D=buffer_pmp[959]
+ CK=CTS_47 RB=FE_OFN627_i_reset_n_i
Xbuffer_pmp_reg[1001] QDFFRBN $PINS Q=buffer_pmp[1001] D=buffer_pmp[980]
+ CK=CTS_47 RB=FE_OFN627_i_reset_n_i
Xbuffer_pmp_reg[1022] QDFFRBN $PINS Q=buffer_pmp[1022] D=buffer_pmp[1001]
+ CK=CTS_46 RB=FE_OFN519_i_reset_n_i
Xbuffer_pmp_reg[1043] QDFFRBN $PINS Q=buffer_pmp[1043] D=buffer_pmp[1022]
+ CK=CTS_46 RB=FE_OFN519_i_reset_n_i
Xbuffer_pmp_reg[1064] QDFFRBN $PINS Q=buffer_pmp[1064] D=buffer_pmp[1043]
+ CK=CTS_46 RB=FE_OFN956_i_reset_n_i
Xbuffer_pmp_reg[1085] QDFFRBN $PINS Q=buffer_pmp[1085] D=buffer_pmp[1064]
+ CK=CTS_46 RB=FE_OFN875_i_reset_n_i
Xbuffer_pmp_reg[1106] QDFFRBN $PINS Q=buffer_pmp[1106] D=buffer_pmp[1085]
+ CK=CTS_46 RB=FE_OFN875_i_reset_n_i
Xpmp_1_r_reg[14] QDFFRBN $PINS Q=pmp_1_r[14] D=pmp_1_w[14] CK=CTS_46
+ RB=FE_OFN876_i_reset_n_i
Xbuffer_pmp_reg[15] QDFFRBN $PINS Q=buffer_pmp[15] D=pmp[15] CK=CTS_44
+ RB=FE_OFN1078_i_reset_n_i
Xbuffer_pmp_reg[36] QDFFRBN $PINS Q=buffer_pmp[36] D=buffer_pmp[15] CK=CTS_64
+ RB=FE_OFN1079_i_reset_n_i
Xbuffer_pmp_reg[57] QDFFRBN $PINS Q=buffer_pmp[57] D=buffer_pmp[36] CK=CTS_64
+ RB=FE_OFN1079_i_reset_n_i
Xbuffer_pmp_reg[78] QDFFRBN $PINS Q=buffer_pmp[78] D=buffer_pmp[57] CK=CTS_64
+ RB=FE_OFN620_i_reset_n_i
Xbuffer_pmp_reg[99] QDFFRBN $PINS Q=buffer_pmp[99] D=buffer_pmp[78] CK=CTS_64
+ RB=FE_OFN620_i_reset_n_i
Xbuffer_pmp_reg[120] QDFFRBN $PINS Q=buffer_pmp[120] D=buffer_pmp[99] CK=CTS_64
+ RB=FE_OFN620_i_reset_n_i
Xbuffer_pmp_reg[141] QDFFRBN $PINS Q=buffer_pmp[141] D=buffer_pmp[120]
+ CK=CTS_64 RB=FE_OFN752_i_reset_n_i
Xbuffer_pmp_reg[162] QDFFRBN $PINS Q=buffer_pmp[162] D=buffer_pmp[141]
+ CK=CTS_64 RB=FE_OFN752_i_reset_n_i
Xbuffer_pmp_reg[183] QDFFRBN $PINS Q=buffer_pmp[183] D=buffer_pmp[162]
+ CK=CTS_62 RB=FE_OFN880_i_reset_n_i
Xbuffer_pmp_reg[204] QDFFRBN $PINS Q=buffer_pmp[204] D=buffer_pmp[183]
+ CK=CTS_62 RB=FE_OFN880_i_reset_n_i
Xbuffer_pmp_reg[225] QDFFRBN $PINS Q=buffer_pmp[225] D=buffer_pmp[204]
+ CK=CTS_62 RB=FE_OFN880_i_reset_n_i
Xbuffer_pmp_reg[246] QDFFRBN $PINS Q=buffer_pmp[246] D=buffer_pmp[225]
+ CK=CTS_62 RB=FE_OFN881_i_reset_n_i
Xbuffer_pmp_reg[267] QDFFRBN $PINS Q=buffer_pmp[267] D=buffer_pmp[246]
+ CK=CTS_64 RB=FE_OFN881_i_reset_n_i
Xbuffer_pmp_reg[288] QDFFRBN $PINS Q=buffer_pmp[288] D=buffer_pmp[267]
+ CK=CTS_62 RB=FE_OFN881_i_reset_n_i
Xbuffer_pmp_reg[309] QDFFRBN $PINS Q=buffer_pmp[309] D=buffer_pmp[288]
+ CK=CTS_62 RB=FE_OFN1114_i_reset_n_i
Xbuffer_pmp_reg[330] QDFFRBN $PINS Q=buffer_pmp[330] D=buffer_pmp[309]
+ CK=CTS_62 RB=FE_OFN1114_i_reset_n_i
Xbuffer_pmp_reg[351] QDFFRBN $PINS Q=buffer_pmp[351] D=buffer_pmp[330]
+ CK=CTS_62 RB=FE_OFN1033_i_reset_n_i
Xbuffer_pmp_reg[372] QDFFRBN $PINS Q=buffer_pmp[372] D=buffer_pmp[351]
+ CK=CTS_62 RB=FE_OFN1033_i_reset_n_i
Xbuffer_pmp_reg[393] QDFFRBN $PINS Q=buffer_pmp[393] D=buffer_pmp[372]
+ CK=CTS_62 RB=FE_OFN1035_i_reset_n_i
Xbuffer_pmp_reg[414] QDFFRBN $PINS Q=buffer_pmp[414] D=buffer_pmp[393]
+ CK=CTS_62 RB=FE_OFN1101_i_reset_n_i
Xbuffer_pmp_reg[435] QDFFRBN $PINS Q=buffer_pmp[435] D=buffer_pmp[414]
+ CK=CTS_62 RB=FE_OFN1101_i_reset_n_i
Xbuffer_pmp_reg[456] QDFFRBN $PINS Q=buffer_pmp[456] D=buffer_pmp[435]
+ CK=CTS_62 RB=FE_OFN1101_i_reset_n_i
Xbuffer_pmp_reg[477] QDFFRBN $PINS Q=buffer_pmp[477] D=buffer_pmp[456]
+ CK=CTS_62 RB=FE_OFN1035_i_reset_n_i
Xbuffer_pmp_reg[498] QDFFRBN $PINS Q=buffer_pmp[498] D=buffer_pmp[477]
+ CK=CTS_62 RB=FE_OFN1035_i_reset_n_i
Xbuffer_pmp_reg[519] QDFFRBN $PINS Q=buffer_pmp[519] D=buffer_pmp[498]
+ CK=CTS_62 RB=FE_OFN1033_i_reset_n_i
Xbuffer_pmp_reg[540] QDFFRBN $PINS Q=buffer_pmp[540] D=buffer_pmp[519]
+ CK=CTS_62 RB=FE_OFN1033_i_reset_n_i
Xbuffer_pmp_reg[561] QDFFRBN $PINS Q=buffer_pmp[561] D=buffer_pmp[540]
+ CK=CTS_62 RB=FE_OFN1071_i_reset_n_i
Xbuffer_pmp_reg[582] QDFFRBN $PINS Q=buffer_pmp[582] D=buffer_pmp[561]
+ CK=CTS_62 RB=FE_OFN1100_i_reset_n_i
Xbuffer_pmp_reg[603] QDFFRBN $PINS Q=buffer_pmp[603] D=buffer_pmp[582]
+ CK=CTS_43 RB=FE_OFN1111_i_reset_n_i
Xbuffer_pmp_reg[624] QDFFRBN $PINS Q=buffer_pmp[624] D=buffer_pmp[603]
+ CK=CTS_62 RB=FE_OFN1111_i_reset_n_i
Xbuffer_pmp_reg[645] QDFFRBN $PINS Q=buffer_pmp[645] D=buffer_pmp[624]
+ CK=CTS_62 RB=FE_OFN1111_i_reset_n_i
Xbuffer_pmp_reg[666] QDFFRBN $PINS Q=buffer_pmp[666] D=buffer_pmp[645]
+ CK=CTS_62 RB=FE_OFN1111_i_reset_n_i
Xbuffer_pmp_reg[687] QDFFRBN $PINS Q=buffer_pmp[687] D=buffer_pmp[666]
+ CK=CTS_62 RB=FE_OFN1112_i_reset_n_i
Xbuffer_pmp_reg[708] QDFFRBN $PINS Q=buffer_pmp[708] D=buffer_pmp[687]
+ CK=CTS_62 RB=FE_OFN1112_i_reset_n_i
Xbuffer_pmp_reg[729] QDFFRBN $PINS Q=buffer_pmp[729] D=buffer_pmp[708]
+ CK=CTS_62 RB=FE_OFN1115_i_reset_n_i
Xbuffer_pmp_reg[750] QDFFRBN $PINS Q=buffer_pmp[750] D=buffer_pmp[729]
+ CK=CTS_62 RB=FE_OFN1102_i_reset_n_i
Xbuffer_pmp_reg[771] QDFFRBN $PINS Q=buffer_pmp[771] D=buffer_pmp[750]
+ CK=CTS_62 RB=FE_OFN1102_i_reset_n_i
Xbuffer_pmp_reg[792] QDFFRBN $PINS Q=buffer_pmp[792] D=buffer_pmp[771]
+ CK=CTS_62 RB=FE_OFN1102_i_reset_n_i
Xbuffer_pmp_reg[813] QDFFRBN $PINS Q=buffer_pmp[813] D=buffer_pmp[792]
+ CK=CTS_62 RB=FE_OFN1115_i_reset_n_i
Xbuffer_pmp_reg[834] QDFFRBN $PINS Q=buffer_pmp[834] D=buffer_pmp[813]
+ CK=CTS_62 RB=FE_OFN1102_i_reset_n_i
Xbuffer_pmp_reg[855] QDFFRBN $PINS Q=buffer_pmp[855] D=buffer_pmp[834]
+ CK=CTS_62 RB=FE_OFN1102_i_reset_n_i
Xbuffer_pmp_reg[876] QDFFRBN $PINS Q=buffer_pmp[876] D=buffer_pmp[855]
+ CK=CTS_62 RB=FE_OFN1115_i_reset_n_i
Xbuffer_pmp_reg[897] QDFFRBN $PINS Q=buffer_pmp[897] D=buffer_pmp[876]
+ CK=CTS_62 RB=FE_OFN1115_i_reset_n_i
Xbuffer_pmp_reg[918] QDFFRBN $PINS Q=buffer_pmp[918] D=buffer_pmp[897]
+ CK=CTS_62 RB=FE_OFN1113_i_reset_n_i
Xbuffer_pmp_reg[939] QDFFRBN $PINS Q=buffer_pmp[939] D=buffer_pmp[918]
+ CK=CTS_62 RB=FE_OFN1112_i_reset_n_i
Xbuffer_pmp_reg[960] QDFFRBN $PINS Q=buffer_pmp[960] D=buffer_pmp[939]
+ CK=CTS_62 RB=FE_OFN1112_i_reset_n_i
Xbuffer_pmp_reg[981] QDFFRBN $PINS Q=buffer_pmp[981] D=buffer_pmp[960]
+ CK=CTS_62 RB=FE_OFN1071_i_reset_n_i
Xbuffer_pmp_reg[1002] QDFFRBN $PINS Q=buffer_pmp[1002] D=buffer_pmp[981]
+ CK=CTS_62 RB=FE_OFN1071_i_reset_n_i
Xbuffer_pmp_reg[1023] QDFFRBN $PINS Q=buffer_pmp[1023] D=buffer_pmp[1002]
+ CK=CTS_62 RB=FE_OFN1071_i_reset_n_i
Xbuffer_pmp_reg[1044] QDFFRBN $PINS Q=buffer_pmp[1044] D=buffer_pmp[1023]
+ CK=CTS_62 RB=FE_OFN1035_i_reset_n_i
Xbuffer_pmp_reg[1065] QDFFRBN $PINS Q=buffer_pmp[1065] D=buffer_pmp[1044]
+ CK=CTS_62 RB=FE_OFN1035_i_reset_n_i
Xbuffer_pmp_reg[1086] QDFFRBN $PINS Q=buffer_pmp[1086] D=buffer_pmp[1065]
+ CK=CTS_62 RB=FE_OFN1033_i_reset_n_i
Xbuffer_pmp_reg[1107] QDFFRBN $PINS Q=buffer_pmp[1107] D=buffer_pmp[1086]
+ CK=CTS_62 RB=FE_OFN1032_i_reset_n_i
Xpmp_1_r_reg[15] QDFFRBN $PINS Q=pmp_1_r[15] D=pmp_1_w[15] CK=CTS_64
+ RB=FE_OFN620_i_reset_n_i
Xbuffer_pmp_reg[16] QDFFRBN $PINS Q=buffer_pmp[16] D=pmp[16] CK=CTS_69
+ RB=FE_OFN672_i_reset_n_i
Xbuffer_pmp_reg[37] QDFFRBN $PINS Q=buffer_pmp[37] D=buffer_pmp[16] CK=CTS_64
+ RB=FE_OFN671_i_reset_n_i
Xbuffer_pmp_reg[58] QDFFRBN $PINS Q=buffer_pmp[58] D=buffer_pmp[37] CK=CTS_61
+ RB=FE_OFN924_i_reset_n_i
Xbuffer_pmp_reg[79] QDFFRBN $PINS Q=buffer_pmp[79] D=buffer_pmp[58] CK=CTS_61
+ RB=FE_OFN924_i_reset_n_i
Xbuffer_pmp_reg[100] QDFFRBN $PINS Q=buffer_pmp[100] D=buffer_pmp[79] CK=CTS_61
+ RB=FE_OFN924_i_reset_n_i
Xbuffer_pmp_reg[121] QDFFRBN $PINS Q=buffer_pmp[121] D=buffer_pmp[100]
+ CK=CTS_61 RB=FE_OFN1058_i_reset_n_i
Xbuffer_pmp_reg[142] QDFFRBN $PINS Q=buffer_pmp[142] D=buffer_pmp[121]
+ CK=CTS_61 RB=FE_OFN1058_i_reset_n_i
Xbuffer_pmp_reg[163] QDFFRBN $PINS Q=buffer_pmp[163] D=buffer_pmp[142]
+ CK=CTS_61 RB=FE_OFN789_i_reset_n_i
Xbuffer_pmp_reg[184] QDFFRBN $PINS Q=buffer_pmp[184] D=buffer_pmp[163]
+ CK=CTS_61 RB=FE_OFN990_i_reset_n_i
Xbuffer_pmp_reg[205] QDFFRBN $PINS Q=buffer_pmp[205] D=buffer_pmp[184]
+ CK=CTS_61 RB=FE_OFN990_i_reset_n_i
Xbuffer_pmp_reg[226] QDFFRBN $PINS Q=buffer_pmp[226] D=buffer_pmp[205]
+ CK=CTS_61 RB=FE_OFN989_i_reset_n_i
Xbuffer_pmp_reg[247] QDFFRBN $PINS Q=buffer_pmp[247] D=buffer_pmp[226]
+ CK=CTS_61 RB=FE_OFN761_i_reset_n_i
Xbuffer_pmp_reg[268] QDFFRBN $PINS Q=buffer_pmp[268] D=buffer_pmp[247]
+ CK=CTS_61 RB=FE_OFN909_i_reset_n_i
Xbuffer_pmp_reg[289] QDFFRBN $PINS Q=buffer_pmp[289] D=buffer_pmp[268]
+ CK=CTS_61 RB=FE_OFN761_i_reset_n_i
Xbuffer_pmp_reg[310] QDFFRBN $PINS Q=buffer_pmp[310] D=buffer_pmp[289]
+ CK=CTS_61 RB=FE_OFN762_i_reset_n_i
Xbuffer_pmp_reg[331] QDFFRBN $PINS Q=buffer_pmp[331] D=buffer_pmp[310]
+ CK=CTS_65 RB=FE_OFN762_i_reset_n_i
Xbuffer_pmp_reg[352] QDFFRBN $PINS Q=buffer_pmp[352] D=buffer_pmp[331]
+ CK=CTS_58 RB=FE_OFN762_i_reset_n_i
Xbuffer_pmp_reg[373] QDFFRBN $PINS Q=buffer_pmp[373] D=buffer_pmp[352]
+ CK=CTS_58 RB=FE_OFN795_i_reset_n_i
Xbuffer_pmp_reg[394] QDFFRBN $PINS Q=buffer_pmp[394] D=buffer_pmp[373]
+ CK=CTS_58 RB=FE_OFN912_i_reset_n_i
Xbuffer_pmp_reg[415] QDFFRBN $PINS Q=buffer_pmp[415] D=buffer_pmp[394]
+ CK=CTS_58 RB=FE_OFN912_i_reset_n_i
Xbuffer_pmp_reg[436] QDFFRBN $PINS Q=buffer_pmp[436] D=buffer_pmp[415]
+ CK=CTS_58 RB=FE_OFN795_i_reset_n_i
Xbuffer_pmp_reg[457] QDFFRBN $PINS Q=buffer_pmp[457] D=buffer_pmp[436]
+ CK=CTS_58 RB=FE_OFN988_i_reset_n_i
Xbuffer_pmp_reg[478] QDFFRBN $PINS Q=buffer_pmp[478] D=buffer_pmp[457]
+ CK=CTS_58 RB=FE_OFN988_i_reset_n_i
Xbuffer_pmp_reg[499] QDFFRBN $PINS Q=buffer_pmp[499] D=buffer_pmp[478]
+ CK=CTS_61 RB=FE_OFN988_i_reset_n_i
Xbuffer_pmp_reg[520] QDFFRBN $PINS Q=buffer_pmp[520] D=buffer_pmp[499]
+ CK=CTS_61 RB=FE_OFN909_i_reset_n_i
Xbuffer_pmp_reg[541] QDFFRBN $PINS Q=buffer_pmp[541] D=buffer_pmp[520]
+ CK=CTS_61 RB=FE_OFN909_i_reset_n_i
Xbuffer_pmp_reg[562] QDFFRBN $PINS Q=buffer_pmp[562] D=buffer_pmp[541]
+ CK=CTS_58 RB=FE_OFN795_i_reset_n_i
Xbuffer_pmp_reg[583] QDFFRBN $PINS Q=buffer_pmp[583] D=buffer_pmp[562]
+ CK=CTS_58 RB=FE_OFN664_i_reset_n_i
Xbuffer_pmp_reg[604] QDFFRBN $PINS Q=buffer_pmp[604] D=buffer_pmp[583]
+ CK=CTS_58 RB=FE_OFN664_i_reset_n_i
Xbuffer_pmp_reg[625] QDFFRBN $PINS Q=buffer_pmp[625] D=buffer_pmp[604]
+ CK=CTS_58 RB=FE_OFN912_i_reset_n_i
Xbuffer_pmp_reg[646] QDFFRBN $PINS Q=buffer_pmp[646] D=buffer_pmp[625]
+ CK=CTS_58 RB=FE_OFN796_i_reset_n_i
Xbuffer_pmp_reg[667] QDFFRBN $PINS Q=buffer_pmp[667] D=buffer_pmp[646]
+ CK=CTS_58 RB=FE_OFN913_i_reset_n_i
Xbuffer_pmp_reg[688] QDFFRBN $PINS Q=buffer_pmp[688] D=buffer_pmp[667]
+ CK=CTS_58 RB=FE_OFN913_i_reset_n_i
Xbuffer_pmp_reg[709] QDFFRBN $PINS Q=buffer_pmp[709] D=buffer_pmp[688]
+ CK=CTS_58 RB=FE_OFN991_i_reset_n_i
Xbuffer_pmp_reg[730] QDFFRBN $PINS Q=buffer_pmp[730] D=buffer_pmp[709]
+ CK=CTS_58 RB=FE_OFN991_i_reset_n_i
Xbuffer_pmp_reg[751] QDFFRBN $PINS Q=buffer_pmp[751] D=buffer_pmp[730]
+ CK=CTS_58 RB=FE_OFN991_i_reset_n_i
Xbuffer_pmp_reg[772] QDFFRBN $PINS Q=buffer_pmp[772] D=buffer_pmp[751]
+ CK=CTS_58 RB=FE_OFN1090_i_reset_n_i
Xbuffer_pmp_reg[793] QDFFRBN $PINS Q=buffer_pmp[793] D=buffer_pmp[772]
+ CK=CTS_58 RB=FE_OFN1090_i_reset_n_i
Xbuffer_pmp_reg[814] QDFFRBN $PINS Q=buffer_pmp[814] D=buffer_pmp[793]
+ CK=CTS_58 RB=FE_OFN1090_i_reset_n_i
Xbuffer_pmp_reg[835] QDFFRBN $PINS Q=buffer_pmp[835] D=buffer_pmp[814]
+ CK=CTS_58 RB=FE_OFN1090_i_reset_n_i
Xbuffer_pmp_reg[856] QDFFRBN $PINS Q=buffer_pmp[856] D=buffer_pmp[835]
+ CK=CTS_58 RB=FE_OFN991_i_reset_n_i
Xbuffer_pmp_reg[877] QDFFRBN $PINS Q=buffer_pmp[877] D=buffer_pmp[856]
+ CK=CTS_58 RB=FE_OFN991_i_reset_n_i
Xbuffer_pmp_reg[898] QDFFRBN $PINS Q=buffer_pmp[898] D=buffer_pmp[877]
+ CK=CTS_58 RB=FE_OFN991_i_reset_n_i
Xbuffer_pmp_reg[919] QDFFRBN $PINS Q=buffer_pmp[919] D=buffer_pmp[898]
+ CK=CTS_58 RB=FE_OFN913_i_reset_n_i
Xbuffer_pmp_reg[940] QDFFRBN $PINS Q=buffer_pmp[940] D=buffer_pmp[919]
+ CK=CTS_58 RB=FE_OFN913_i_reset_n_i
Xbuffer_pmp_reg[961] QDFFRBN $PINS Q=buffer_pmp[961] D=buffer_pmp[940]
+ CK=CTS_58 RB=FE_OFN913_i_reset_n_i
Xbuffer_pmp_reg[982] QDFFRBN $PINS Q=buffer_pmp[982] D=buffer_pmp[961]
+ CK=CTS_58 RB=FE_OFN796_i_reset_n_i
Xbuffer_pmp_reg[1003] QDFFRBN $PINS Q=buffer_pmp[1003] D=buffer_pmp[982]
+ CK=CTS_58 RB=FE_OFN796_i_reset_n_i
Xbuffer_pmp_reg[1024] QDFFRBN $PINS Q=buffer_pmp[1024] D=buffer_pmp[1003]
+ CK=CTS_58 RB=FE_OFN664_i_reset_n_i
Xbuffer_pmp_reg[1045] QDFFRBN $PINS Q=buffer_pmp[1045] D=buffer_pmp[1024]
+ CK=CTS_61 RB=FE_OFN761_i_reset_n_i
Xbuffer_pmp_reg[1066] QDFFRBN $PINS Q=buffer_pmp[1066] D=buffer_pmp[1045]
+ CK=CTS_61 RB=FE_OFN761_i_reset_n_i
Xbuffer_pmp_reg[1087] QDFFRBN $PINS Q=buffer_pmp[1087] D=buffer_pmp[1066]
+ CK=CTS_61 RB=FE_OFN989_i_reset_n_i
Xbuffer_pmp_reg[1108] QDFFRBN $PINS Q=buffer_pmp[1108] D=buffer_pmp[1087]
+ CK=CTS_61 RB=FE_OFN990_i_reset_n_i
Xpmp_1_r_reg[16] QDFFRBN $PINS Q=pmp_1_r[16] D=pmp_1_w[16] CK=CTS_61
+ RB=FE_OFN924_i_reset_n_i
Xbuffer_pmp_reg[17] QDFFRBN $PINS Q=buffer_pmp[17] D=pmp[17] CK=CTS_69
+ RB=FE_OFN803_i_reset_n_i
Xbuffer_pmp_reg[38] QDFFRBN $PINS Q=buffer_pmp[38] D=buffer_pmp[17] CK=CTS_64
+ RB=FE_OFN803_i_reset_n_i
Xbuffer_pmp_reg[59] QDFFRBN $PINS Q=buffer_pmp[59] D=buffer_pmp[38] CK=CTS_69
+ RB=FE_OFN804_i_reset_n_i
Xbuffer_pmp_reg[80] QDFFRBN $PINS Q=buffer_pmp[80] D=buffer_pmp[59] CK=CTS_60
+ RB=FE_OFN921_i_reset_n_i
Xbuffer_pmp_reg[101] QDFFRBN $PINS Q=buffer_pmp[101] D=buffer_pmp[80] CK=CTS_60
+ RB=FE_OFN923_i_reset_n_i
Xbuffer_pmp_reg[122] QDFFRBN $PINS Q=buffer_pmp[122] D=buffer_pmp[101]
+ CK=CTS_60 RB=FE_OFN392_i_reset_n_i
Xbuffer_pmp_reg[143] QDFFRBN $PINS Q=buffer_pmp[143] D=buffer_pmp[122]
+ CK=CTS_60 RB=FE_OFN546_i_reset_n_i
Xbuffer_pmp_reg[164] QDFFRBN $PINS Q=buffer_pmp[164] D=buffer_pmp[143]
+ CK=CTS_60 RB=FE_OFN451_i_reset_n_i
Xbuffer_pmp_reg[185] QDFFRBN $PINS Q=buffer_pmp[185] D=buffer_pmp[164]
+ CK=CTS_60 RB=FE_OFN451_i_reset_n_i
Xbuffer_pmp_reg[206] QDFFRBN $PINS Q=buffer_pmp[206] D=buffer_pmp[185]
+ CK=CTS_60 RB=FE_OFN547_i_reset_n_i
Xbuffer_pmp_reg[227] QDFFRBN $PINS Q=buffer_pmp[227] D=buffer_pmp[206]
+ CK=CTS_60 RB=FE_OFN547_i_reset_n_i
Xbuffer_pmp_reg[248] QDFFRBN $PINS Q=buffer_pmp[248] D=buffer_pmp[227]
+ CK=CTS_60 RB=FE_OFN660_i_reset_n_i
Xbuffer_pmp_reg[269] QDFFRBN $PINS Q=buffer_pmp[269] D=buffer_pmp[248]
+ CK=CTS_60 RB=FE_OFN660_i_reset_n_i
Xbuffer_pmp_reg[290] QDFFRBN $PINS Q=buffer_pmp[290] D=buffer_pmp[269]
+ CK=CTS_60 RB=FE_OFN907_i_reset_n_i
Xbuffer_pmp_reg[311] QDFFRBN $PINS Q=buffer_pmp[311] D=buffer_pmp[290]
+ CK=CTS_68 RB=FE_OFN666_i_reset_n_i
Xbuffer_pmp_reg[332] QDFFRBN $PINS Q=buffer_pmp[332] D=buffer_pmp[311]
+ CK=CTS_68 RB=FE_OFN666_i_reset_n_i
Xbuffer_pmp_reg[353] QDFFRBN $PINS Q=buffer_pmp[353] D=buffer_pmp[332]
+ CK=CTS_68 RB=FE_OFN797_i_reset_n_i
Xbuffer_pmp_reg[374] QDFFRBN $PINS Q=buffer_pmp[374] D=buffer_pmp[353]
+ CK=CTS_68 RB=FE_OFN797_i_reset_n_i
Xbuffer_pmp_reg[395] QDFFRBN $PINS Q=buffer_pmp[395] D=buffer_pmp[374]
+ CK=CTS_68 RB=FE_OFN797_i_reset_n_i
Xbuffer_pmp_reg[416] QDFFRBN $PINS Q=buffer_pmp[416] D=buffer_pmp[395]
+ CK=CTS_68 RB=FE_OFN791_i_reset_n_i
Xbuffer_pmp_reg[437] QDFFRBN $PINS Q=buffer_pmp[437] D=buffer_pmp[416]
+ CK=CTS_68 RB=FE_OFN791_i_reset_n_i
Xbuffer_pmp_reg[458] QDFFRBN $PINS Q=buffer_pmp[458] D=buffer_pmp[437]
+ CK=CTS_68 RB=FE_OFN791_i_reset_n_i
Xbuffer_pmp_reg[479] QDFFRBN $PINS Q=buffer_pmp[479] D=buffer_pmp[458]
+ CK=CTS_68 RB=FE_OFN661_i_reset_n_i
Xbuffer_pmp_reg[500] QDFFRBN $PINS Q=buffer_pmp[500] D=buffer_pmp[479]
+ CK=CTS_60 RB=FE_OFN547_i_reset_n_i
Xbuffer_pmp_reg[521] QDFFRBN $PINS Q=buffer_pmp[521] D=buffer_pmp[500]
+ CK=CTS_60 RB=FE_OFN660_i_reset_n_i
Xbuffer_pmp_reg[542] QDFFRBN $PINS Q=buffer_pmp[542] D=buffer_pmp[521]
+ CK=CTS_61 RB=FE_OFN792_i_reset_n_i
Xbuffer_pmp_reg[563] QDFFRBN $PINS Q=buffer_pmp[563] D=buffer_pmp[542]
+ CK=CTS_61 RB=FE_OFN792_i_reset_n_i
Xbuffer_pmp_reg[584] QDFFRBN $PINS Q=buffer_pmp[584] D=buffer_pmp[563]
+ CK=CTS_61 RB=FE_OFN661_i_reset_n_i
Xbuffer_pmp_reg[605] QDFFRBN $PINS Q=buffer_pmp[605] D=buffer_pmp[584]
+ CK=CTS_58 RB=FE_OFN908_i_reset_n_i
Xbuffer_pmp_reg[626] QDFFRBN $PINS Q=buffer_pmp[626] D=buffer_pmp[605]
+ CK=CTS_58 RB=FE_OFN452_i_reset_n_i
Xbuffer_pmp_reg[647] QDFFRBN $PINS Q=buffer_pmp[647] D=buffer_pmp[626]
+ CK=CTS_58 RB=FE_OFN452_i_reset_n_i
Xbuffer_pmp_reg[668] QDFFRBN $PINS Q=buffer_pmp[668] D=buffer_pmp[647]
+ CK=CTS_68 RB=FE_OFN393_i_reset_n_i
Xbuffer_pmp_reg[689] QDFFRBN $PINS Q=buffer_pmp[689] D=buffer_pmp[668]
+ CK=CTS_68 RB=FE_OFN914_i_reset_n_i
Xbuffer_pmp_reg[710] QDFFRBN $PINS Q=buffer_pmp[710] D=buffer_pmp[689]
+ CK=CTS_68 RB=FE_OFN453_i_reset_n_i
Xbuffer_pmp_reg[731] QDFFRBN $PINS Q=buffer_pmp[731] D=buffer_pmp[710]
+ CK=CTS_68 RB=FE_OFN393_i_reset_n_i
Xbuffer_pmp_reg[752] QDFFRBN $PINS Q=buffer_pmp[752] D=buffer_pmp[731]
+ CK=CTS_68 RB=FE_OFN548_i_reset_n_i
Xbuffer_pmp_reg[773] QDFFRBN $PINS Q=buffer_pmp[773] D=buffer_pmp[752]
+ CK=CTS_68 RB=FE_OFN548_i_reset_n_i
Xbuffer_pmp_reg[794] QDFFRBN $PINS Q=buffer_pmp[794] D=buffer_pmp[773]
+ CK=CTS_68 RB=FE_OFN548_i_reset_n_i
Xbuffer_pmp_reg[815] QDFFRBN $PINS Q=buffer_pmp[815] D=buffer_pmp[794]
+ CK=CTS_68 RB=FE_OFN548_i_reset_n_i
Xbuffer_pmp_reg[836] QDFFRBN $PINS Q=buffer_pmp[836] D=buffer_pmp[815]
+ CK=CTS_58 RB=FE_OFN794_i_reset_n_i
Xbuffer_pmp_reg[857] QDFFRBN $PINS Q=buffer_pmp[857] D=buffer_pmp[836]
+ CK=CTS_58 RB=FE_OFN794_i_reset_n_i
Xbuffer_pmp_reg[878] QDFFRBN $PINS Q=buffer_pmp[878] D=buffer_pmp[857]
+ CK=CTS_58 RB=FE_OFN548_i_reset_n_i
Xbuffer_pmp_reg[899] QDFFRBN $PINS Q=buffer_pmp[899] D=buffer_pmp[878]
+ CK=CTS_58 RB=FE_OFN548_i_reset_n_i
Xbuffer_pmp_reg[920] QDFFRBN $PINS Q=buffer_pmp[920] D=buffer_pmp[899]
+ CK=CTS_58 RB=FE_OFN453_i_reset_n_i
Xbuffer_pmp_reg[941] QDFFRBN $PINS Q=buffer_pmp[941] D=buffer_pmp[920]
+ CK=CTS_68 RB=FE_OFN453_i_reset_n_i
Xbuffer_pmp_reg[962] QDFFRBN $PINS Q=buffer_pmp[962] D=buffer_pmp[941]
+ CK=CTS_58 RB=FE_OFN452_i_reset_n_i
Xbuffer_pmp_reg[983] QDFFRBN $PINS Q=buffer_pmp[983] D=buffer_pmp[962]
+ CK=CTS_68 RB=FE_OFN452_i_reset_n_i
Xbuffer_pmp_reg[1004] QDFFRBN $PINS Q=buffer_pmp[1004] D=buffer_pmp[983]
+ CK=CTS_61 RB=FE_OFN791_i_reset_n_i
Xbuffer_pmp_reg[1025] QDFFRBN $PINS Q=buffer_pmp[1025] D=buffer_pmp[1004]
+ CK=CTS_68 RB=FE_OFN791_i_reset_n_i
Xbuffer_pmp_reg[1046] QDFFRBN $PINS Q=buffer_pmp[1046] D=buffer_pmp[1025]
+ CK=CTS_61 RB=FE_OFN791_i_reset_n_i
Xbuffer_pmp_reg[1067] QDFFRBN $PINS Q=buffer_pmp[1067] D=buffer_pmp[1046]
+ CK=CTS_61 RB=FE_OFN661_i_reset_n_i
Xbuffer_pmp_reg[1088] QDFFRBN $PINS Q=buffer_pmp[1088] D=buffer_pmp[1067]
+ CK=CTS_60 RB=FE_OFN660_i_reset_n_i
Xbuffer_pmp_reg[1109] QDFFRBN $PINS Q=buffer_pmp[1109] D=buffer_pmp[1088]
+ CK=CTS_61 RB=FE_OFN660_i_reset_n_i
Xpmp_1_r_reg[17] QDFFRBN $PINS Q=pmp_1_r[17] D=pmp_1_w[17] CK=CTS_60
+ RB=FE_OFN392_i_reset_n_i
Xbuffer_pmp_reg[18] QDFFRBN $PINS Q=buffer_pmp[18] D=pmp[18] CK=CTS_69
+ RB=FE_OFN922_i_reset_n_i
Xbuffer_pmp_reg[39] QDFFRBN $PINS Q=buffer_pmp[39] D=buffer_pmp[18] CK=CTS_69
+ RB=FE_OFN922_i_reset_n_i
Xbuffer_pmp_reg[60] QDFFRBN $PINS Q=buffer_pmp[60] D=buffer_pmp[39] CK=CTS_69
+ RB=FE_OFN922_i_reset_n_i
Xbuffer_pmp_reg[81] QDFFRBN $PINS Q=buffer_pmp[81] D=buffer_pmp[60] CK=CTS_69
+ RB=FE_OFN802_i_reset_n_i
Xbuffer_pmp_reg[102] QDFFRBN $PINS Q=buffer_pmp[102] D=buffer_pmp[81] CK=CTS_69
+ RB=FE_OFN802_i_reset_n_i
Xbuffer_pmp_reg[123] QDFFRBN $PINS Q=buffer_pmp[123] D=buffer_pmp[102]
+ CK=CTS_69 RB=FE_OFN802_i_reset_n_i
Xbuffer_pmp_reg[144] QDFFRBN $PINS Q=buffer_pmp[144] D=buffer_pmp[123]
+ CK=CTS_69 RB=FE_OFN921_i_reset_n_i
Xbuffer_pmp_reg[165] QDFFRBN $PINS Q=buffer_pmp[165] D=buffer_pmp[144]
+ CK=CTS_69 RB=FE_OFN921_i_reset_n_i
Xbuffer_pmp_reg[186] QDFFRBN $PINS Q=buffer_pmp[186] D=buffer_pmp[165]
+ CK=CTS_60 RB=FE_OFN921_i_reset_n_i
Xbuffer_pmp_reg[207] QDFFRBN $PINS Q=buffer_pmp[207] D=buffer_pmp[186]
+ CK=CTS_60 RB=FE_OFN657_i_reset_n_i
Xbuffer_pmp_reg[228] QDFFRBN $PINS Q=buffer_pmp[228] D=buffer_pmp[207]
+ CK=CTS_60 RB=FE_OFN451_i_reset_n_i
Xbuffer_pmp_reg[249] QDFFRBN $PINS Q=buffer_pmp[249] D=buffer_pmp[228]
+ CK=CTS_60 RB=FE_OFN657_i_reset_n_i
Xbuffer_pmp_reg[270] QDFFRBN $PINS Q=buffer_pmp[270] D=buffer_pmp[249]
+ CK=CTS_60 RB=FE_OFN657_i_reset_n_i
Xbuffer_pmp_reg[291] QDFFRBN $PINS Q=buffer_pmp[291] D=buffer_pmp[270]
+ CK=CTS_60 RB=FE_OFN786_i_reset_n_i
Xbuffer_pmp_reg[312] QDFFRBN $PINS Q=buffer_pmp[312] D=buffer_pmp[291]
+ CK=CTS_60 RB=FE_OFN544_i_reset_n_i
Xbuffer_pmp_reg[333] QDFFRBN $PINS Q=buffer_pmp[333] D=buffer_pmp[312]
+ CK=CTS_60 RB=FE_OFN544_i_reset_n_i
Xbuffer_pmp_reg[354] QDFFRBN $PINS Q=buffer_pmp[354] D=buffer_pmp[333]
+ CK=CTS_60 RB=FE_OFN544_i_reset_n_i
Xbuffer_pmp_reg[375] QDFFRBN $PINS Q=buffer_pmp[375] D=buffer_pmp[354]
+ CK=CTS_60 RB=FE_OFN544_i_reset_n_i
Xbuffer_pmp_reg[396] QDFFRBN $PINS Q=buffer_pmp[396] D=buffer_pmp[375]
+ CK=CTS_60 RB=FE_OFN544_i_reset_n_i
Xbuffer_pmp_reg[417] QDFFRBN $PINS Q=buffer_pmp[417] D=buffer_pmp[396]
+ CK=CTS_60 RB=FE_OFN657_i_reset_n_i
Xbuffer_pmp_reg[438] QDFFRBN $PINS Q=buffer_pmp[438] D=buffer_pmp[417]
+ CK=CTS_60 RB=FE_OFN657_i_reset_n_i
Xbuffer_pmp_reg[459] QDFFRBN $PINS Q=buffer_pmp[459] D=buffer_pmp[438]
+ CK=CTS_60 RB=FE_OFN907_i_reset_n_i
Xbuffer_pmp_reg[480] QDFFRBN $PINS Q=buffer_pmp[480] D=buffer_pmp[459]
+ CK=CTS_60 RB=FE_OFN907_i_reset_n_i
Xbuffer_pmp_reg[501] QDFFRBN $PINS Q=buffer_pmp[501] D=buffer_pmp[480]
+ CK=CTS_60 RB=FE_OFN907_i_reset_n_i
Xbuffer_pmp_reg[522] QDFFRBN $PINS Q=buffer_pmp[522] D=buffer_pmp[501]
+ CK=CTS_60 RB=FE_OFN788_i_reset_n_i
Xbuffer_pmp_reg[543] QDFFRBN $PINS Q=buffer_pmp[543] D=buffer_pmp[522]
+ CK=CTS_60 RB=FE_OFN907_i_reset_n_i
Xbuffer_pmp_reg[564] QDFFRBN $PINS Q=buffer_pmp[564] D=buffer_pmp[543]
+ CK=CTS_60 RB=FE_OFN907_i_reset_n_i
Xbuffer_pmp_reg[585] QDFFRBN $PINS Q=buffer_pmp[585] D=buffer_pmp[564]
+ CK=CTS_68 RB=FE_OFN906_i_reset_n_i
Xbuffer_pmp_reg[606] QDFFRBN $PINS Q=buffer_pmp[606] D=buffer_pmp[585]
+ CK=CTS_68 RB=FE_OFN666_i_reset_n_i
Xbuffer_pmp_reg[627] QDFFRBN $PINS Q=buffer_pmp[627] D=buffer_pmp[606]
+ CK=CTS_68 RB=FE_OFN665_i_reset_n_i
Xbuffer_pmp_reg[648] QDFFRBN $PINS Q=buffer_pmp[648] D=buffer_pmp[627]
+ CK=CTS_68 RB=FE_OFN666_i_reset_n_i
Xbuffer_pmp_reg[669] QDFFRBN $PINS Q=buffer_pmp[669] D=buffer_pmp[648]
+ CK=CTS_68 RB=FE_OFN550_i_reset_n_i
Xbuffer_pmp_reg[690] QDFFRBN $PINS Q=buffer_pmp[690] D=buffer_pmp[669]
+ CK=CTS_68 RB=FE_OFN667_i_reset_n_i
Xbuffer_pmp_reg[711] QDFFRBN $PINS Q=buffer_pmp[711] D=buffer_pmp[690]
+ CK=CTS_68 RB=FE_OFN667_i_reset_n_i
Xbuffer_pmp_reg[732] QDFFRBN $PINS Q=buffer_pmp[732] D=buffer_pmp[711]
+ CK=CTS_68 RB=FE_OFN798_i_reset_n_i
Xbuffer_pmp_reg[753] QDFFRBN $PINS Q=buffer_pmp[753] D=buffer_pmp[732]
+ CK=CTS_68 RB=FE_OFN915_i_reset_n_i
Xbuffer_pmp_reg[774] QDFFRBN $PINS Q=buffer_pmp[774] D=buffer_pmp[753]
+ CK=CTS_68 RB=FE_OFN915_i_reset_n_i
Xbuffer_pmp_reg[795] QDFFRBN $PINS Q=buffer_pmp[795] D=buffer_pmp[774]
+ CK=CTS_68 RB=FE_OFN915_i_reset_n_i
Xbuffer_pmp_reg[816] QDFFRBN $PINS Q=buffer_pmp[816] D=buffer_pmp[795]
+ CK=CTS_68 RB=FE_OFN915_i_reset_n_i
Xbuffer_pmp_reg[837] QDFFRBN $PINS Q=buffer_pmp[837] D=buffer_pmp[816]
+ CK=CTS_68 RB=FE_OFN915_i_reset_n_i
Xbuffer_pmp_reg[858] QDFFRBN $PINS Q=buffer_pmp[858] D=buffer_pmp[837]
+ CK=CTS_68 RB=FE_OFN915_i_reset_n_i
Xbuffer_pmp_reg[879] QDFFRBN $PINS Q=buffer_pmp[879] D=buffer_pmp[858]
+ CK=CTS_68 RB=FE_OFN798_i_reset_n_i
Xbuffer_pmp_reg[900] QDFFRBN $PINS Q=buffer_pmp[900] D=buffer_pmp[879]
+ CK=CTS_68 RB=FE_OFN914_i_reset_n_i
Xbuffer_pmp_reg[921] QDFFRBN $PINS Q=buffer_pmp[921] D=buffer_pmp[900]
+ CK=CTS_68 RB=FE_OFN798_i_reset_n_i
Xbuffer_pmp_reg[942] QDFFRBN $PINS Q=buffer_pmp[942] D=buffer_pmp[921]
+ CK=CTS_68 RB=FE_OFN914_i_reset_n_i
Xbuffer_pmp_reg[963] QDFFRBN $PINS Q=buffer_pmp[963] D=buffer_pmp[942]
+ CK=CTS_68 RB=FE_OFN797_i_reset_n_i
Xbuffer_pmp_reg[984] QDFFRBN $PINS Q=buffer_pmp[984] D=buffer_pmp[963]
+ CK=CTS_68 RB=FE_OFN797_i_reset_n_i
Xbuffer_pmp_reg[1005] QDFFRBN $PINS Q=buffer_pmp[1005] D=buffer_pmp[984]
+ CK=CTS_68 RB=FE_OFN666_i_reset_n_i
Xbuffer_pmp_reg[1026] QDFFRBN $PINS Q=buffer_pmp[1026] D=buffer_pmp[1005]
+ CK=CTS_68 RB=FE_OFN665_i_reset_n_i
Xbuffer_pmp_reg[1047] QDFFRBN $PINS Q=buffer_pmp[1047] D=buffer_pmp[1026]
+ CK=CTS_68 RB=FE_OFN906_i_reset_n_i
Xbuffer_pmp_reg[1068] QDFFRBN $PINS Q=buffer_pmp[1068] D=buffer_pmp[1047]
+ CK=CTS_68 RB=FE_OFN906_i_reset_n_i
Xbuffer_pmp_reg[1089] QDFFRBN $PINS Q=buffer_pmp[1089] D=buffer_pmp[1068]
+ CK=CTS_60 RB=FE_OFN788_i_reset_n_i
Xbuffer_pmp_reg[1110] QDFFRBN $PINS Q=buffer_pmp[1110] D=buffer_pmp[1089]
+ CK=CTS_60 RB=FE_OFN788_i_reset_n_i
Xpmp_1_r_reg[18] QDFFRBN $PINS Q=pmp_1_r[18] D=pmp_1_w[18] CK=CTS_60
+ RB=FE_OFN451_i_reset_n_i
XBuffer/counter_temp_reg[3] QDFFRBN $PINS Q=Buffer/counter_temp[3] D=n1710
+ CK=CTS_29 RB=FE_OFN634_i_reset_n_i
XBuffer/data_buffer_reg[0] QDFFRBN $PINS Q=Buffer/data_buffer[0] D=n1709
+ CK=CTS_34 RB=FE_OFN439_i_reset_n_i
XBuffer/data_buffer_reg[1] QDFFRBN $PINS Q=Buffer/data_buffer[1] D=n1708
+ CK=CTS_29 RB=FE_OFN634_i_reset_n_i
XBuffer/data_buffer_reg[2] QDFFRBN $PINS Q=Buffer/data_buffer[2] D=n1707
+ CK=CTS_29 RB=FE_OFN437_i_reset_n_i
XBuffer/data_buffer_reg[3] QDFFRBN $PINS Q=Buffer/data_buffer[3] D=n1706
+ CK=CTS_29 RB=FE_OFN1007_i_reset_n_i
XBuffer/data_buffer_reg[4] QDFFRBN $PINS Q=Buffer/data_buffer[4] D=n1705
+ CK=CTS_2 RB=FE_OFN477_i_reset_n_i
XBuffer/data_buffer_reg[5] QDFFRBN $PINS Q=Buffer/data_buffer[5] D=n1704
+ CK=CTS_2 RB=FE_OFN696_i_reset_n_i
XBuffer/data_buffer_reg[6] QDFFRBN $PINS Q=Buffer/data_buffer[6] D=n1703
+ CK=CTS_29 RB=FE_OFN381_i_reset_n_i
XBuffer/data_buffer_reg[7] QDFFRBN $PINS Q=Buffer/data_buffer[7] D=n1702
+ CK=CTS_29 RB=FE_OFN634_i_reset_n_i
XBuffer/data_buffer_reg[8] QDFFRBN $PINS Q=Buffer/data_buffer[8] D=n1701
+ CK=CTS_34 RB=FE_OFN439_i_reset_n_i
XBuffer/data_buffer_reg[9] QDFFRBN $PINS Q=Buffer/data_buffer[9] D=n1700
+ CK=CTS_29 RB=FE_OFN524_i_reset_n_i
XBuffer/data_buffer_reg[10] QDFFRBN $PINS Q=Buffer/data_buffer[10] D=n1699
+ CK=CTS_29 RB=FE_OFN636_i_reset_n_i
XBuffer/data_buffer_reg[11] QDFFRBN $PINS Q=Buffer/data_buffer[11] D=n1698
+ CK=CTS_29 RB=FE_OFN1008_i_reset_n_i
XBuffer/data_buffer_reg[12] QDFFRBN $PINS Q=Buffer/data_buffer[12] D=n1697
+ CK=CTS_26 RB=FE_OFN576_i_reset_n_i
XBuffer/data_buffer_reg[13] QDFFRBN $PINS Q=Buffer/data_buffer[13] D=n1696
+ CK=CTS_26 RB=FE_OFN696_i_reset_n_i
XBuffer/data_buffer_reg[14] QDFFRBN $PINS Q=Buffer/data_buffer[14] D=n1695
+ CK=CTS_29 RB=FE_OFN524_i_reset_n_i
XBuffer/data_buffer_reg[15] QDFFRBN $PINS Q=Buffer/data_buffer[15] D=n1694
+ CK=CTS_29 RB=FE_OFN524_i_reset_n_i
XBuffer/data_buffer_reg[16] QDFFRBN $PINS Q=Buffer/data_buffer[16] D=n1693
+ CK=CTS_34 RB=FE_OFN812_i_reset_n_i
XBuffer/data_buffer_reg[17] QDFFRBN $PINS Q=Buffer/data_buffer[17] D=n1692
+ CK=CTS_29 RB=FE_OFN636_i_reset_n_i
XBuffer/data_buffer_reg[18] QDFFRBN $PINS Q=Buffer/data_buffer[18] D=n1691
+ CK=CTS_29 RB=FE_OFN766_i_reset_n_i
XBuffer/data_buffer_reg[19] QDFFRBN $PINS Q=Buffer/data_buffer[19] D=n1690
+ CK=CTS_29 RB=FE_OFN1008_i_reset_n_i
XBuffer/data_buffer_reg[20] QDFFRBN $PINS Q=Buffer/data_buffer[20] D=n1689
+ CK=CTS_26 RB=FE_OFN576_i_reset_n_i
XBuffer/data_buffer_reg[21] QDFFRBN $PINS Q=Buffer/data_buffer[21] D=n1688
+ CK=CTS_2 RB=FE_OFN696_i_reset_n_i
XBuffer/data_buffer_reg[22] QDFFRBN $PINS Q=Buffer/data_buffer[22] D=n1687
+ CK=CTS_29 RB=FE_OFN636_i_reset_n_i
XBuffer/data_buffer_reg[23] QDFFRBN $PINS Q=Buffer/data_buffer[23] D=n1686
+ CK=CTS_29 RB=FE_OFN636_i_reset_n_i
XBuffer/data_buffer_reg[24] QDFFRBN $PINS Q=Buffer/data_buffer[24] D=n1685
+ CK=CTS_31 RB=FE_OFN812_i_reset_n_i
XBuffer/data_buffer_reg[25] QDFFRBN $PINS Q=Buffer/data_buffer[25] D=n1684
+ CK=CTS_29 RB=FE_OFN765_i_reset_n_i
XBuffer/data_buffer_reg[26] QDFFRBN $PINS Q=Buffer/data_buffer[26] D=n1683
+ CK=CTS_29 RB=FE_OFN765_i_reset_n_i
XBuffer/data_buffer_reg[27] QDFFRBN $PINS Q=Buffer/data_buffer[27] D=n1682
+ CK=CTS_29 RB=FE_OFN938_i_reset_n_i
XBuffer/data_buffer_reg[28] QDFFRBN $PINS Q=Buffer/data_buffer[28] D=n1681
+ CK=CTS_26 RB=FE_OFN694_i_reset_n_i
XBuffer/data_buffer_reg[29] QDFFRBN $PINS Q=Buffer/data_buffer[29] D=n1680
+ CK=CTS_26 RB=FE_OFN694_i_reset_n_i
XBuffer/data_buffer_reg[30] QDFFRBN $PINS Q=Buffer/data_buffer[30] D=n1679
+ CK=CTS_29 RB=FE_OFN766_i_reset_n_i
XBuffer/data_buffer_reg[31] QDFFRBN $PINS Q=Buffer/data_buffer[31] D=n1678
+ CK=CTS_29 RB=FE_OFN765_i_reset_n_i
XBuffer/data_buffer_reg[32] QDFFRBN $PINS Q=Buffer/data_buffer[32] D=n1677
+ CK=CTS_31 RB=FE_OFN813_i_reset_n_i
XBuffer/data_buffer_reg[33] QDFFRBN $PINS Q=Buffer/data_buffer[33] D=n1676
+ CK=CTS_29 RB=FE_OFN765_i_reset_n_i
XBuffer/data_buffer_reg[34] QDFFRBN $PINS Q=Buffer/data_buffer[34] D=n1675
+ CK=CTS_29 RB=FE_OFN1008_i_reset_n_i
XBuffer/data_buffer_reg[35] QDFFRBN $PINS Q=Buffer/data_buffer[35] D=n1674
+ CK=CTS_29 RB=FE_OFN1054_i_reset_n_i
XBuffer/data_buffer_reg[36] QDFFRBN $PINS Q=Buffer/data_buffer[36] D=n1673
+ CK=CTS_26 RB=FE_OFN1054_i_reset_n_i
XBuffer/data_buffer_reg[37] QDFFRBN $PINS Q=Buffer/data_buffer[37] D=n1672
+ CK=CTS_26 RB=FE_OFN694_i_reset_n_i
XBuffer/data_buffer_reg[38] QDFFRBN $PINS Q=Buffer/data_buffer[38] D=n1671
+ CK=CTS_29 RB=FE_OFN1007_i_reset_n_i
XBuffer/data_buffer_reg[39] QDFFRBN $PINS Q=Buffer/data_buffer[39] D=n1670
+ CK=CTS_29 RB=FE_OFN765_i_reset_n_i
XBuffer/data_buffer_reg[40] QDFFRBN $PINS Q=Buffer/data_buffer[40] D=n1669
+ CK=CTS_31 RB=FE_OFN465_i_reset_n_i
XBuffer/data_buffer_reg[41] QDFFRBN $PINS Q=Buffer/data_buffer[41] D=n1668
+ CK=CTS_26 RB=FE_OFN1054_i_reset_n_i
XBuffer/data_buffer_reg[42] QDFFRBN $PINS Q=Buffer/data_buffer[42] D=n1667
+ CK=CTS_26 RB=FE_OFN980_i_reset_n_i
XBuffer/data_buffer_reg[43] QDFFRBN $PINS Q=Buffer/data_buffer[43] D=n1666
+ CK=CTS_26 RB=FE_OFN1054_i_reset_n_i
XBuffer/data_buffer_reg[44] QDFFRBN $PINS Q=Buffer/data_buffer[44] D=n1665
+ CK=CTS_26 RB=FE_OFN694_i_reset_n_i
XBuffer/data_buffer_reg[45] QDFFRBN $PINS Q=Buffer/data_buffer[45] D=n1664
+ CK=CTS_34 RB=FE_OFN1060_i_reset_n_i
XBuffer/data_buffer_reg[46] QDFFRBN $PINS Q=Buffer/data_buffer[46] D=n1663
+ CK=CTS_26 RB=FE_OFN1006_i_reset_n_i
XBuffer/data_buffer_reg[47] QDFFRBN $PINS Q=Buffer/data_buffer[47] D=n1662
+ CK=CTS_26 RB=FE_OFN1054_i_reset_n_i
XBuffer/data_buffer_reg[48] QDFFRBN $PINS Q=Buffer/data_buffer[48] D=n1661
+ CK=CTS_31 RB=FE_OFN461_i_reset_n_i
XBuffer/data_buffer_reg[49] QDFFRBN $PINS Q=Buffer/data_buffer[49] D=n1660
+ CK=CTS_26 RB=FE_OFN383_i_reset_n_i
XBuffer/data_buffer_reg[50] QDFFRBN $PINS Q=Buffer/data_buffer[50] D=n1659
+ CK=CTS_26 RB=FE_OFN383_i_reset_n_i
XBuffer/data_buffer_reg[51] QDFFRBN $PINS Q=Buffer/data_buffer[51] D=n1658
+ CK=CTS_26 RB=FE_OFN1060_i_reset_n_i
XBuffer/data_buffer_reg[52] QDFFRBN $PINS Q=Buffer/data_buffer[52] D=n1657
+ CK=CTS_34 RB=FE_OFN1092_i_reset_n_i
XBuffer/data_buffer_reg[53] QDFFRBN $PINS Q=Buffer/data_buffer[53] D=n1656
+ CK=CTS_34 RB=FE_OFN1092_i_reset_n_i
XBuffer/data_buffer_reg[54] QDFFRBN $PINS Q=Buffer/data_buffer[54] D=n1655
+ CK=CTS_26 RB=FE_OFN694_i_reset_n_i
XBuffer/data_buffer_reg[55] QDFFRBN $PINS Q=Buffer/data_buffer[55] D=n1654
+ CK=CTS_26 RB=FE_OFN383_i_reset_n_i
XBuffer/data_buffer_reg[56] QDFFRBN $PINS Q=Buffer/data_buffer[56] D=n1653
+ CK=CTS_18 RB=FE_OFN556_i_reset_n_i
XBuffer/data_buffer_reg[57] QDFFRBN $PINS Q=Buffer/data_buffer[57] D=n1652
+ CK=CTS_34 RB=FE_OFN692_i_reset_n_i
XBuffer/data_buffer_reg[58] QDFFRBN $PINS Q=Buffer/data_buffer[58] D=n1651
+ CK=CTS_31 RB=FE_OFN830_i_reset_n_i
XBuffer/data_buffer_reg[59] QDFFRBN $PINS Q=Buffer/data_buffer[59] D=n1650
+ CK=CTS_34 RB=FE_OFN569_i_reset_n_i
XBuffer/data_buffer_reg[60] QDFFRBN $PINS Q=Buffer/data_buffer[60] D=n1649
+ CK=CTS_34 RB=FE_OFN832_i_reset_n_i
XBuffer/data_buffer_reg[61] QDFFRBN $PINS Q=Buffer/data_buffer[61] D=n1648
+ CK=CTS_31 RB=FE_OFN702_i_reset_n_i
XBuffer/data_buffer_reg[62] QDFFRBN $PINS Q=Buffer/data_buffer[62] D=n1647
+ CK=CTS_34 RB=FE_OFN569_i_reset_n_i
XBuffer/data_buffer_reg[63] QDFFRBN $PINS Q=Buffer/data_buffer[63] D=n1646
+ CK=CTS_34 RB=FE_OFN569_i_reset_n_i
XBuffer/data_buffer_reg[64] QDFFRBN $PINS Q=Buffer/data_buffer[64] D=n1645
+ CK=CTS_18 RB=FE_OFN556_i_reset_n_i
XBuffer/data_buffer_reg[65] QDFFRBN $PINS Q=Buffer/data_buffer[65] D=n1644
+ CK=CTS_31 RB=FE_OFN830_i_reset_n_i
XBuffer/data_buffer_reg[66] QDFFRBN $PINS Q=Buffer/data_buffer[66] D=n1643
+ CK=CTS_31 RB=FE_OFN830_i_reset_n_i
XBuffer/data_buffer_reg[67] QDFFRBN $PINS Q=Buffer/data_buffer[67] D=n1642
+ CK=CTS_31 RB=FE_OFN578_i_reset_n_i
XBuffer/data_buffer_reg[68] QDFFRBN $PINS Q=Buffer/data_buffer[68] D=n1641
+ CK=CTS_3 RB=FE_OFN479_i_reset_n_i
XBuffer/data_buffer_reg[69] QDFFRBN $PINS Q=Buffer/data_buffer[69] D=n1640
+ CK=CTS_31 RB=FE_OFN478_i_reset_n_i
XBuffer/data_buffer_reg[70] QDFFRBN $PINS Q=Buffer/data_buffer[70] D=n1639
+ CK=CTS_3 RB=FE_OFN479_i_reset_n_i
XBuffer/data_buffer_reg[71] QDFFRBN $PINS Q=Buffer/data_buffer[71] D=n1638
+ CK=CTS_31 RB=FE_OFN830_i_reset_n_i
XBuffer/data_buffer_reg[72] QDFFRBN $PINS Q=Buffer/data_buffer[72] D=n1637
+ CK=CTS_18 RB=FE_OFN820_i_reset_n_i
XBuffer/data_buffer_reg[73] QDFFRBN $PINS Q=Buffer/data_buffer[73] D=n1636
+ CK=CTS_31 RB=FE_OFN558_i_reset_n_i
XBuffer/data_buffer_reg[74] QDFFRBN $PINS Q=Buffer/data_buffer[74] D=n1635
+ CK=CTS_31 RB=FE_OFN700_i_reset_n_i
XBuffer/data_buffer_reg[75] QDFFRBN $PINS Q=Buffer/data_buffer[75] D=n1634
+ CK=CTS_31 RB=FE_OFN478_i_reset_n_i
XBuffer/data_buffer_reg[76] QDFFRBN $PINS Q=Buffer/data_buffer[76] D=n1633
+ CK=CTS_21 RB=FE_OFN577_i_reset_n_i
XBuffer/data_buffer_reg[77] QDFFRBN $PINS Q=Buffer/data_buffer[77] D=n1632
+ CK=CTS_21 RB=FE_OFN577_i_reset_n_i
XBuffer/data_buffer_reg[78] QDFFRBN $PINS Q=Buffer/data_buffer[78] D=n1631
+ CK=CTS_21 RB=FE_OFN577_i_reset_n_i
XBuffer/data_buffer_reg[79] QDFFRBN $PINS Q=Buffer/data_buffer[79] D=n1630
+ CK=CTS_31 RB=FE_OFN558_i_reset_n_i
XBuffer/data_buffer_reg[80] QDFFRBN $PINS Q=Buffer/data_buffer[80] D=n1629
+ CK=CTS_18 RB=FE_OFN820_i_reset_n_i
XBuffer/data_buffer_reg[81] QDFFRBN $PINS Q=Buffer/data_buffer[81] D=n1628
+ CK=CTS_31 RB=FE_OFN400_i_reset_n_i
XBuffer/data_buffer_reg[82] QDFFRBN $PINS Q=Buffer/data_buffer[82] D=n1627
+ CK=CTS_31 RB=FE_OFN400_i_reset_n_i
XBuffer/data_buffer_reg[83] QDFFRBN $PINS Q=Buffer/data_buffer[83] D=n1626
+ CK=CTS_31 RB=FE_OFN558_i_reset_n_i
XBuffer/data_buffer_reg[84] QDFFRBN $PINS Q=Buffer/data_buffer[84] D=n1625
+ CK=CTS_31 RB=FE_OFN557_i_reset_n_i
XBuffer/data_buffer_reg[85] QDFFRBN $PINS Q=Buffer/data_buffer[85] D=n1624
+ CK=CTS_31 RB=FE_OFN461_i_reset_n_i
XBuffer/data_buffer_reg[86] QDFFRBN $PINS Q=Buffer/data_buffer[86] D=n1623
+ CK=CTS_31 RB=FE_OFN558_i_reset_n_i
XBuffer/data_buffer_reg[87] QDFFRBN $PINS Q=Buffer/data_buffer[87] D=n1622
+ CK=CTS_31 RB=FE_OFN400_i_reset_n_i
XBuffer/data_buffer_reg[88] QDFFRBN $PINS Q=Buffer/data_buffer[88] D=n1621
+ CK=CTS_18 RB=FE_OFN808_i_reset_n_i
XBuffer/data_buffer_reg[89] QDFFRBN $PINS Q=Buffer/data_buffer[89] D=n1620
+ CK=CTS_31 RB=FE_OFN465_i_reset_n_i
XBuffer/data_buffer_reg[90] QDFFRBN $PINS Q=Buffer/data_buffer[90] D=n1619
+ CK=CTS_31 RB=FE_OFN465_i_reset_n_i
XBuffer/data_buffer_reg[91] QDFFRBN $PINS Q=Buffer/data_buffer[91] D=n1618
+ CK=CTS_33 RB=FE_OFN562_i_reset_n_i
XBuffer/data_buffer_reg[92] QDFFRBN $PINS Q=Buffer/data_buffer[92] D=n1617
+ CK=CTS_31 RB=FE_OFN675_i_reset_n_i
XBuffer/data_buffer_reg[93] QDFFRBN $PINS Q=Buffer/data_buffer[93] D=n1616
+ CK=CTS_31 RB=FE_OFN557_i_reset_n_i
XBuffer/data_buffer_reg[94] QDFFRBN $PINS Q=Buffer/data_buffer[94] D=n1615
+ CK=CTS_31 RB=FE_OFN562_i_reset_n_i
XBuffer/data_buffer_reg[95] QDFFRBN $PINS Q=Buffer/data_buffer[95] D=n1614
+ CK=CTS_31 RB=FE_OFN465_i_reset_n_i
XBuffer/data_buffer_reg[96] QDFFRBN $PINS Q=Buffer/data_buffer[96] D=n1613
+ CK=CTS_18 RB=FE_OFN819_i_reset_n_i
XBuffer/data_buffer_reg[97] QDFFRBN $PINS Q=Buffer/data_buffer[97] D=n1612
+ CK=CTS_31 RB=FE_OFN561_i_reset_n_i
XBuffer/data_buffer_reg[98] QDFFRBN $PINS Q=Buffer/data_buffer[98] D=n1611
+ CK=CTS_31 RB=FE_OFN681_i_reset_n_i
XBuffer/data_buffer_reg[99] QDFFRBN $PINS Q=Buffer/data_buffer[99] D=n1610
+ CK=CTS_33 RB=FE_OFN682_i_reset_n_i
XBuffer/data_buffer_reg[100] QDFFRBN $PINS Q=Buffer/data_buffer[100] D=n1609
+ CK=CTS_33 RB=FE_OFN682_i_reset_n_i
XBuffer/data_buffer_reg[101] QDFFRBN $PINS Q=Buffer/data_buffer[101] D=n1608
+ CK=CTS_33 RB=FE_OFN675_i_reset_n_i
XBuffer/data_buffer_reg[102] QDFFRBN $PINS Q=Buffer/data_buffer[102] D=n1607
+ CK=CTS_31 RB=FE_OFN561_i_reset_n_i
XBuffer/data_buffer_reg[103] QDFFRBN $PINS Q=Buffer/data_buffer[103] D=n1606
+ CK=CTS_34 RB=FE_OFN681_i_reset_n_i
XBuffer/data_buffer_reg[104] QDFFRBN $PINS Q=Buffer/data_buffer[104] D=n1605
+ CK=CTS_18 RB=FE_OFN927_i_reset_n_i
XBuffer/data_buffer_reg[105] QDFFRBN $PINS Q=Buffer/data_buffer[105] D=n1604
+ CK=CTS_31 RB=FE_OFN680_i_reset_n_i
XBuffer/data_buffer_reg[106] QDFFRBN $PINS Q=Buffer/data_buffer[106] D=n1603
+ CK=CTS_34 RB=FE_OFN812_i_reset_n_i
XBuffer/data_buffer_reg[107] QDFFRBN $PINS Q=Buffer/data_buffer[107] D=n1602
+ CK=CTS_33 RB=FE_OFN561_i_reset_n_i
XBuffer/data_buffer_reg[108] QDFFRBN $PINS Q=Buffer/data_buffer[108] D=n1601
+ CK=CTS_33 RB=FE_OFN682_i_reset_n_i
XBuffer/data_buffer_reg[109] QDFFRBN $PINS Q=Buffer/data_buffer[109] D=n1600
+ CK=CTS_33 RB=FE_OFN682_i_reset_n_i
XBuffer/data_buffer_reg[110] QDFFRBN $PINS Q=Buffer/data_buffer[110] D=n1599
+ CK=CTS_31 RB=FE_OFN680_i_reset_n_i
XBuffer/data_buffer_reg[111] QDFFRBN $PINS Q=Buffer/data_buffer[111] D=n1598
+ CK=CTS_34 RB=FE_OFN812_i_reset_n_i
XBuffer/data_buffer_reg[112] QDFFRBN $PINS Q=Buffer/data_buffer[112] D=n1597
+ CK=CTS_30 RB=FE_OFN927_i_reset_n_i
XBuffer/data_buffer_reg[113] QDFFRBN $PINS Q=Buffer/data_buffer[113] D=n1596
+ CK=CTS_33 RB=FE_OFN812_i_reset_n_i
XBuffer/data_buffer_reg[114] QDFFRBN $PINS Q=Buffer/data_buffer[114] D=n1595
+ CK=CTS_34 RB=FE_OFN384_i_reset_n_i
XBuffer/data_buffer_reg[115] QDFFRBN $PINS Q=Buffer/data_buffer[115] D=n1594
+ CK=CTS_33 RB=FE_OFN814_i_reset_n_i
XBuffer/data_buffer_reg[116] QDFFRBN $PINS Q=Buffer/data_buffer[116] D=n1593
+ CK=CTS_33 RB=FE_OFN680_i_reset_n_i
XBuffer/data_buffer_reg[117] QDFFRBN $PINS Q=Buffer/data_buffer[117] D=n1592
+ CK=CTS_33 RB=FE_OFN680_i_reset_n_i
XBuffer/data_buffer_reg[118] QDFFRBN $PINS Q=Buffer/data_buffer[118] D=n1591
+ CK=CTS_33 RB=FE_OFN441_i_reset_n_i
XBuffer/data_buffer_reg[119] QDFFRBN $PINS Q=Buffer/data_buffer[119] D=n1590
+ CK=CTS_34 RB=FE_OFN384_i_reset_n_i
XBuffer/data_buffer_reg[120] QDFFRBN $PINS Q=Buffer/data_buffer[120] D=n1589
+ CK=CTS_30 RB=FE_OFN928_i_reset_n_i
XBuffer/data_buffer_reg[121] QDFFRBN $PINS Q=Buffer/data_buffer[121] D=n1588
+ CK=CTS_25 RB=FE_OFN528_i_reset_n_i
XBuffer/data_buffer_reg[122] QDFFRBN $PINS Q=Buffer/data_buffer[122] D=n1587
+ CK=CTS_25 RB=FE_OFN999_i_reset_n_i
XBuffer/data_buffer_reg[123] QDFFRBN $PINS Q=Buffer/data_buffer[123] D=n1586
+ CK=CTS_25 RB=FE_OFN528_i_reset_n_i
XBuffer/data_buffer_reg[124] QDFFRBN $PINS Q=Buffer/data_buffer[124] D=n1585
+ CK=CTS_33 RB=FE_OFN441_i_reset_n_i
XBuffer/data_buffer_reg[125] QDFFRBN $PINS Q=Buffer/data_buffer[125] D=n1584
+ CK=CTS_33 RB=FE_OFN811_i_reset_n_i
XBuffer/data_buffer_reg[126] QDFFRBN $PINS Q=Buffer/data_buffer[126] D=n1583
+ CK=CTS_25 RB=FE_OFN528_i_reset_n_i
XBuffer/data_buffer_reg[127] QDFFRBN $PINS Q=Buffer/data_buffer[127] D=n1582
+ CK=CTS_25 RB=FE_OFN528_i_reset_n_i
XBuffer/data_buffer_reg[128] QDFFRBN $PINS Q=Buffer/data_buffer[128] D=n1581
+ CK=CTS_30 RB=FE_OFN809_i_reset_n_i
XBuffer/data_buffer_reg[129] QDFFRBN $PINS Q=Buffer/data_buffer[129] D=n1580
+ CK=CTS_25 RB=FE_OFN442_i_reset_n_i
XBuffer/data_buffer_reg[130] QDFFRBN $PINS Q=Buffer/data_buffer[130] D=n1579
+ CK=CTS_25 RB=FE_OFN641_i_reset_n_i
XBuffer/data_buffer_reg[131] QDFFRBN $PINS Q=Buffer/data_buffer[131] D=n1578
+ CK=CTS_25 RB=FE_OFN527_i_reset_n_i
XBuffer/data_buffer_reg[132] QDFFRBN $PINS Q=Buffer/data_buffer[132] D=n1577
+ CK=CTS_25 RB=FE_OFN440_i_reset_n_i
XBuffer/data_buffer_reg[133] QDFFRBN $PINS Q=Buffer/data_buffer[133] D=n1576
+ CK=CTS_25 RB=FE_OFN441_i_reset_n_i
XBuffer/data_buffer_reg[134] QDFFRBN $PINS Q=Buffer/data_buffer[134] D=n1575
+ CK=CTS_25 RB=FE_OFN641_i_reset_n_i
XBuffer/data_buffer_reg[135] QDFFRBN $PINS Q=Buffer/data_buffer[135] D=n1574
+ CK=CTS_25 RB=FE_OFN531_i_reset_n_i
XBuffer/data_buffer_reg[136] QDFFRBN $PINS Q=Buffer/data_buffer[136] D=n1573
+ CK=CTS_30 RB=FE_OFN809_i_reset_n_i
XBuffer/data_buffer_reg[137] QDFFRBN $PINS Q=Buffer/data_buffer[137] D=n1572
+ CK=CTS_28 RB=FE_OCPN9784_FE_OFN385_i_reset_n_i
XBuffer/data_buffer_reg[138] QDFFRBN $PINS Q=Buffer/data_buffer[138] D=n1571
+ CK=CTS_28 RB=FE_OFN530_i_reset_n_i
XBuffer/data_buffer_reg[139] QDFFRBN $PINS Q=Buffer/data_buffer[139] D=n1570
+ CK=CTS_25 RB=FE_OFN442_i_reset_n_i
XBuffer/data_buffer_reg[140] QDFFRBN $PINS Q=Buffer/data_buffer[140] D=n1569
+ CK=CTS_34 RB=FE_OFN439_i_reset_n_i
XBuffer/data_buffer_reg[141] QDFFRBN $PINS Q=Buffer/data_buffer[141] D=n1568
+ CK=CTS_25 RB=FE_OFN640_i_reset_n_i
XBuffer/data_buffer_reg[142] QDFFRBN $PINS Q=Buffer/data_buffer[142] D=n1567
+ CK=CTS_28 RB=FE_OFN529_i_reset_n_i
XBuffer/data_buffer_reg[143] QDFFRBN $PINS Q=Buffer/data_buffer[143] D=n1566
+ CK=CTS_28 RB=FE_OFN530_i_reset_n_i
XBuffer/data_buffer_reg[144] QDFFRBN $PINS Q=Buffer/data_buffer[144] D=n1565
+ CK=CTS_30 RB=FE_OFN675_i_reset_n_i
XBuffer/data_buffer_reg[145] QDFFRBN $PINS Q=Buffer/data_buffer[145] D=n1564
+ CK=CTS_28 RB=FE_OFN639_i_reset_n_i
XBuffer/data_buffer_reg[146] QDFFRBN $PINS Q=Buffer/data_buffer[146] D=n1563
+ CK=CTS_28 RB=FE_OFN639_i_reset_n_i
XBuffer/data_buffer_reg[147] QDFFRBN $PINS Q=Buffer/data_buffer[147] D=n1562
+ CK=CTS_34 RB=FE_OFN525_i_reset_n_i
XBuffer/data_buffer_reg[148] QDFFRBN $PINS Q=Buffer/data_buffer[148] D=n1561
+ CK=CTS_34 RB=FE_OFN637_i_reset_n_i
XBuffer/data_buffer_reg[149] QDFFRBN $PINS Q=Buffer/data_buffer[149] D=n1560
+ CK=CTS_34 RB=FE_OFN526_i_reset_n_i
XBuffer/data_buffer_reg[150] QDFFRBN $PINS Q=Buffer/data_buffer[150] D=n1559
+ CK=CTS_28 RB=FE_OFN767_i_reset_n_i
XBuffer/data_buffer_reg[151] QDFFRBN $PINS Q=Buffer/data_buffer[151] D=n1558
+ CK=CTS_28 RB=FE_OFN893_i_reset_n_i
XBuffer/data_buffer_reg[152] QDFFRBN $PINS Q=Buffer/data_buffer[152] D=n1557
+ CK=CTS_30 RB=FE_OFN675_i_reset_n_i
XBuffer/data_buffer_reg[153] QDFFRBN $PINS Q=Buffer/data_buffer[153] D=n1556
+ CK=CTS_26 RB=FE_OFN383_i_reset_n_i
XBuffer/data_buffer_reg[154] QDFFRBN $PINS Q=Buffer/data_buffer[154] D=n1555
+ CK=CTS_26 RB=FE_OFN980_i_reset_n_i
XBuffer/data_buffer_reg[155] QDFFRBN $PINS Q=Buffer/data_buffer[155] D=n1554
+ CK=CTS_26 RB=FE_OFN438_i_reset_n_i
XBuffer/data_buffer_reg[156] QDFFRBN $PINS Q=Buffer/data_buffer[156] D=n1553
+ CK=CTS_26 RB=FE_OFN1060_i_reset_n_i
XBuffer/data_buffer_reg[157] QDFFRBN $PINS Q=Buffer/data_buffer[157] D=n1552
+ CK=CTS_34 RB=FE_OFN1004_i_reset_n_i
XBuffer/data_buffer_reg[158] QDFFRBN $PINS Q=Buffer/data_buffer[158] D=n1551
+ CK=CTS_26 RB=FE_OFN1006_i_reset_n_i
XBuffer/data_buffer_reg[159] QDFFRBN $PINS Q=Buffer/data_buffer[159] D=n1550
+ CK=CTS_26 RB=FE_OFN980_i_reset_n_i
XBuffer/data_buffer_reg[160] QDFFRBN $PINS Q=Buffer/data_buffer[160] D=n1549
+ CK=CTS_18 RB=FE_OFN676_i_reset_n_i
XBuffer/data_buffer_reg[161] QDFFRBN $PINS Q=Buffer/data_buffer[161] D=n1548
+ CK=CTS_34 RB=FE_OFN935_i_reset_n_i
XBuffer/data_buffer_reg[162] QDFFRBN $PINS Q=Buffer/data_buffer[162] D=n1547
+ CK=CTS_34 RB=FE_OFN1061_i_reset_n_i
XBuffer/data_buffer_reg[163] QDFFRBN $PINS Q=Buffer/data_buffer[163] D=n1546
+ CK=CTS_26 RB=FE_OFN1060_i_reset_n_i
XBuffer/data_buffer_reg[164] QDFFRBN $PINS Q=Buffer/data_buffer[164] D=n1545
+ CK=CTS_34 RB=FE_OFN1092_i_reset_n_i
XBuffer/data_buffer_reg[165] QDFFRBN $PINS Q=Buffer/data_buffer[165] D=n1544
+ CK=CTS_34 RB=FE_OFN1061_i_reset_n_i
XBuffer/data_buffer_reg[166] QDFFRBN $PINS Q=Buffer/data_buffer[166] D=n1543
+ CK=CTS_34 RB=FE_OFN1092_i_reset_n_i
XBuffer/data_buffer_reg[167] QDFFRBN $PINS Q=Buffer/data_buffer[167] D=n1542
+ CK=CTS_34 RB=FE_OFN935_i_reset_n_i
XBuffer/data_buffer_reg[168] QDFFRBN $PINS Q=Buffer/data_buffer[168] D=n1541
+ CK=CTS_18 RB=FE_OFN556_i_reset_n_i
XBuffer/data_buffer_reg[169] QDFFRBN $PINS Q=Buffer/data_buffer[169] D=n1540
+ CK=CTS_34 RB=FE_OFN827_i_reset_n_i
XBuffer/data_buffer_reg[170] QDFFRBN $PINS Q=Buffer/data_buffer[170] D=n1539
+ CK=CTS_34 RB=FE_OFN569_i_reset_n_i
XBuffer/data_buffer_reg[171] QDFFRBN $PINS Q=Buffer/data_buffer[171] D=n1538
+ CK=CTS_34 RB=FE_OFN569_i_reset_n_i
XBuffer/data_buffer_reg[172] QDFFRBN $PINS Q=Buffer/data_buffer[172] D=n1537
+ CK=CTS_31 RB=FE_OFN832_i_reset_n_i
XBuffer/data_buffer_reg[173] QDFFRBN $PINS Q=Buffer/data_buffer[173] D=n1536
+ CK=CTS_31 RB=FE_OFN578_i_reset_n_i
XBuffer/data_buffer_reg[174] QDFFRBN $PINS Q=Buffer/data_buffer[174] D=n1535
+ CK=CTS_34 RB=FE_OFN1092_i_reset_n_i
XBuffer/data_buffer_reg[175] QDFFRBN $PINS Q=Buffer/data_buffer[175] D=n1534
+ CK=CTS_34 RB=FE_OFN825_i_reset_n_i
XBuffer/data_buffer_reg[176] QDFFRBN $PINS Q=Buffer/data_buffer[176] D=n1533
+ CK=CTS_18 RB=FE_OFN808_i_reset_n_i
XBuffer/data_buffer_reg[177] QDFFRBN $PINS Q=Buffer/data_buffer[177] D=n1532
+ CK=CTS_31 RB=FE_OFN700_i_reset_n_i
XBuffer/data_buffer_reg[178] QDFFRBN $PINS Q=Buffer/data_buffer[178] D=n1531
+ CK=CTS_31 RB=FE_OFN700_i_reset_n_i
XBuffer/data_buffer_reg[179] QDFFRBN $PINS Q=Buffer/data_buffer[179] D=n1530
+ CK=CTS_31 RB=FE_OFN700_i_reset_n_i
XBuffer/data_buffer_reg[180] QDFFRBN $PINS Q=Buffer/data_buffer[180] D=n1529
+ CK=CTS_3 RB=FE_OFN410_i_reset_n_i
XBuffer/data_buffer_reg[181] QDFFRBN $PINS Q=Buffer/data_buffer[181] D=n1528
+ CK=CTS_21 RB=FE_OFN577_i_reset_n_i
XBuffer/data_buffer_reg[182] QDFFRBN $PINS Q=Buffer/data_buffer[182] D=n1527
+ CK=CTS_3 RB=FE_OFN479_i_reset_n_i
XBuffer/data_buffer_reg[183] QDFFRBN $PINS Q=Buffer/data_buffer[183] D=n1526
+ CK=CTS_31 RB=FE_OFN700_i_reset_n_i
XBuffer/data_buffer_reg[184] QDFFRBN $PINS Q=Buffer/data_buffer[184] D=n1525
+ CK=CTS_18 RB=FE_OFN820_i_reset_n_i
XBuffer/data_buffer_reg[185] QDFFRBN $PINS Q=Buffer/data_buffer[185] D=n1524
+ CK=CTS_31 RB=FE_OFN461_i_reset_n_i
XBuffer/data_buffer_reg[186] QDFFRBN $PINS Q=Buffer/data_buffer[186] D=n1523
+ CK=CTS_31 RB=FE_OFN461_i_reset_n_i
XBuffer/data_buffer_reg[187] QDFFRBN $PINS Q=Buffer/data_buffer[187] D=n1522
+ CK=CTS_18 RB=FE_OFN398_i_reset_n_i
XBuffer/data_buffer_reg[188] QDFFRBN $PINS Q=Buffer/data_buffer[188] D=n1521
+ CK=CTS_21 RB=FE_OFN817_i_reset_n_i
XBuffer/data_buffer_reg[189] QDFFRBN $PINS Q=Buffer/data_buffer[189] D=n1520
+ CK=CTS_18 RB=FE_OFN817_i_reset_n_i
XBuffer/data_buffer_reg[190] QDFFRBN $PINS Q=Buffer/data_buffer[190] D=n1519
+ CK=CTS_18 RB=FE_OFN817_i_reset_n_i
XBuffer/data_buffer_reg[191] QDFFRBN $PINS Q=Buffer/data_buffer[191] D=n1518
+ CK=CTS_31 RB=FE_OFN398_i_reset_n_i
XBuffer/data_buffer_reg[192] QDFFRBN $PINS Q=Buffer/data_buffer[192] D=n1517
+ CK=CTS_18 RB=FE_OFN566_i_reset_n_i
XBuffer/data_buffer_reg[193] QDFFRBN $PINS Q=Buffer/data_buffer[193] D=n1516
+ CK=CTS_18 RB=FE_OFN676_i_reset_n_i
XBuffer/data_buffer_reg[194] QDFFRBN $PINS Q=Buffer/data_buffer[194] D=n1515
+ CK=CTS_30 RB=FE_OFN809_i_reset_n_i
XBuffer/data_buffer_reg[195] QDFFRBN $PINS Q=Buffer/data_buffer[195] D=n1514
+ CK=CTS_18 RB=FE_OFN808_i_reset_n_i
XBuffer/data_buffer_reg[196] QDFFRBN $PINS Q=Buffer/data_buffer[196] D=n1513
+ CK=CTS_18 RB=FE_OFN819_i_reset_n_i
XBuffer/data_buffer_reg[197] QDFFRBN $PINS Q=Buffer/data_buffer[197] D=n1512
+ CK=CTS_18 RB=FE_OFN688_i_reset_n_i
XBuffer/data_buffer_reg[198] QDFFRBN $PINS Q=Buffer/data_buffer[198] D=n1511
+ CK=CTS_18 RB=FE_OFN819_i_reset_n_i
XBuffer/data_buffer_reg[199] QDFFRBN $PINS Q=Buffer/data_buffer[199] D=n1510
+ CK=CTS_18 RB=FE_OFN676_i_reset_n_i
XBuffer/data_buffer_reg[200] QDFFRBN $PINS Q=Buffer/data_buffer[200] D=n1509
+ CK=CTS_16 RB=FE_OFN588_i_reset_n_i
XBuffer/data_buffer_reg[201] QDFFRBN $PINS Q=Buffer/data_buffer[201] D=n1508
+ CK=CTS_20 RB=FE_OFN865_i_reset_n_i
XBuffer/data_buffer_reg[202] QDFFRBN $PINS Q=Buffer/data_buffer[202] D=n1507
+ CK=CTS_20 RB=FE_OFN1013_i_reset_n_i
XBuffer/data_buffer_reg[203] QDFFRBN $PINS Q=Buffer/data_buffer[203] D=n1506
+ CK=CTS_20 RB=FE_OFN1013_i_reset_n_i
XBuffer/data_buffer_reg[204] QDFFRBN $PINS Q=Buffer/data_buffer[204] D=n1505
+ CK=CTS_20 RB=FE_OFN509_i_reset_n_i
XBuffer/data_buffer_reg[205] QDFFRBN $PINS Q=Buffer/data_buffer[205] D=n1504
+ CK=CTS_20 RB=FE_OFN428_i_reset_n_i
XBuffer/data_buffer_reg[206] QDFFRBN $PINS Q=Buffer/data_buffer[206] D=n1503
+ CK=CTS_20 RB=FE_OFN508_i_reset_n_i
XBuffer/data_buffer_reg[207] QDFFRBN $PINS Q=Buffer/data_buffer[207] D=n1502
+ CK=CTS_20 RB=FE_OFN865_i_reset_n_i
XBuffer/data_buffer_reg[208] QDFFRBN $PINS Q=Buffer/data_buffer[208] D=n1501
+ CK=CTS_12 RB=FE_OFN943_i_reset_n_i
XBuffer/data_buffer_reg[209] QDFFRBN $PINS Q=Buffer/data_buffer[209] D=n1500
+ CK=CTS_20 RB=FE_OFN508_i_reset_n_i
XBuffer/data_buffer_reg[210] QDFFRBN $PINS Q=Buffer/data_buffer[210] D=n1499
+ CK=CTS_20 RB=FE_OFN736_i_reset_n_i
XBuffer/data_buffer_reg[211] QDFFRBN $PINS Q=Buffer/data_buffer[211] D=n1498
+ CK=CTS_20 RB=FE_OFN607_i_reset_n_i
XBuffer/data_buffer_reg[212] QDFFRBN $PINS Q=Buffer/data_buffer[212] D=n1497
+ CK=CTS_20 RB=FE_OFN735_i_reset_n_i
XBuffer/data_buffer_reg[213] QDFFRBN $PINS Q=Buffer/data_buffer[213] D=n1496
+ CK=CTS_12 RB=FE_OFN838_i_reset_n_i
XBuffer/data_buffer_reg[214] QDFFRBN $PINS Q=Buffer/data_buffer[214] D=n1495
+ CK=CTS_20 RB=FE_OFN605_i_reset_n_i
XBuffer/data_buffer_reg[215] QDFFRBN $PINS Q=Buffer/data_buffer[215] D=n1494
+ CK=CTS_20 RB=FE_OFN736_i_reset_n_i
XBuffer/data_buffer_reg[216] QDFFRBN $PINS Q=Buffer/data_buffer[216] D=n1493
+ CK=CTS_12 RB=FE_OFN943_i_reset_n_i
XBuffer/data_buffer_reg[217] QDFFRBN $PINS Q=Buffer/data_buffer[217] D=n1492
+ CK=CTS_20 RB=FE_OFN605_i_reset_n_i
XBuffer/data_buffer_reg[218] QDFFRBN $PINS Q=Buffer/data_buffer[218] D=n1491
+ CK=CTS_24 RB=FE_OFN736_i_reset_n_i
XBuffer/data_buffer_reg[219] QDFFRBN $PINS Q=Buffer/data_buffer[219] D=n1490
+ CK=CTS_20 RB=FE_OFN606_i_reset_n_i
XBuffer/data_buffer_reg[220] QDFFRBN $PINS Q=Buffer/data_buffer[220] D=n1489
+ CK=CTS_55 RB=FE_OFN613_i_reset_n_i
XBuffer/data_buffer_reg[221] QDFFRBN $PINS Q=Buffer/data_buffer[221] D=n1488
+ CK=CTS_12 RB=FE_OFN612_i_reset_n_i
XBuffer/data_buffer_reg[222] QDFFRBN $PINS Q=Buffer/data_buffer[222] D=n1487
+ CK=CTS_20 RB=FE_OFN742_i_reset_n_i
XBuffer/data_buffer_reg[223] QDFFRBN $PINS Q=Buffer/data_buffer[223] D=n1486
+ CK=CTS_55 RB=FE_OFN1021_i_reset_n_i
XBuffer/data_buffer_reg[224] QDFFRBN $PINS Q=Buffer/data_buffer[224] D=n1485
+ CK=CTS_12 RB=FE_OFN584_i_reset_n_i
XBuffer/data_buffer_reg[225] QDFFRBN $PINS Q=Buffer/data_buffer[225] D=n1484
+ CK=CTS_12 RB=FE_OFN710_i_reset_n_i
XBuffer/data_buffer_reg[226] QDFFRBN $PINS Q=Buffer/data_buffer[226] D=n1483
+ CK=CTS_12 RB=FE_OFN512_i_reset_n_i
XBuffer/data_buffer_reg[227] QDFFRBN $PINS Q=Buffer/data_buffer[227] D=n1482
+ CK=CTS_12 RB=FE_OFN612_i_reset_n_i
XBuffer/data_buffer_reg[228] QDFFRBN $PINS Q=Buffer/data_buffer[228] D=n1481
+ CK=CTS_12 RB=FE_OFN613_i_reset_n_i
XBuffer/data_buffer_reg[229] QDFFRBN $PINS Q=Buffer/data_buffer[229] D=n1480
+ CK=CTS_12 RB=FE_OCPN9786_FE_OFN350_i_reset_n_i
XBuffer/data_buffer_reg[230] QDFFRBN $PINS Q=Buffer/data_buffer[230] D=n1479
+ CK=CTS_12 RB=FE_OFN612_i_reset_n_i
XBuffer/data_buffer_reg[231] QDFFRBN $PINS Q=Buffer/data_buffer[231] D=n1478
+ CK=CTS_12 RB=FE_OFN512_i_reset_n_i
XBuffer/data_buffer_reg[232] QDFFRBN $PINS Q=Buffer/data_buffer[232] D=n1477
+ CK=CTS_38 RB=FE_OFN582_i_reset_n_i
XBuffer/data_buffer_reg[233] QDFFRBN $PINS Q=Buffer/data_buffer[233] D=n1476
+ CK=CTS_12 RB=FE_OFN836_i_reset_n_i
XBuffer/data_buffer_reg[234] QDFFRBN $PINS Q=Buffer/data_buffer[234] D=n1475
+ CK=CTS_12 RB=FE_OFN513_i_reset_n_i
XBuffer/data_buffer_reg[235] QDFFRBN $PINS Q=Buffer/data_buffer[235] D=n1474
+ CK=CTS_38 RB=FE_OFN708_i_reset_n_i
XBuffer/data_buffer_reg[236] QDFFRBN $PINS Q=Buffer/data_buffer[236] D=n1473
+ CK=CTS_38 RB=FE_OFN841_i_reset_n_i
XBuffer/data_buffer_reg[237] QDFFRBN $PINS Q=Buffer/data_buffer[237] D=n1472
+ CK=CTS_38 RB=FE_OFN945_i_reset_n_i
XBuffer/data_buffer_reg[238] QDFFRBN $PINS Q=Buffer/data_buffer[238] D=n1471
+ CK=CTS_38 RB=FE_OFN945_i_reset_n_i
XBuffer/data_buffer_reg[239] QDFFRBN $PINS Q=Buffer/data_buffer[239] D=n1470
+ CK=CTS_38 RB=FE_OFN873_i_reset_n_i
XBuffer/data_buffer_reg[240] QDFFRBN $PINS Q=Buffer/data_buffer[240] D=n1469
+ CK=CTS_13 RB=FE_OFN415_i_reset_n_i
XBuffer/data_buffer_reg[241] QDFFRBN $PINS Q=Buffer/data_buffer[241] D=n1468
+ CK=CTS_38 RB=FE_OFN587_i_reset_n_i
XBuffer/data_buffer_reg[242] QDFFRBN $PINS Q=Buffer/data_buffer[242] D=n1467
+ CK=CTS_12 RB=FE_OFN708_i_reset_n_i
XBuffer/data_buffer_reg[243] QDFFRBN $PINS Q=Buffer/data_buffer[243] D=n1466
+ CK=CTS_38 RB=FE_OFN708_i_reset_n_i
XBuffer/data_buffer_reg[244] QDFFRBN $PINS Q=Buffer/data_buffer[244] D=n1465
+ CK=CTS_38 RB=FE_OFN587_i_reset_n_i
XBuffer/data_buffer_reg[245] QDFFRBN $PINS Q=Buffer/data_buffer[245] D=n1464
+ CK=CTS_38 RB=FE_OFN711_i_reset_n_i
XBuffer/data_buffer_reg[246] QDFFRBN $PINS Q=Buffer/data_buffer[246] D=n1463
+ CK=CTS_38 RB=FE_OFN841_i_reset_n_i
XBuffer/data_buffer_reg[247] QDFFRBN $PINS Q=Buffer/data_buffer[247] D=n1462
+ CK=CTS_38 RB=FE_OFN945_i_reset_n_i
XBuffer/data_buffer_reg[248] QDFFRBN $PINS Q=Buffer/data_buffer[248] D=n1461
+ CK=CTS_38 RB=FE_OFN485_i_reset_n_i
XBuffer/data_buffer_reg[249] QDFFRBN $PINS Q=Buffer/data_buffer[249] D=n1460
+ CK=CTS_38 RB=FE_OFN486_i_reset_n_i
XBuffer/data_buffer_reg[250] QDFFRBN $PINS Q=Buffer/data_buffer[250] D=n1459
+ CK=CTS_12 RB=FE_OFN709_i_reset_n_i
XBuffer/data_buffer_reg[251] QDFFRBN $PINS Q=Buffer/data_buffer[251] D=n1458
+ CK=CTS_38 RB=FE_OFN486_i_reset_n_i
XBuffer/data_buffer_reg[252] QDFFRBN $PINS Q=Buffer/data_buffer[252] D=n1457
+ CK=CTS_38 RB=FE_OFN587_i_reset_n_i
XBuffer/data_buffer_reg[253] QDFFRBN $PINS Q=Buffer/data_buffer[253] D=n1456
+ CK=CTS_38 RB=FE_OFN839_i_reset_n_i
XBuffer/data_buffer_reg[254] QDFFRBN $PINS Q=Buffer/data_buffer[254] D=n1455
+ CK=CTS_38 RB=FE_OFN587_i_reset_n_i
XBuffer/data_buffer_reg[255] QDFFRBN $PINS Q=Buffer/data_buffer[255] D=n1454
+ CK=CTS_38 RB=FE_OFN587_i_reset_n_i
XBuffer/data_buffer_reg[256] QDFFRBN $PINS Q=Buffer/data_buffer[256] D=n1453
+ CK=CTS_39 RB=FE_OFN367_i_reset_n_i
XBuffer/data_buffer_reg[257] QDFFRBN $PINS Q=Buffer/data_buffer[257] D=n1452
+ CK=CTS_38 RB=FE_OFN484_i_reset_n_i
XBuffer/data_buffer_reg[258] QDFFRBN $PINS Q=Buffer/data_buffer[258] D=n1451
+ CK=CTS_12 RB=FE_OFN709_i_reset_n_i
XBuffer/data_buffer_reg[259] QDFFRBN $PINS Q=Buffer/data_buffer[259] D=n1450
+ CK=CTS_38 RB=FE_OFN484_i_reset_n_i
XBuffer/data_buffer_reg[260] QDFFRBN $PINS Q=Buffer/data_buffer[260] D=n1449
+ CK=CTS_38 RB=FE_OFN586_i_reset_n_i
XBuffer/data_buffer_reg[261] QDFFRBN $PINS Q=Buffer/data_buffer[261] D=n1448
+ CK=CTS_38 RB=FE_OFN485_i_reset_n_i
XBuffer/data_buffer_reg[262] QDFFRBN $PINS Q=Buffer/data_buffer[262] D=n1447
+ CK=CTS_38 RB=FE_OFN586_i_reset_n_i
XBuffer/data_buffer_reg[263] QDFFRBN $PINS Q=Buffer/data_buffer[263] D=n1446
+ CK=CTS_38 RB=FE_OFN708_i_reset_n_i
XBuffer/data_buffer_reg[264] QDFFRBN $PINS Q=Buffer/data_buffer[264] D=n1445
+ CK=CTS_39 RB=FE_OFN489_i_reset_n_i
XBuffer/data_buffer_reg[265] QDFFRBN $PINS Q=Buffer/data_buffer[265] D=n1444
+ CK=CTS_13 RB=FE_OFN415_i_reset_n_i
XBuffer/data_buffer_reg[266] QDFFRBN $PINS Q=Buffer/data_buffer[266] D=n1443
+ CK=CTS_12 RB=FE_OFN710_i_reset_n_i
XBuffer/data_buffer_reg[267] QDFFRBN $PINS Q=Buffer/data_buffer[267] D=n1442
+ CK=CTS_38 RB=FE_OFN484_i_reset_n_i
XBuffer/data_buffer_reg[268] QDFFRBN $PINS Q=Buffer/data_buffer[268] D=n1441
+ CK=CTS_13 RB=FE_OFN415_i_reset_n_i
XBuffer/data_buffer_reg[269] QDFFRBN $PINS Q=Buffer/data_buffer[269] D=n1440
+ CK=CTS_38 RB=FE_OFN485_i_reset_n_i
XBuffer/data_buffer_reg[270] QDFFRBN $PINS Q=Buffer/data_buffer[270] D=n1439
+ CK=CTS_38 RB=FE_OFN486_i_reset_n_i
XBuffer/data_buffer_reg[271] QDFFRBN $PINS Q=Buffer/data_buffer[271] D=n1438
+ CK=CTS_12 RB=FE_OFN584_i_reset_n_i
XBuffer/data_buffer_reg[272] QDFFRBN $PINS Q=Buffer/data_buffer[272] D=n1437
+ CK=CTS_39 RB=FE_OFN715_i_reset_n_i
XBuffer/data_buffer_reg[273] QDFFRBN $PINS Q=Buffer/data_buffer[273] D=n1436
+ CK=CTS_13 RB=FE_OFN716_i_reset_n_i
XBuffer/data_buffer_reg[274] QDFFRBN $PINS Q=Buffer/data_buffer[274] D=n1435
+ CK=CTS_12 RB=FE_OFN943_i_reset_n_i
XBuffer/data_buffer_reg[275] QDFFRBN $PINS Q=Buffer/data_buffer[275] D=n1434
+ CK=CTS_13 RB=FE_OFN367_i_reset_n_i
XBuffer/data_buffer_reg[276] QDFFRBN $PINS Q=Buffer/data_buffer[276] D=n1433
+ CK=CTS_13 RB=FE_OFN591_i_reset_n_i
XBuffer/data_buffer_reg[277] QDFFRBN $PINS Q=Buffer/data_buffer[277] D=n1432
+ CK=CTS_13 RB=FE_OFN591_i_reset_n_i
XBuffer/data_buffer_reg[278] QDFFRBN $PINS Q=Buffer/data_buffer[278] D=n1431
+ CK=CTS_12 RB=FE_OFN710_i_reset_n_i
XBuffer/data_buffer_reg[279] QDFFRBN $PINS Q=Buffer/data_buffer[279] D=n1430
+ CK=CTS_12 RB=FE_OFN837_i_reset_n_i
XBuffer/data_buffer_reg[280] QDFFRBN $PINS Q=Buffer/data_buffer[280] D=n1429
+ CK=CTS_13 RB=FE_OFN591_i_reset_n_i
XBuffer/data_buffer_reg[281] QDFFRBN $PINS Q=Buffer/data_buffer[281] D=n1428
+ CK=CTS_13 RB=FE_OFN845_i_reset_n_i
XBuffer/data_buffer_reg[282] QDFFRBN $PINS Q=Buffer/data_buffer[282] D=n1427
+ CK=CTS_12 RB=FE_OFN943_i_reset_n_i
XBuffer/data_buffer_reg[283] QDFFRBN $PINS Q=Buffer/data_buffer[283] D=n1426
+ CK=CTS_13 RB=FE_OFN845_i_reset_n_i
XBuffer/data_buffer_reg[284] QDFFRBN $PINS Q=Buffer/data_buffer[284] D=n1425
+ CK=CTS_13 RB=FE_OFN716_i_reset_n_i
XBuffer/data_buffer_reg[285] QDFFRBN $PINS Q=Buffer/data_buffer[285] D=n1424
+ CK=CTS_13 RB=FE_OFN716_i_reset_n_i
XBuffer/data_buffer_reg[286] QDFFRBN $PINS Q=Buffer/data_buffer[286] D=n1423
+ CK=CTS_12 RB=FE_OFN837_i_reset_n_i
XBuffer/data_buffer_reg[287] QDFFRBN $PINS Q=Buffer/data_buffer[287] D=n1422
+ CK=CTS_12 RB=FE_OFN943_i_reset_n_i
XBuffer/data_buffer_reg[288] QDFFRBN $PINS Q=Buffer/data_buffer[288] D=n1421
+ CK=CTS_39 RB=FE_OFN715_i_reset_n_i
XBuffer/data_buffer_reg[289] QDFFRBN $PINS Q=Buffer/data_buffer[289] D=n1420
+ CK=CTS_12 RB=FE_OFN714_i_reset_n_i
XBuffer/data_buffer_reg[290] QDFFRBN $PINS Q=Buffer/data_buffer[290] D=n1419
+ CK=CTS_16 RB=FE_OFN713_i_reset_n_i
XBuffer/data_buffer_reg[291] QDFFRBN $PINS Q=Buffer/data_buffer[291] D=n1418
+ CK=CTS_16 RB=FE_OFN714_i_reset_n_i
XBuffer/data_buffer_reg[292] QDFFRBN $PINS Q=Buffer/data_buffer[292] D=n1417
+ CK=CTS_16 RB=FE_OFN844_i_reset_n_i
XBuffer/data_buffer_reg[293] QDFFRBN $PINS Q=Buffer/data_buffer[293] D=n1416
+ CK=CTS_16 RB=FE_OFN844_i_reset_n_i
XBuffer/data_buffer_reg[294] QDFFRBN $PINS Q=Buffer/data_buffer[294] D=n1415
+ CK=CTS_12 RB=FE_OFN944_i_reset_n_i
XBuffer/data_buffer_reg[295] QDFFRBN $PINS Q=Buffer/data_buffer[295] D=n1414
+ CK=CTS_16 RB=FE_OFN842_i_reset_n_i
XBuffer/data_buffer_reg[296] QDFFRBN $PINS Q=Buffer/data_buffer[296] D=n1413
+ CK=CTS_39 RB=FE_OFN846_i_reset_n_i
XBuffer/data_buffer_reg[297] QDFFRBN $PINS Q=Buffer/data_buffer[297] D=n1412
+ CK=CTS_16 RB=FE_OFN842_i_reset_n_i
XBuffer/data_buffer_reg[298] QDFFRBN $PINS Q=Buffer/data_buffer[298] D=n1411
+ CK=CTS_16 RB=FE_OFN492_i_reset_n_i
XBuffer/data_buffer_reg[299] QDFFRBN $PINS Q=Buffer/data_buffer[299] D=n1410
+ CK=CTS_16 RB=FE_OFN842_i_reset_n_i
XBuffer/data_buffer_reg[300] QDFFRBN $PINS Q=Buffer/data_buffer[300] D=n1409
+ CK=CTS_16 RB=FE_OFN590_i_reset_n_i
XBuffer/data_buffer_reg[301] QDFFRBN $PINS Q=Buffer/data_buffer[301] D=n1408
+ CK=CTS_16 RB=FE_OFN713_i_reset_n_i
XBuffer/data_buffer_reg[302] QDFFRBN $PINS Q=Buffer/data_buffer[302] D=n1407
+ CK=CTS_16 RB=FE_OFN717_i_reset_n_i
XBuffer/data_buffer_reg[303] QDFFRBN $PINS Q=Buffer/data_buffer[303] D=n1406
+ CK=CTS_16 RB=FE_OFN717_i_reset_n_i
XBuffer/data_buffer_reg[304] QDFFRBN $PINS Q=Buffer/data_buffer[304] D=n1405
+ CK=CTS_13 RB=FE_OFN846_i_reset_n_i
XBuffer/data_buffer_reg[305] QDFFRBN $PINS Q=Buffer/data_buffer[305] D=n1404
+ CK=CTS_30 RB=FE_OFN594_i_reset_n_i
XBuffer/data_buffer_reg[306] QDFFRBN $PINS Q=Buffer/data_buffer[306] D=n1403
+ CK=CTS_30 RB=FE_OFN719_i_reset_n_i
XBuffer/data_buffer_reg[307] QDFFRBN $PINS Q=Buffer/data_buffer[307] D=n1402
+ CK=CTS_30 RB=FE_OFN594_i_reset_n_i
XBuffer/data_buffer_reg[308] QDFFRBN $PINS Q=Buffer/data_buffer[308] D=n1401
+ CK=CTS_30 RB=FE_OFN594_i_reset_n_i
XBuffer/data_buffer_reg[309] QDFFRBN $PINS Q=Buffer/data_buffer[309] D=n1400
+ CK=CTS_16 RB=FE_OFN492_i_reset_n_i
XBuffer/data_buffer_reg[310] QDFFRBN $PINS Q=Buffer/data_buffer[310] D=n1399
+ CK=CTS_30 RB=FE_OFN719_i_reset_n_i
XBuffer/data_buffer_reg[311] QDFFRBN $PINS Q=Buffer/data_buffer[311] D=n1398
+ CK=CTS_30 RB=FE_OFN719_i_reset_n_i
XBuffer/data_buffer_reg[312] QDFFRBN $PINS Q=Buffer/data_buffer[312] D=n1397
+ CK=CTS_13 RB=FE_OFN416_i_reset_n_i
XBuffer/data_buffer_reg[313] QDFFRBN $PINS Q=Buffer/data_buffer[313] D=n1396
+ CK=CTS_30 RB=FE_OFN849_i_reset_n_i
XBuffer/data_buffer_reg[314] QDFFRBN $PINS Q=Buffer/data_buffer[314] D=n1395
+ CK=CTS_30 RB=FE_OFN947_i_reset_n_i
XBuffer/data_buffer_reg[315] QDFFRBN $PINS Q=Buffer/data_buffer[315] D=n1394
+ CK=CTS_30 RB=FE_OFN720_i_reset_n_i
XBuffer/data_buffer_reg[316] QDFFRBN $PINS Q=Buffer/data_buffer[316] D=n1393
+ CK=CTS_30 RB=FE_OFN720_i_reset_n_i
XBuffer/data_buffer_reg[317] QDFFRBN $PINS Q=Buffer/data_buffer[317] D=n1392
+ CK=CTS_30 RB=FE_OFN719_i_reset_n_i
XBuffer/data_buffer_reg[318] QDFFRBN $PINS Q=Buffer/data_buffer[318] D=n1391
+ CK=CTS_20 RB=FE_OFN947_i_reset_n_i
XBuffer/data_buffer_reg[319] QDFFRBN $PINS Q=Buffer/data_buffer[319] D=n1390
+ CK=CTS_30 RB=FE_OFN849_i_reset_n_i
XBuffer/data_buffer_reg[320] QDFFRBN $PINS Q=Buffer/data_buffer[320] D=n1389
+ CK=CTS_16 RB=FE_OFN487_i_reset_n_i
XBuffer/data_buffer_reg[321] QDFFRBN $PINS Q=Buffer/data_buffer[321] D=n1388
+ CK=CTS_30 RB=FE_OFN849_i_reset_n_i
XBuffer/data_buffer_reg[322] QDFFRBN $PINS Q=Buffer/data_buffer[322] D=n1387
+ CK=CTS_30 RB=FE_OFN849_i_reset_n_i
XBuffer/data_buffer_reg[323] QDFFRBN $PINS Q=Buffer/data_buffer[323] D=n1386
+ CK=CTS_33 RB=FE_OFN399_i_reset_n_i
XBuffer/data_buffer_reg[324] QDFFRBN $PINS Q=Buffer/data_buffer[324] D=n1385
+ CK=CTS_30 RB=FE_OFN848_i_reset_n_i
XBuffer/data_buffer_reg[325] QDFFRBN $PINS Q=Buffer/data_buffer[325] D=n1384
+ CK=CTS_30 RB=FE_OFN849_i_reset_n_i
XBuffer/data_buffer_reg[326] QDFFRBN $PINS Q=Buffer/data_buffer[326] D=n1383
+ CK=CTS_20 RB=FE_OFN463_i_reset_n_i
XBuffer/data_buffer_reg[327] QDFFRBN $PINS Q=Buffer/data_buffer[327] D=n1382
+ CK=CTS_33 RB=FE_OFN463_i_reset_n_i
XBuffer/data_buffer_reg[328] QDFFRBN $PINS Q=Buffer/data_buffer[328] D=n1381
+ CK=CTS_16 RB=FE_OFN493_i_reset_n_i
XBuffer/data_buffer_reg[329] QDFFRBN $PINS Q=Buffer/data_buffer[329] D=n1380
+ CK=CTS_33 RB=FE_OFN678_i_reset_n_i
XBuffer/data_buffer_reg[330] QDFFRBN $PINS Q=Buffer/data_buffer[330] D=n1379
+ CK=CTS_20 RB=FE_OFN559_i_reset_n_i
XBuffer/data_buffer_reg[331] QDFFRBN $PINS Q=Buffer/data_buffer[331] D=n1378
+ CK=CTS_33 RB=FE_OFN678_i_reset_n_i
XBuffer/data_buffer_reg[332] QDFFRBN $PINS Q=Buffer/data_buffer[332] D=n1377
+ CK=CTS_30 RB=FE_OFN399_i_reset_n_i
XBuffer/data_buffer_reg[333] QDFFRBN $PINS Q=Buffer/data_buffer[333] D=n1376
+ CK=CTS_30 RB=FE_OFN848_i_reset_n_i
XBuffer/data_buffer_reg[334] QDFFRBN $PINS Q=Buffer/data_buffer[334] D=n1375
+ CK=CTS_33 RB=FE_OFN677_i_reset_n_i
XBuffer/data_buffer_reg[335] QDFFRBN $PINS Q=Buffer/data_buffer[335] D=n1374
+ CK=CTS_33 RB=FE_OFN559_i_reset_n_i
XBuffer/data_buffer_reg[336] QDFFRBN $PINS Q=Buffer/data_buffer[336] D=n1373
+ CK=CTS_30 RB=FE_OFN494_i_reset_n_i
XBuffer/data_buffer_reg[337] QDFFRBN $PINS Q=Buffer/data_buffer[337] D=n1372
+ CK=CTS_33 RB=FE_OFN678_i_reset_n_i
XBuffer/data_buffer_reg[338] QDFFRBN $PINS Q=Buffer/data_buffer[338] D=n1371
+ CK=CTS_33 RB=FE_OFN677_i_reset_n_i
XBuffer/data_buffer_reg[339] QDFFRBN $PINS Q=Buffer/data_buffer[339] D=n1370
+ CK=CTS_33 RB=FE_OFN996_i_reset_n_i
XBuffer/data_buffer_reg[340] QDFFRBN $PINS Q=Buffer/data_buffer[340] D=n1369
+ CK=CTS_33 RB=FE_OFN678_i_reset_n_i
XBuffer/data_buffer_reg[341] QDFFRBN $PINS Q=Buffer/data_buffer[341] D=n1368
+ CK=CTS_33 RB=FE_OFN814_i_reset_n_i
XBuffer/data_buffer_reg[342] QDFFRBN $PINS Q=Buffer/data_buffer[342] D=n1367
+ CK=CTS_33 RB=FE_OFN678_i_reset_n_i
XBuffer/data_buffer_reg[343] QDFFRBN $PINS Q=Buffer/data_buffer[343] D=n1366
+ CK=CTS_33 RB=FE_OFN677_i_reset_n_i
XBuffer/data_buffer_reg[344] QDFFRBN $PINS Q=Buffer/data_buffer[344] D=n1365
+ CK=CTS_30 RB=FE_OFN847_i_reset_n_i
XBuffer/data_buffer_reg[345] QDFFRBN $PINS Q=Buffer/data_buffer[345] D=n1364
+ CK=CTS_33 RB=FE_OFN996_i_reset_n_i
XBuffer/data_buffer_reg[346] QDFFRBN $PINS Q=Buffer/data_buffer[346] D=n1363
+ CK=CTS_25 RB=FE_OFN999_i_reset_n_i
XBuffer/data_buffer_reg[347] QDFFRBN $PINS Q=Buffer/data_buffer[347] D=n1362
+ CK=CTS_25 RB=FE_OFN441_i_reset_n_i
XBuffer/data_buffer_reg[348] QDFFRBN $PINS Q=Buffer/data_buffer[348] D=n1361
+ CK=CTS_33 RB=FE_OFN811_i_reset_n_i
XBuffer/data_buffer_reg[349] QDFFRBN $PINS Q=Buffer/data_buffer[349] D=n1360
+ CK=CTS_33 RB=FE_OFN811_i_reset_n_i
XBuffer/data_buffer_reg[350] QDFFRBN $PINS Q=Buffer/data_buffer[350] D=n1359
+ CK=CTS_25 RB=FE_OFN999_i_reset_n_i
XBuffer/data_buffer_reg[351] QDFFRBN $PINS Q=Buffer/data_buffer[351] D=n1358
+ CK=CTS_25 RB=FE_OFN930_i_reset_n_i
XBuffer/data_buffer_reg[352] QDFFRBN $PINS Q=Buffer/data_buffer[352] D=n1357
+ CK=CTS_30 RB=FE_OFN928_i_reset_n_i
XBuffer/data_buffer_reg[353] QDFFRBN $PINS Q=Buffer/data_buffer[353] D=n1356
+ CK=CTS_25 RB=FE_OFN442_i_reset_n_i
XBuffer/data_buffer_reg[354] QDFFRBN $PINS Q=Buffer/data_buffer[354] D=n1355
+ CK=CTS_25 RB=FE_OFN768_i_reset_n_i
XBuffer/data_buffer_reg[355] QDFFRBN $PINS Q=Buffer/data_buffer[355] D=n1354
+ CK=CTS_25 RB=FE_OFN527_i_reset_n_i
XBuffer/data_buffer_reg[356] QDFFRBN $PINS Q=Buffer/data_buffer[356] D=n1353
+ CK=CTS_33 RB=FE_OFN384_i_reset_n_i
XBuffer/data_buffer_reg[357] QDFFRBN $PINS Q=Buffer/data_buffer[357] D=n1352
+ CK=CTS_25 RB=FE_OFN440_i_reset_n_i
XBuffer/data_buffer_reg[358] QDFFRBN $PINS Q=Buffer/data_buffer[358] D=n1351
+ CK=CTS_25 RB=FE_OFN641_i_reset_n_i
XBuffer/data_buffer_reg[359] QDFFRBN $PINS Q=Buffer/data_buffer[359] D=n1350
+ CK=CTS_25 RB=FE_OFN531_i_reset_n_i
XBuffer/data_buffer_reg[360] QDFFRBN $PINS Q=Buffer/data_buffer[360] D=n1349
+ CK=CTS_30 RB=FE_OFN929_i_reset_n_i
XBuffer/data_buffer_reg[361] QDFFRBN $PINS Q=Buffer/data_buffer[361] D=n1348
+ CK=CTS_25 RB=FE_OFN444_i_reset_n_i
XBuffer/data_buffer_reg[362] QDFFRBN $PINS Q=Buffer/data_buffer[362] D=n1347
+ CK=CTS_28 RB=FE_OFN444_i_reset_n_i
XBuffer/data_buffer_reg[363] QDFFRBN $PINS Q=Buffer/data_buffer[363] D=n1346
+ CK=CTS_25 RB=FE_OFN640_i_reset_n_i
XBuffer/data_buffer_reg[364] QDFFRBN $PINS Q=Buffer/data_buffer[364] D=n1345
+ CK=CTS_34 RB=FE_OFN526_i_reset_n_i
XBuffer/data_buffer_reg[365] QDFFRBN $PINS Q=Buffer/data_buffer[365] D=n1344
+ CK=CTS_25 RB=FE_OFN527_i_reset_n_i
XBuffer/data_buffer_reg[366] QDFFRBN $PINS Q=Buffer/data_buffer[366] D=n1343
+ CK=CTS_28 RB=FE_OFN529_i_reset_n_i
XBuffer/data_buffer_reg[367] QDFFRBN $PINS Q=Buffer/data_buffer[367] D=n1342
+ CK=CTS_28 RB=FE_OFN642_i_reset_n_i
XBuffer/data_buffer_reg[368] QDFFRBN $PINS Q=Buffer/data_buffer[368] D=n1341
+ CK=CTS_30 RB=FE_OFN675_i_reset_n_i
XBuffer/data_buffer_reg[369] QDFFRBN $PINS Q=Buffer/data_buffer[369] D=n1340
+ CK=CTS_28 RB=FE_OFN638_i_reset_n_i
Xdata_0_r_reg[1] QDFFRBN $PINS Q=data_0_r[1] D=n1711 CK=CTS_29
+ RB=FE_OFN829_i_reset_n_i
XBuffer/data_buffer_reg[370] QDFFRBN $PINS Q=Buffer/data_buffer[370] D=n1339
+ CK=CTS_28 RB=FE_OFN529_i_reset_n_i
XBuffer/data_buffer_reg[371] QDFFRBN $PINS Q=Buffer/data_buffer[371] D=n1338
+ CK=CTS_28 RB=FE_OFN525_i_reset_n_i
XBuffer/data_buffer_reg[372] QDFFRBN $PINS Q=Buffer/data_buffer[372] D=n1337
+ CK=CTS_34 RB=FE_OFN637_i_reset_n_i
XBuffer/data_buffer_reg[373] QDFFRBN $PINS Q=Buffer/data_buffer[373] D=n1336
+ CK=CTS_34 RB=FE_OFN382_i_reset_n_i
XBuffer/data_buffer_reg[374] QDFFRBN $PINS Q=Buffer/data_buffer[374] D=n1335
+ CK=CTS_28 RB=FE_OFN639_i_reset_n_i
Xdata_0_r_reg[6] QDFFRBN $PINS Q=data_0_r[6] D=n1716 CK=CTS_29
+ RB=FE_OFN936_i_reset_n_i
XBuffer/data_buffer_reg[375] QDFFRBN $PINS Q=Buffer/data_buffer[375] D=n1334
+ CK=CTS_28 RB=FE_OFN893_i_reset_n_i
XBuffer/data_buffer_reg[376] QDFFRBN $PINS Q=Buffer/data_buffer[376] D=n1333
+ CK=CTS_30 RB=FE_OFN675_i_reset_n_i
Xdata_0_r_reg[8] QDFFRBN $PINS Q=data_0_r[8] D=n1718 CK=CTS_29
+ RB=FE_OFN1007_i_reset_n_i
XBuffer/data_buffer_reg[377] QDFFRBN $PINS Q=Buffer/data_buffer[377] D=n1332
+ CK=CTS_26 RB=FE_OFN438_i_reset_n_i
Xdata_0_r_reg[9] QDFFRBN $PINS Q=data_0_r[9] D=n1719 CK=CTS_29
+ RB=FE_OFN1007_i_reset_n_i
XBuffer/data_buffer_reg[378] QDFFRBN $PINS Q=Buffer/data_buffer[378] D=n1331
+ CK=CTS_26 RB=FE_OFN980_i_reset_n_i
Xdata_0_r_reg[10] QDFFRBN $PINS Q=data_0_r[10] D=n1720 CK=CTS_29
+ RB=FE_OFN936_i_reset_n_i
XBuffer/data_buffer_reg[379] QDFFRBN $PINS Q=Buffer/data_buffer[379] D=n1330
+ CK=CTS_26 RB=FE_OFN438_i_reset_n_i
Xdata_0_r_reg[11] QDFFRBN $PINS Q=data_0_r[11] D=n1721 CK=CTS_29
+ RB=FE_OFN936_i_reset_n_i
XBuffer/data_buffer_reg[380] QDFFRBN $PINS Q=Buffer/data_buffer[380] D=n1329
+ CK=CTS_26 RB=FE_OFN1060_i_reset_n_i
Xdata_0_r_reg[12] QDFFRBN $PINS Q=data_0_r[12] D=n1722 CK=CTS_26
+ RB=FE_OFN699_i_reset_n_i
XBuffer/data_buffer_reg[381] QDFFRBN $PINS Q=Buffer/data_buffer[381] D=n1328
+ CK=CTS_34 RB=FE_OFN382_i_reset_n_i
Xdata_0_r_reg[13] QDFFRBN $PINS Q=data_0_r[13] D=n1723 CK=CTS_29
+ RB=FE_OFN829_i_reset_n_i
XBuffer/data_buffer_reg[382] QDFFRBN $PINS Q=Buffer/data_buffer[382] D=n1327
+ CK=CTS_26 RB=FE_OFN1054_i_reset_n_i
Xdata_0_r_reg[14] QDFFRBN $PINS Q=data_0_r[14] D=n1724 CK=CTS_26
+ RB=FE_OFN936_i_reset_n_i
XBuffer/data_buffer_reg[383] QDFFRBN $PINS Q=Buffer/data_buffer[383] D=n1326
+ CK=CTS_26 RB=FE_OFN894_i_reset_n_i
Xdata_0_r_reg[15] QDFFRBP $PINS Q=data_0_r[15] D=n1725 CK=CTS_26
+ RB=FE_OFN936_i_reset_n_i
XBuffer/data_buffer_reg[384] QDFFRBN $PINS Q=Buffer/data_buffer[384] D=n1325
+ CK=CTS_31 RB=FE_OFN557_i_reset_n_i
XBuffer/data_buffer_reg[385] QDFFRBN $PINS Q=Buffer/data_buffer[385] D=n1324
+ CK=CTS_26 RB=FE_OFN382_i_reset_n_i
XBuffer/data_buffer_reg[386] QDFFRBN $PINS Q=Buffer/data_buffer[386] D=n1323
+ CK=CTS_34 RB=FE_OFN935_i_reset_n_i
XBuffer/data_buffer_reg[387] QDFFRBN $PINS Q=Buffer/data_buffer[387] D=n1322
+ CK=CTS_34 RB=FE_OFN1061_i_reset_n_i
XBuffer/data_buffer_reg[388] QDFFRBN $PINS Q=Buffer/data_buffer[388] D=n1321
+ CK=CTS_34 RB=FE_OFN1092_i_reset_n_i
XBuffer/data_buffer_reg[389] QDFFRBN $PINS Q=Buffer/data_buffer[389] D=n1320
+ CK=CTS_34 RB=FE_OFN1061_i_reset_n_i
XBuffer/data_buffer_reg[390] QDFFRBN $PINS Q=Buffer/data_buffer[390] D=n1319
+ CK=CTS_26 RB=FE_OFN1060_i_reset_n_i
XBuffer/data_buffer_reg[391] QDFFRBN $PINS Q=Buffer/data_buffer[391] D=n1318
+ CK=CTS_34 RB=FE_OFN935_i_reset_n_i
XBuffer/data_buffer_reg[392] QDFFRBN $PINS Q=Buffer/data_buffer[392] D=n1317
+ CK=CTS_18 RB=FE_OFN556_i_reset_n_i
Xdata_0_r_reg[24] QDFFRBN $PINS Q=data_0_r[24] D=n1733 CK=CTS_21
+ RB=FE_OFN364_i_reset_n_i
XBuffer/data_buffer_reg[393] QDFFRBN $PINS Q=Buffer/data_buffer[393] D=n1316
+ CK=CTS_34 RB=FE_OFN825_i_reset_n_i
XBuffer/data_buffer_reg[394] QDFFRBN $PINS Q=Buffer/data_buffer[394] D=n1315
+ CK=CTS_31 RB=FE_OFN702_i_reset_n_i
Xdata_0_r_reg[26] QDFFRBN $PINS Q=data_0_r[26] D=n1735 CK=CTS_3
+ RB=FE_OFN412_i_reset_n_i
XBuffer/data_buffer_reg[395] QDFFRBN $PINS Q=Buffer/data_buffer[395] D=n1314
+ CK=CTS_31 RB=FE_OFN702_i_reset_n_i
Xdata_0_r_reg[27] QDFFRBN $PINS Q=data_0_r[27] D=n1736 CK=CTS_3
+ RB=FE_OFN412_i_reset_n_i
XBuffer/data_buffer_reg[396] QDFFRBN $PINS Q=Buffer/data_buffer[396] D=n1313
+ CK=CTS_31 RB=FE_OFN832_i_reset_n_i
Xdata_0_r_reg[28] QDFFRBN $PINS Q=data_0_r[28] D=n1737 CK=CTS_3
+ RB=FE_OFN412_i_reset_n_i
XBuffer/data_buffer_reg[397] QDFFRBN $PINS Q=Buffer/data_buffer[397] D=n1312
+ CK=CTS_3 RB=FE_OFN831_i_reset_n_i
Xdata_0_r_reg[29] QDFFRBN $PINS Q=data_0_r[29] D=n1738 CK=CTS_3
+ RB=FE_OFN412_i_reset_n_i
XBuffer/data_buffer_reg[398] QDFFRBN $PINS Q=Buffer/data_buffer[398] D=n1311
+ CK=CTS_34 RB=FE_OFN471_i_reset_n_i
Xdata_0_r_reg[30] QDFFRBN $PINS Q=data_0_r[30] D=n1739 CK=CTS_3
+ RB=FE_OFN939_i_reset_n_i
XBuffer/data_buffer_reg[399] QDFFRBN $PINS Q=Buffer/data_buffer[399] D=n1310
+ CK=CTS_31 RB=FE_OFN830_i_reset_n_i
Xdata_0_r_reg[31] QDFFRBN $PINS Q=data_0_r[31] D=n1740 CK=CTS_3
+ RB=FE_OFN939_i_reset_n_i
XBuffer/data_buffer_reg[400] QDFFRBN $PINS Q=Buffer/data_buffer[400] D=n1309
+ CK=CTS_18 RB=FE_OFN556_i_reset_n_i
XBuffer/data_buffer_reg[401] QDFFRBN $PINS Q=Buffer/data_buffer[401] D=n1308
+ CK=CTS_31 RB=FE_OFN701_i_reset_n_i
Xdata_0_r_reg[33] QDFFRBN $PINS Q=data_0_r[33] D=n1741 CK=CTS_3
+ RB=FE_OFN364_i_reset_n_i
XBuffer/data_buffer_reg[402] QDFFRBN $PINS Q=Buffer/data_buffer[402] D=n1307
+ CK=CTS_31 RB=FE_OFN578_i_reset_n_i
XBuffer/data_buffer_reg[403] QDFFRBN $PINS Q=Buffer/data_buffer[403] D=n1306
+ CK=CTS_31 RB=FE_OFN479_i_reset_n_i
XBuffer/data_buffer_reg[404] QDFFRBN $PINS Q=Buffer/data_buffer[404] D=n1305
+ CK=CTS_3 RB=FE_OFN479_i_reset_n_i
XBuffer/data_buffer_reg[405] QDFFRBN $PINS Q=Buffer/data_buffer[405] D=n1304
+ CK=CTS_21 RB=FE_OFN410_i_reset_n_i
Xdata_0_r_reg[37] QDFFRBN $PINS Q=data_0_r[37] D=n1745 CK=CTS_21
+ RB=FE_OFN364_i_reset_n_i
XBuffer/data_buffer_reg[406] QDFFRBN $PINS Q=Buffer/data_buffer[406] D=n1303
+ CK=CTS_3 RB=FE_OFN831_i_reset_n_i
Xdata_0_r_reg[38] QDFFRBN $PINS Q=data_0_r[38] D=n1746 CK=CTS_3
+ RB=FE_OFN364_i_reset_n_i
XBuffer/data_buffer_reg[407] QDFFRBN $PINS Q=Buffer/data_buffer[407] D=n1302
+ CK=CTS_31 RB=FE_OFN701_i_reset_n_i
Xdata_0_r_reg[39] QDFFRBN $PINS Q=data_0_r[39] D=n1747 CK=CTS_3
+ RB=FE_OFN364_i_reset_n_i
XBuffer/data_buffer_reg[408] QDFFRBN $PINS Q=Buffer/data_buffer[408] D=n1301
+ CK=CTS_18 RB=FE_OFN821_i_reset_n_i
Xdata_0_r_reg[40] QDFFRBN $PINS Q=data_0_r[40] D=n1748 CK=CTS_21
+ RB=FE_OFN824_i_reset_n_i
XBuffer/data_buffer_reg[409] QDFFRBN $PINS Q=Buffer/data_buffer[409] D=n1300
+ CK=CTS_18 RB=FE_OFN398_i_reset_n_i
Xdata_0_r_reg[41] QDFFRBN $PINS Q=data_0_r[41] D=n1749 CK=CTS_21
+ RB=FE_OFN1002_i_reset_n_i
XBuffer/data_buffer_reg[410] QDFFRBN $PINS Q=Buffer/data_buffer[410] D=n1299
+ CK=CTS_21 RB=FE_OFN577_i_reset_n_i
Xdata_0_r_reg[42] QDFFRBN $PINS Q=data_0_r[42] D=n1750 CK=CTS_21
+ RB=FE_OFN1002_i_reset_n_i
XBuffer/data_buffer_reg[411] QDFFRBN $PINS Q=Buffer/data_buffer[411] D=n1298
+ CK=CTS_18 RB=FE_OFN817_i_reset_n_i
Xdata_0_r_reg[43] QDFFRBN $PINS Q=data_0_r[43] D=n1751 CK=CTS_21
+ RB=FE_OFN1002_i_reset_n_i
XBuffer/data_buffer_reg[412] QDFFRBN $PINS Q=Buffer/data_buffer[412] D=n1297
+ CK=CTS_21 RB=FE_OFN686_i_reset_n_i
Xdata_0_r_reg[44] QDFFRBN $PINS Q=data_0_r[44] D=n1752 CK=CTS_21
+ RB=FE_OFN824_i_reset_n_i
XBuffer/data_buffer_reg[413] QDFFRBN $PINS Q=Buffer/data_buffer[413] D=n1296
+ CK=CTS_21 RB=FE_OFN686_i_reset_n_i
Xdata_0_r_reg[45] QDFFRBN $PINS Q=data_0_r[45] D=n1753 CK=CTS_21
+ RB=FE_OFN824_i_reset_n_i
XBuffer/data_buffer_reg[414] QDFFRBN $PINS Q=Buffer/data_buffer[414] D=n1295
+ CK=CTS_21 RB=FE_OFN577_i_reset_n_i
Xdata_0_r_reg[46] QDFFRBN $PINS Q=data_0_r[46] D=n1754 CK=CTS_21
+ RB=FE_OFN1002_i_reset_n_i
XBuffer/data_buffer_reg[415] QDFFRBN $PINS Q=Buffer/data_buffer[415] D=n1294
+ CK=CTS_31 RB=FE_OFN398_i_reset_n_i
Xdata_0_r_reg[47] QDFFRBN $PINS Q=data_0_r[47] D=n1755 CK=CTS_21
+ RB=FE_OFN1002_i_reset_n_i
XBuffer/data_buffer_reg[416] QDFFRBN $PINS Q=Buffer/data_buffer[416] D=n1293
+ CK=CTS_18 RB=FE_OFN683_i_reset_n_i
XBuffer/data_buffer_reg[417] QDFFRBN $PINS Q=Buffer/data_buffer[417] D=n1292
+ CK=CTS_18 RB=FE_OFN556_i_reset_n_i
XBuffer/data_buffer_reg[418] QDFFRBN $PINS Q=Buffer/data_buffer[418] D=n1291
+ CK=CTS_18 RB=FE_OFN685_i_reset_n_i
XBuffer/data_buffer_reg[419] QDFFRBN $PINS Q=Buffer/data_buffer[419] D=n1290
+ CK=CTS_18 RB=FE_OFN565_i_reset_n_i
XBuffer/data_buffer_reg[420] QDFFRBN $PINS Q=Buffer/data_buffer[420] D=n1289
+ CK=CTS_21 RB=FE_OFN565_i_reset_n_i
XBuffer/data_buffer_reg[421] QDFFRBN $PINS Q=Buffer/data_buffer[421] D=n1288
+ CK=CTS_21 RB=FE_OFN467_i_reset_n_i
XBuffer/data_buffer_reg[422] QDFFRBN $PINS Q=Buffer/data_buffer[422] D=n1287
+ CK=CTS_21 RB=FE_OFN565_i_reset_n_i
XBuffer/data_buffer_reg[423] QDFFRBN $PINS Q=Buffer/data_buffer[423] D=n1286
+ CK=CTS_18 RB=FE_OFN685_i_reset_n_i
XBuffer/data_buffer_reg[424] QDFFRBN $PINS Q=Buffer/data_buffer[424] D=n1285
+ CK=CTS_18 RB=FE_OFN1000_i_reset_n_i
XBuffer/data_buffer_reg[425] QDFFRBN $PINS Q=Buffer/data_buffer[425] D=n1284
+ CK=CTS_18 RB=FE_OFN816_i_reset_n_i
XBuffer/data_buffer_reg[426] QDFFRBN $PINS Q=Buffer/data_buffer[426] D=n1283
+ CK=CTS_18 RB=FE_OFN564_i_reset_n_i
XBuffer/data_buffer_reg[427] QDFFRBN $PINS Q=Buffer/data_buffer[427] D=n1282
+ CK=CTS_21 RB=FE_OFN564_i_reset_n_i
XBuffer/data_buffer_reg[428] QDFFRBN $PINS Q=Buffer/data_buffer[428] D=n1281
+ CK=CTS_21 RB=FE_OFN467_i_reset_n_i
XBuffer/data_buffer_reg[429] QDFFRBN $PINS Q=Buffer/data_buffer[429] D=n1280
+ CK=CTS_18 RB=FE_OFN563_i_reset_n_i
XBuffer/data_buffer_reg[430] QDFFRBN $PINS Q=Buffer/data_buffer[430] D=n1279
+ CK=CTS_21 RB=FE_OFN467_i_reset_n_i
XBuffer/data_buffer_reg[431] QDFFRBN $PINS Q=Buffer/data_buffer[431] D=n1278
+ CK=CTS_18 RB=FE_OFN685_i_reset_n_i
XBuffer/data_buffer_reg[432] QDFFRBN $PINS Q=Buffer/data_buffer[432] D=n1277
+ CK=CTS_6 RB=FE_OFN673_i_reset_n_i
XBuffer/data_buffer_reg[433] QDFFRBN $PINS Q=Buffer/data_buffer[433] D=n1276
+ CK=CTS_18 RB=FE_OFN816_i_reset_n_i
XBuffer/data_buffer_reg[434] QDFFRBN $PINS Q=Buffer/data_buffer[434] D=n1275
+ CK=CTS_18 RB=FE_OFN683_i_reset_n_i
XBuffer/data_buffer_reg[435] QDFFRBN $PINS Q=Buffer/data_buffer[435] D=n1274
+ CK=CTS_6 RB=FE_OFN563_i_reset_n_i
XBuffer/data_buffer_reg[436] QDFFRBN $PINS Q=Buffer/data_buffer[436] D=n1273
+ CK=CTS_21 RB=FE_OFN401_i_reset_n_i
XBuffer/data_buffer_reg[437] QDFFRBN $PINS Q=Buffer/data_buffer[437] D=n1272
+ CK=CTS_6 RB=FE_OFN1001_i_reset_n_i
XBuffer/data_buffer_reg[438] QDFFRBN $PINS Q=Buffer/data_buffer[438] D=n1271
+ CK=CTS_21 RB=FE_OFN401_i_reset_n_i
XBuffer/data_buffer_reg[439] QDFFRBN $PINS Q=Buffer/data_buffer[439] D=n1270
+ CK=CTS_18 RB=FE_OFN816_i_reset_n_i
XBuffer/data_buffer_reg[440] QDFFRBN $PINS Q=Buffer/data_buffer[440] D=n1269
+ CK=CTS_6 RB=FE_OFN555_i_reset_n_i
XBuffer/data_buffer_reg[441] QDFFRBN $PINS Q=Buffer/data_buffer[441] D=n1268
+ CK=CTS_18 RB=FE_OFN683_i_reset_n_i
XBuffer/data_buffer_reg[442] QDFFRBN $PINS Q=Buffer/data_buffer[442] D=n1267
+ CK=CTS_18 RB=FE_OFN933_i_reset_n_i
XBuffer/data_buffer_reg[443] QDFFRBN $PINS Q=Buffer/data_buffer[443] D=n1266
+ CK=CTS_6 RB=FE_OFN1001_i_reset_n_i
XBuffer/data_buffer_reg[444] QDFFRBN $PINS Q=Buffer/data_buffer[444] D=n1265
+ CK=CTS_17 RB=FE_OFN853_i_reset_n_i
XBuffer/data_buffer_reg[445] QDFFRBN $PINS Q=Buffer/data_buffer[445] D=n1264
+ CK=CTS_17 RB=FE_OFN853_i_reset_n_i
XBuffer/data_buffer_reg[446] QDFFRBN $PINS Q=Buffer/data_buffer[446] D=n1263
+ CK=CTS_17 RB=FE_OFN1001_i_reset_n_i
XBuffer/data_buffer_reg[447] QDFFRBN $PINS Q=Buffer/data_buffer[447] D=n1262
+ CK=CTS_18 RB=FE_OFN564_i_reset_n_i
XBuffer/data_buffer_reg[448] QDFFRBN $PINS Q=Buffer/data_buffer[448] D=n1261
+ CK=CTS_6 RB=FE_OFN555_i_reset_n_i
XBuffer/data_buffer_reg[449] QDFFRBN $PINS Q=Buffer/data_buffer[449] D=n1260
+ CK=CTS_18 RB=FE_OFN932_i_reset_n_i
XBuffer/data_buffer_reg[450] QDFFRBN $PINS Q=Buffer/data_buffer[450] D=n1259
+ CK=CTS_6 RB=FE_OFN933_i_reset_n_i
XBuffer/data_buffer_reg[451] QDFFRBN $PINS Q=Buffer/data_buffer[451] D=n1258
+ CK=CTS_6 RB=FE_OFN1001_i_reset_n_i
XBuffer/data_buffer_reg[452] QDFFRBN $PINS Q=Buffer/data_buffer[452] D=n1257
+ CK=CTS_6 RB=FE_OFN852_i_reset_n_i
XBuffer/data_buffer_reg[453] QDFFRBN $PINS Q=Buffer/data_buffer[453] D=n1256
+ CK=CTS_17 RB=FE_OFN852_i_reset_n_i
XBuffer/data_buffer_reg[454] QDFFRBN $PINS Q=Buffer/data_buffer[454] D=n1255
+ CK=CTS_6 RB=FE_OFN1001_i_reset_n_i
XBuffer/data_buffer_reg[455] QDFFRBN $PINS Q=Buffer/data_buffer[455] D=n1254
+ CK=CTS_18 RB=FE_OFN932_i_reset_n_i
XBuffer/data_buffer_reg[456] QDFFRBN $PINS Q=Buffer/data_buffer[456] D=n1253
+ CK=CTS_6 RB=FE_OFN397_i_reset_n_i
XBuffer/data_buffer_reg[457] QDFFRBN $PINS Q=Buffer/data_buffer[457] D=n1252
+ CK=CTS_6 RB=FE_OFN1000_i_reset_n_i
XBuffer/data_buffer_reg[458] QDFFRBN $PINS Q=Buffer/data_buffer[458] D=n1251
+ CK=CTS_6 RB=FE_OFN1000_i_reset_n_i
XBuffer/data_buffer_reg[459] QDFFRBN $PINS Q=Buffer/data_buffer[459] D=n1250
+ CK=CTS_6 RB=FE_OFN933_i_reset_n_i
XBuffer/data_buffer_reg[460] QDFFRBN $PINS Q=Buffer/data_buffer[460] D=n1249
+ CK=CTS_6 RB=FE_OFN805_i_reset_n_i
XBuffer/data_buffer_reg[461] QDFFRBN $PINS Q=Buffer/data_buffer[461] D=n1248
+ CK=CTS_6 RB=FE_OFN805_i_reset_n_i
XBuffer/data_buffer_reg[462] QDFFRBN $PINS Q=Buffer/data_buffer[462] D=n1247
+ CK=CTS_6 RB=FE_OFN1001_i_reset_n_i
XBuffer/data_buffer_reg[463] QDFFRBN $PINS Q=Buffer/data_buffer[463] D=n1246
+ CK=CTS_18 RB=FE_OFN683_i_reset_n_i
XBuffer/data_buffer_reg[464] QDFFRBN $PINS Q=Buffer/data_buffer[464] D=n1245
+ CK=CTS_6 RB=FE_OFN397_i_reset_n_i
XBuffer/data_buffer_reg[465] QDFFRBN $PINS Q=Buffer/data_buffer[465] D=n1244
+ CK=CTS_6 RB=FE_OFN402_i_reset_n_i
XBuffer/data_buffer_reg[466] QDFFRBN $PINS Q=Buffer/data_buffer[466] D=n1243
+ CK=CTS_18 RB=FE_OFN1000_i_reset_n_i
XBuffer/data_buffer_reg[467] QDFFRBN $PINS Q=Buffer/data_buffer[467] D=n1242
+ CK=CTS_6 RB=FE_OFN1000_i_reset_n_i
XBuffer/data_buffer_reg[468] QDFFRBN $PINS Q=Buffer/data_buffer[468] D=n1241
+ CK=CTS_6 RB=FE_OFN673_i_reset_n_i
XBuffer/data_buffer_reg[469] QDFFRBN $PINS Q=Buffer/data_buffer[469] D=n1240
+ CK=CTS_6 RB=FE_OFN805_i_reset_n_i
XBuffer/data_buffer_reg[470] QDFFRBN $PINS Q=Buffer/data_buffer[470] D=n1239
+ CK=CTS_6 RB=FE_OFN673_i_reset_n_i
XBuffer/data_buffer_reg[471] QDFFRBN $PINS Q=Buffer/data_buffer[471] D=n1238
+ CK=CTS_18 RB=FE_OFN821_i_reset_n_i
XBuffer/data_buffer_reg[472] QDFFRBN $PINS Q=Buffer/data_buffer[472] D=n1237
+ CK=CTS_6 RB=FE_OFN459_i_reset_n_i
XBuffer/data_buffer_reg[473] QDFFRBN $PINS Q=Buffer/data_buffer[473] D=n1236
+ CK=CTS_18 RB=FE_OFN821_i_reset_n_i
XBuffer/data_buffer_reg[474] QDFFRBN $PINS Q=Buffer/data_buffer[474] D=n1235
+ CK=CTS_6 RB=FE_OFN402_i_reset_n_i
XBuffer/data_buffer_reg[475] QDFFRBN $PINS Q=Buffer/data_buffer[475] D=n1234
+ CK=CTS_6 RB=FE_OFN806_i_reset_n_i
XBuffer/data_buffer_reg[476] QDFFRBN $PINS Q=Buffer/data_buffer[476] D=n1233
+ CK=CTS_6 RB=FE_OFN555_i_reset_n_i
XBuffer/data_buffer_reg[477] QDFFRBN $PINS Q=Buffer/data_buffer[477] D=n1232
+ CK=CTS_6 RB=FE_OFN555_i_reset_n_i
XBuffer/data_buffer_reg[478] QDFFRBN $PINS Q=Buffer/data_buffer[478] D=n1231
+ CK=CTS_6 RB=FE_OFN674_i_reset_n_i
XBuffer/data_buffer_reg[479] QDFFRBN $PINS Q=Buffer/data_buffer[479] D=n1230
+ CK=CTS_18 RB=FE_OFN821_i_reset_n_i
XBuffer/data_buffer_reg[480] QDFFRBN $PINS Q=Buffer/data_buffer[480] D=n1229
+ CK=CTS_6 RB=FE_OFN459_i_reset_n_i
XBuffer/data_buffer_reg[481] QDFFRBN $PINS Q=Buffer/data_buffer[481] D=n1228
+ CK=CTS_6 RB=FE_OFN468_i_reset_n_i
XBuffer/data_buffer_reg[482] QDFFRBN $PINS Q=Buffer/data_buffer[482] D=n1227
+ CK=CTS_6 RB=FE_OFN402_i_reset_n_i
XBuffer/data_buffer_reg[483] QDFFRBN $PINS Q=Buffer/data_buffer[483] D=n1226
+ CK=CTS_6 RB=FE_OFN806_i_reset_n_i
XBuffer/data_buffer_reg[484] QDFFRBN $PINS Q=Buffer/data_buffer[484] D=n1225
+ CK=CTS_6 RB=FE_OFN674_i_reset_n_i
XBuffer/data_buffer_reg[485] QDFFRBN $PINS Q=Buffer/data_buffer[485] D=n1224
+ CK=CTS_6 RB=FE_OFN674_i_reset_n_i
XBuffer/data_buffer_reg[486] QDFFRBN $PINS Q=Buffer/data_buffer[486] D=n1223
+ CK=CTS_6 RB=FE_OFN806_i_reset_n_i
XBuffer/data_buffer_reg[487] QDFFRBN $PINS Q=Buffer/data_buffer[487] D=n1222
+ CK=CTS_18 RB=FE_OFN688_i_reset_n_i
XBuffer/data_buffer_reg[488] QDFFRBN $PINS Q=Buffer/data_buffer[488] D=n1221
+ CK=CTS_13 RB=FE_OFN926_i_reset_n_i
XBuffer/data_buffer_reg[489] QDFFRBN $PINS Q=Buffer/data_buffer[489] D=n1220
+ CK=CTS_18 RB=FE_OFN688_i_reset_n_i
XBuffer/data_buffer_reg[490] QDFFRBN $PINS Q=Buffer/data_buffer[490] D=n1219
+ CK=CTS_6 RB=FE_OFN468_i_reset_n_i
XBuffer/data_buffer_reg[491] QDFFRBN $PINS Q=Buffer/data_buffer[491] D=n1218
+ CK=CTS_6 RB=FE_OFN925_i_reset_n_i
XBuffer/data_buffer_reg[492] QDFFRBN $PINS Q=Buffer/data_buffer[492] D=n1217
+ CK=CTS_6 RB=FE_OFN674_i_reset_n_i
XBuffer/data_buffer_reg[493] QDFFRBN $PINS Q=Buffer/data_buffer[493] D=n1216
+ CK=CTS_6 RB=FE_OFN807_i_reset_n_i
XBuffer/data_buffer_reg[494] QDFFRBN $PINS Q=Buffer/data_buffer[494] D=n1215
+ CK=CTS_6 RB=FE_OFN402_i_reset_n_i
XBuffer/data_buffer_reg[495] QDFFRBN $PINS Q=Buffer/data_buffer[495] D=n1214
+ CK=CTS_6 RB=FE_OFN468_i_reset_n_i
XBuffer/data_buffer_reg[496] QDFFRBN $PINS Q=Buffer/data_buffer[496] D=n1213
+ CK=CTS_10 RB=FE_OFN1016_i_reset_n_i
XBuffer/data_buffer_reg[497] QDFFRBN $PINS Q=Buffer/data_buffer[497] D=n1212
+ CK=CTS_18 RB=FE_OFN566_i_reset_n_i
XBuffer/data_buffer_reg[498] QDFFRBN $PINS Q=Buffer/data_buffer[498] D=n1211
+ CK=CTS_6 RB=FE_OFN468_i_reset_n_i
XBuffer/data_buffer_reg[499] QDFFRBN $PINS Q=Buffer/data_buffer[499] D=n1210
+ CK=CTS_6 RB=FE_OFN994_i_reset_n_i
XBuffer/data_buffer_reg[500] QDFFRBN $PINS Q=Buffer/data_buffer[500] D=n1209
+ CK=CTS_6 RB=FE_OFN925_i_reset_n_i
XBuffer/data_buffer_reg[501] QDFFRBN $PINS Q=Buffer/data_buffer[501] D=n1208
+ CK=CTS_6 RB=FE_OFN925_i_reset_n_i
XBuffer/data_buffer_reg[502] QDFFRBN $PINS Q=Buffer/data_buffer[502] D=n1207
+ CK=CTS_6 RB=FE_OFN468_i_reset_n_i
XBuffer/data_buffer_reg[503] QDFFRBN $PINS Q=Buffer/data_buffer[503] D=n1206
+ CK=CTS_18 RB=FE_OFN566_i_reset_n_i
XBuffer/data_buffer_reg[504] QDFFRBN $PINS Q=Buffer/data_buffer[504] D=n1205
+ CK=CTS_10 RB=FE_OFN419_i_reset_n_i
XBuffer/data_buffer_reg[505] QDFFRBN $PINS Q=Buffer/data_buffer[505] D=n1204
+ CK=CTS_18 RB=FE_OFN687_i_reset_n_i
XBuffer/data_buffer_reg[506] QDFFRBN $PINS Q=Buffer/data_buffer[506] D=n1203
+ CK=CTS_16 RB=FE_OFN687_i_reset_n_i
XBuffer/data_buffer_reg[507] QDFFRBN $PINS Q=Buffer/data_buffer[507] D=n1202
+ CK=CTS_6 RB=FE_OFN566_i_reset_n_i
XBuffer/data_buffer_reg[508] QDFFRBN $PINS Q=Buffer/data_buffer[508] D=n1201
+ CK=CTS_6 RB=FE_OFN994_i_reset_n_i
XBuffer/data_buffer_reg[509] QDFFRBN $PINS Q=Buffer/data_buffer[509] D=n1200
+ CK=CTS_6 RB=FE_OFN994_i_reset_n_i
XBuffer/data_buffer_reg[510] QDFFRBN $PINS Q=Buffer/data_buffer[510] D=n1199
+ CK=CTS_16 RB=FE_OFN818_i_reset_n_i
XBuffer/data_buffer_reg[511] QDFFRBN $PINS Q=Buffer/data_buffer[511] D=n1198
+ CK=CTS_18 RB=FE_OFN687_i_reset_n_i
XBuffer/data_buffer_reg[512] QDFFRBN $PINS Q=Buffer/data_buffer[512] D=n1197
+ CK=CTS_13 RB=FE_OFN419_i_reset_n_i
XBuffer/data_buffer_reg[513] QDFFRBN $PINS Q=Buffer/data_buffer[513] D=n1196
+ CK=CTS_30 RB=FE_OFN687_i_reset_n_i
XBuffer/data_buffer_reg[514] QDFFRBN $PINS Q=Buffer/data_buffer[514] D=n1195
+ CK=CTS_16 RB=FE_OFN818_i_reset_n_i
XBuffer/data_buffer_reg[515] QDFFRBN $PINS Q=Buffer/data_buffer[515] D=n1194
+ CK=CTS_16 RB=FE_OFN818_i_reset_n_i
XBuffer/data_buffer_reg[516] QDFFRBN $PINS Q=Buffer/data_buffer[516] D=n1193
+ CK=CTS_16 RB=FE_OFN818_i_reset_n_i
XBuffer/data_buffer_reg[517] QDFFRBN $PINS Q=Buffer/data_buffer[517] D=n1192
+ CK=CTS_16 RB=FE_OFN994_i_reset_n_i
XBuffer/data_buffer_reg[518] QDFFRBN $PINS Q=Buffer/data_buffer[518] D=n1191
+ CK=CTS_16 RB=FE_OFN818_i_reset_n_i
XBuffer/data_buffer_reg[519] QDFFRBN $PINS Q=Buffer/data_buffer[519] D=n1190
+ CK=CTS_16 RB=FE_OFN687_i_reset_n_i
XBuffer/data_buffer_reg[520] QDFFRBN $PINS Q=Buffer/data_buffer[520] D=n1189
+ CK=CTS_13 RB=FE_OFN490_i_reset_n_i
XBuffer/data_buffer_reg[521] QDFFRBN $PINS Q=Buffer/data_buffer[521] D=n1188
+ CK=CTS_16 RB=FE_OFN420_i_reset_n_i
XBuffer/data_buffer_reg[522] QDFFRBN $PINS Q=Buffer/data_buffer[522] D=n1187
+ CK=CTS_16 RB=FE_OFN492_i_reset_n_i
XBuffer/data_buffer_reg[523] QDFFRBN $PINS Q=Buffer/data_buffer[523] D=n1186
+ CK=CTS_16 RB=FE_OFN493_i_reset_n_i
XBuffer/data_buffer_reg[524] QDFFRBN $PINS Q=Buffer/data_buffer[524] D=n1185
+ CK=CTS_16 RB=FE_OFN371_i_reset_n_i
XBuffer/data_buffer_reg[525] QDFFRBN $PINS Q=Buffer/data_buffer[525] D=n1184
+ CK=CTS_16 RB=FE_OFN589_i_reset_n_i
XBuffer/data_buffer_reg[526] QDFFRBN $PINS Q=Buffer/data_buffer[526] D=n1183
+ CK=CTS_16 RB=FE_OFN589_i_reset_n_i
XBuffer/data_buffer_reg[527] QDFFRBN $PINS Q=Buffer/data_buffer[527] D=n1182
+ CK=CTS_16 RB=FE_OFN420_i_reset_n_i
XBuffer/data_buffer_reg[528] QDFFRBN $PINS Q=Buffer/data_buffer[528] D=n1181
+ CK=CTS_13 RB=FE_OFN846_i_reset_n_i
XBuffer/data_buffer_reg[529] QDFFRBN $PINS Q=Buffer/data_buffer[529] D=n1180
+ CK=CTS_30 RB=FE_OFN592_i_reset_n_i
XBuffer/data_buffer_reg[530] QDFFRBN $PINS Q=Buffer/data_buffer[530] D=n1179
+ CK=CTS_30 RB=FE_OFN592_i_reset_n_i
XBuffer/data_buffer_reg[531] QDFFRBN $PINS Q=Buffer/data_buffer[531] D=n1178
+ CK=CTS_20 RB=FE_OFN718_i_reset_n_i
XBuffer/data_buffer_reg[532] QDFFRBN $PINS Q=Buffer/data_buffer[532] D=n1177
+ CK=CTS_16 RB=FE_OFN492_i_reset_n_i
XBuffer/data_buffer_reg[533] QDFFRBN $PINS Q=Buffer/data_buffer[533] D=n1176
+ CK=CTS_16 RB=FE_OFN590_i_reset_n_i
XBuffer/data_buffer_reg[534] QDFFRBN $PINS Q=Buffer/data_buffer[534] D=n1175
+ CK=CTS_16 RB=FE_OFN420_i_reset_n_i
XBuffer/data_buffer_reg[535] QDFFRBN $PINS Q=Buffer/data_buffer[535] D=n1174
+ CK=CTS_30 RB=FE_OFN592_i_reset_n_i
XBuffer/data_buffer_reg[536] QDFFRBN $PINS Q=Buffer/data_buffer[536] D=n1173
+ CK=CTS_13 RB=FE_OFN716_i_reset_n_i
XBuffer/data_buffer_reg[537] QDFFRBN $PINS Q=Buffer/data_buffer[537] D=n1172
+ CK=CTS_20 RB=FE_OFN509_i_reset_n_i
XBuffer/data_buffer_reg[538] QDFFRBN $PINS Q=Buffer/data_buffer[538] D=n1171
+ CK=CTS_20 RB=FE_OFN718_i_reset_n_i
XBuffer/data_buffer_reg[539] QDFFRBN $PINS Q=Buffer/data_buffer[539] D=n1170
+ CK=CTS_20 RB=FE_OFN509_i_reset_n_i
XBuffer/data_buffer_reg[540] QDFFRBN $PINS Q=Buffer/data_buffer[540] D=n1169
+ CK=CTS_20 RB=FE_OFN718_i_reset_n_i
XBuffer/data_buffer_reg[541] QDFFRBN $PINS Q=Buffer/data_buffer[541] D=n1168
+ CK=CTS_12 RB=FE_OFN944_i_reset_n_i
XBuffer/data_buffer_reg[542] QDFFRBN $PINS Q=Buffer/data_buffer[542] D=n1167
+ CK=CTS_12 RB=FE_OFN944_i_reset_n_i
XBuffer/data_buffer_reg[543] QDFFRBN $PINS Q=Buffer/data_buffer[543] D=n1166
+ CK=CTS_30 RB=FE_OFN718_i_reset_n_i
XBuffer/data_buffer_reg[544] QDFFRBN $PINS Q=Buffer/data_buffer[544] D=n1165
+ CK=CTS_38 RB=FE_OFN582_i_reset_n_i
XBuffer/data_buffer_reg[545] QDFFRBN $PINS Q=Buffer/data_buffer[545] D=n1164
+ CK=CTS_20 RB=FE_OFN605_i_reset_n_i
XBuffer/data_buffer_reg[546] QDFFRBN $PINS Q=Buffer/data_buffer[546] D=n1163
+ CK=CTS_20 RB=FE_OFN607_i_reset_n_i
XBuffer/data_buffer_reg[547] QDFFRBN $PINS Q=Buffer/data_buffer[547] D=n1162
+ CK=CTS_20 RB=FE_OFN607_i_reset_n_i
XBuffer/data_buffer_reg[548] QDFFRBN $PINS Q=Buffer/data_buffer[548] D=n1161
+ CK=CTS_20 RB=FE_OFN735_i_reset_n_i
XBuffer/data_buffer_reg[549] QDFFRBN $PINS Q=Buffer/data_buffer[549] D=n1160
+ CK=CTS_12 RB=FE_OFN710_i_reset_n_i
XBuffer/data_buffer_reg[550] QDFFRBN $PINS Q=Buffer/data_buffer[550] D=n1159
+ CK=CTS_12 RB=FE_OFN838_i_reset_n_i
XBuffer/data_buffer_reg[551] QDFFRBN $PINS Q=Buffer/data_buffer[551] D=n1158
+ CK=CTS_20 RB=FE_OFN736_i_reset_n_i
XBuffer/data_buffer_reg[552] QDFFRBN $PINS Q=Buffer/data_buffer[552] D=n1157
+ CK=CTS_13 RB=FE_OFN582_i_reset_n_i
XBuffer/data_buffer_reg[553] QDFFRBN $PINS Q=Buffer/data_buffer[553] D=n1156
+ CK=CTS_20 RB=FE_OFN606_i_reset_n_i
XBuffer/data_buffer_reg[554] QDFFRBN $PINS Q=Buffer/data_buffer[554] D=n1155
+ CK=CTS_20 RB=FE_OFN736_i_reset_n_i
XBuffer/data_buffer_reg[555] QDFFRBN $PINS Q=Buffer/data_buffer[555] D=n1154
+ CK=CTS_20 RB=FE_OFN735_i_reset_n_i
XBuffer/data_buffer_reg[556] QDFFRBN $PINS Q=Buffer/data_buffer[556] D=n1153
+ CK=CTS_55 RB=FE_OFN870_i_reset_n_i
XBuffer/data_buffer_reg[557] QDFFRBN $PINS Q=Buffer/data_buffer[557] D=n1152
+ CK=CTS_12 RB=FE_OFN836_i_reset_n_i
XBuffer/data_buffer_reg[558] QDFFRBN $PINS Q=Buffer/data_buffer[558] D=n1151
+ CK=CTS_20 RB=FE_OFN742_i_reset_n_i
XBuffer/data_buffer_reg[559] QDFFRBN $PINS Q=Buffer/data_buffer[559] D=n1150
+ CK=CTS_55 RB=FE_OFN1021_i_reset_n_i
XBuffer/data_buffer_reg[560] QDFFRBN $PINS Q=Buffer/data_buffer[560] D=n1149
+ CK=CTS_38 RB=FE_OFN582_i_reset_n_i
XBuffer/data_buffer_reg[561] QDFFRBN $PINS Q=Buffer/data_buffer[561] D=n1148
+ CK=CTS_12 RB=FE_OFN836_i_reset_n_i
XBuffer/data_buffer_reg[562] QDFFRBN $PINS Q=Buffer/data_buffer[562] D=n1147
+ CK=CTS_12 RB=FE_OFN613_i_reset_n_i
XBuffer/data_buffer_reg[563] QDFFRBN $PINS Q=Buffer/data_buffer[563] D=n1146
+ CK=CTS_12 RB=FE_OFN742_i_reset_n_i
XBuffer/data_buffer_reg[564] QDFFRBN $PINS Q=Buffer/data_buffer[564] D=n1145
+ CK=CTS_12 RB=FE_OFN615_i_reset_n_i
XBuffer/data_buffer_reg[565] QDFFRBN $PINS Q=Buffer/data_buffer[565] D=n1144
+ CK=CTS_12 RB=FE_OFN612_i_reset_n_i
XBuffer/data_buffer_reg[566] QDFFRBN $PINS Q=Buffer/data_buffer[566] D=n1143
+ CK=CTS_12 RB=FE_OCPN9786_FE_OFN350_i_reset_n_i
XBuffer/data_buffer_reg[567] QDFFRBN $PINS Q=Buffer/data_buffer[567] D=n1142
+ CK=CTS_12 RB=FE_OFN615_i_reset_n_i
XBuffer/data_buffer_reg[568] QDFFRBN $PINS Q=Buffer/data_buffer[568] D=n1141
+ CK=CTS_38 RB=FE_OFN486_i_reset_n_i
XBuffer/data_buffer_reg[569] QDFFRBN $PINS Q=Buffer/data_buffer[569] D=n1140
+ CK=CTS_12 RB=FE_OFN708_i_reset_n_i
XBuffer/data_buffer_reg[570] QDFFRBN $PINS Q=Buffer/data_buffer[570] D=n1139
+ CK=CTS_38 RB=FE_OFN873_i_reset_n_i
XBuffer/data_buffer_reg[571] QDFFRBN $PINS Q=Buffer/data_buffer[571] D=n1138
+ CK=CTS_38 RB=FE_OFN945_i_reset_n_i
XBuffer/data_buffer_reg[572] QDFFRBN $PINS Q=Buffer/data_buffer[572] D=n1137
+ CK=CTS_38 RB=FE_OFN1010_i_reset_n_i
XBuffer/data_buffer_reg[573] QDFFRBN $PINS Q=Buffer/data_buffer[573] D=n1136
+ CK=CTS_38 RB=FE_OFN841_i_reset_n_i
XBuffer/data_buffer_reg[574] QDFFRBN $PINS Q=Buffer/data_buffer[574] D=n1135
+ CK=CTS_38 RB=FE_OFN1010_i_reset_n_i
XBuffer/data_buffer_reg[575] QDFFRBN $PINS Q=Buffer/data_buffer[575] D=n1134
+ CK=CTS_38 RB=FE_OFN1010_i_reset_n_i
XBuffer/data_buffer_reg[576] QDFFRBN $PINS Q=Buffer/data_buffer[576] D=n1133
+ CK=CTS_38 RB=FE_OFN485_i_reset_n_i
XBuffer/data_buffer_reg[577] QDFFRBN $PINS Q=Buffer/data_buffer[577] D=n1132
+ CK=CTS_38 RB=FE_OFN711_i_reset_n_i
XBuffer/data_buffer_reg[578] QDFFRBN $PINS Q=Buffer/data_buffer[578] D=n1131
+ CK=CTS_38 RB=FE_OFN946_i_reset_n_i
XBuffer/data_buffer_reg[579] QDFFRBN $PINS Q=Buffer/data_buffer[579] D=n1130
+ CK=CTS_38 RB=FE_OFN711_i_reset_n_i
XBuffer/data_buffer_reg[580] QDFFRBN $PINS Q=Buffer/data_buffer[580] D=n1129
+ CK=CTS_38 RB=FE_OFN1010_i_reset_n_i
XBuffer/data_buffer_reg[581] QDFFRBN $PINS Q=Buffer/data_buffer[581] D=n1128
+ CK=CTS_38 RB=FE_OFN946_i_reset_n_i
XBuffer/data_buffer_reg[582] QDFFRBN $PINS Q=Buffer/data_buffer[582] D=n1127
+ CK=CTS_38 RB=FE_OFN1010_i_reset_n_i
XBuffer/data_buffer_reg[583] QDFFRBN $PINS Q=Buffer/data_buffer[583] D=n1126
+ CK=CTS_38 RB=FE_OFN946_i_reset_n_i
XBuffer/data_buffer_reg[584] QDFFRBN $PINS Q=Buffer/data_buffer[584] D=n1125
+ CK=CTS_36 RB=FE_OFN485_i_reset_n_i
XBuffer/data_buffer_reg[585] QDFFRBN $PINS Q=Buffer/data_buffer[585] D=n1124
+ CK=CTS_36 RB=FE_OFN839_i_reset_n_i
XBuffer/data_buffer_reg[586] QDFFRBN $PINS Q=Buffer/data_buffer[586] D=n1123
+ CK=CTS_36 RB=FE_OFN1011_i_reset_n_i
XBuffer/data_buffer_reg[587] QDFFRBN $PINS Q=Buffer/data_buffer[587] D=n1122
+ CK=CTS_38 RB=FE_OFN840_i_reset_n_i
XBuffer/data_buffer_reg[588] QDFFRBN $PINS Q=Buffer/data_buffer[588] D=n1121
+ CK=CTS_36 RB=FE_OFN1011_i_reset_n_i
XBuffer/data_buffer_reg[589] QDFFRBN $PINS Q=Buffer/data_buffer[589] D=n1120
+ CK=CTS_36 RB=FE_OFN946_i_reset_n_i
XBuffer/data_buffer_reg[590] QDFFRBN $PINS Q=Buffer/data_buffer[590] D=n1119
+ CK=CTS_36 RB=FE_OFN1094_i_reset_n_i
XBuffer/data_buffer_reg[591] QDFFRBN $PINS Q=Buffer/data_buffer[591] D=n1118
+ CK=CTS_36 RB=FE_OFN1094_i_reset_n_i
XBuffer/data_buffer_reg[592] QDFFRBN $PINS Q=Buffer/data_buffer[592] D=n1117
+ CK=CTS_39 RB=FE_OFN585_i_reset_n_i
XBuffer/data_buffer_reg[593] QDFFRBN $PINS Q=Buffer/data_buffer[593] D=n1116
+ CK=CTS_36 RB=FE_OFN840_i_reset_n_i
XBuffer/data_buffer_reg[594] QDFFRBN $PINS Q=Buffer/data_buffer[594] D=n1115
+ CK=CTS_36 RB=FE_OFN1094_i_reset_n_i
XBuffer/data_buffer_reg[595] QDFFRBN $PINS Q=Buffer/data_buffer[595] D=n1114
+ CK=CTS_36 RB=FE_OFN840_i_reset_n_i
XBuffer/data_buffer_reg[596] QDFFRBN $PINS Q=Buffer/data_buffer[596] D=n1113
+ CK=CTS_36 RB=FE_OFN1011_i_reset_n_i
XBuffer/data_buffer_reg[597] QDFFRBN $PINS Q=Buffer/data_buffer[597] D=n1112
+ CK=CTS_36 RB=FE_OFN1011_i_reset_n_i
XBuffer/data_buffer_reg[598] QDFFRBN $PINS Q=Buffer/data_buffer[598] D=n1111
+ CK=CTS_36 RB=FE_OFN1094_i_reset_n_i
XBuffer/data_buffer_reg[599] QDFFRBN $PINS Q=Buffer/data_buffer[599] D=n1110
+ CK=CTS_36 RB=FE_OFN1094_i_reset_n_i
XBuffer/data_buffer_reg[600] QDFFRBN $PINS Q=Buffer/data_buffer[600] D=n1109
+ CK=CTS_39 RB=FE_OFN367_i_reset_n_i
XBuffer/data_buffer_reg[601] QDFFRBN $PINS Q=Buffer/data_buffer[601] D=n1108
+ CK=CTS_36 RB=FE_OFN840_i_reset_n_i
XBuffer/data_buffer_reg[602] QDFFRBN $PINS Q=Buffer/data_buffer[602] D=n1107
+ CK=CTS_36 RB=FE_OFN941_i_reset_n_i
XBuffer/data_buffer_reg[603] QDFFRBN $PINS Q=Buffer/data_buffer[603] D=n1106
+ CK=CTS_36 RB=FE_OFN1011_i_reset_n_i
XBuffer/data_buffer_reg[604] QDFFRBN $PINS Q=Buffer/data_buffer[604] D=n1105
+ CK=CTS_36 RB=FE_OFN941_i_reset_n_i
XBuffer/data_buffer_reg[605] QDFFRBN $PINS Q=Buffer/data_buffer[605] D=n1104
+ CK=CTS_36 RB=FE_OFN840_i_reset_n_i
XBuffer/data_buffer_reg[606] QDFFRBN $PINS Q=Buffer/data_buffer[606] D=n1103
+ CK=CTS_36 RB=FE_OFN941_i_reset_n_i
XBuffer/data_buffer_reg[607] QDFFRBN $PINS Q=Buffer/data_buffer[607] D=n1102
+ CK=CTS_36 RB=FE_OFN941_i_reset_n_i
XBuffer/data_buffer_reg[608] QDFFRBN $PINS Q=Buffer/data_buffer[608] D=n1101
+ CK=CTS_39 RB=FE_OFN367_i_reset_n_i
XBuffer/data_buffer_reg[609] QDFFRBN $PINS Q=Buffer/data_buffer[609] D=n1100
+ CK=CTS_36 RB=FE_OFN834_i_reset_n_i
XBuffer/data_buffer_reg[610] QDFFRBN $PINS Q=Buffer/data_buffer[610] D=n1099
+ CK=CTS_36 RB=FE_OFN941_i_reset_n_i
XBuffer/data_buffer_reg[611] QDFFRBN $PINS Q=Buffer/data_buffer[611] D=n1098
+ CK=CTS_36 RB=FE_OFN835_i_reset_n_i
XBuffer/data_buffer_reg[612] QDFFRBN $PINS Q=Buffer/data_buffer[612] D=n1097
+ CK=CTS_36 RB=FE_OFN940_i_reset_n_i
XBuffer/data_buffer_reg[613] QDFFRBN $PINS Q=Buffer/data_buffer[613] D=n1096
+ CK=CTS_36 RB=FE_OFN834_i_reset_n_i
XBuffer/data_buffer_reg[614] QDFFRBN $PINS Q=Buffer/data_buffer[614] D=n1095
+ CK=CTS_36 RB=FE_OFN835_i_reset_n_i
XBuffer/data_buffer_reg[615] QDFFRBN $PINS Q=Buffer/data_buffer[615] D=n1094
+ CK=CTS_36 RB=FE_OFN941_i_reset_n_i
XBuffer/data_buffer_reg[616] QDFFRBN $PINS Q=Buffer/data_buffer[616] D=n1093
+ CK=CTS_39 RB=FE_OFN417_i_reset_n_i
XBuffer/data_buffer_reg[617] QDFFRBN $PINS Q=Buffer/data_buffer[617] D=n1092
+ CK=CTS_36 RB=FE_OFN706_i_reset_n_i
XBuffer/data_buffer_reg[618] QDFFRBN $PINS Q=Buffer/data_buffer[618] D=n1091
+ CK=CTS_36 RB=FE_OFN835_i_reset_n_i
XBuffer/data_buffer_reg[619] QDFFRBN $PINS Q=Buffer/data_buffer[619] D=n1090
+ CK=CTS_36 RB=FE_OFN940_i_reset_n_i
XBuffer/data_buffer_reg[620] QDFFRBN $PINS Q=Buffer/data_buffer[620] D=n1089
+ CK=CTS_36 RB=FE_OFN940_i_reset_n_i
XBuffer/data_buffer_reg[621] QDFFRBN $PINS Q=Buffer/data_buffer[621] D=n1088
+ CK=CTS_36 RB=FE_OFN707_i_reset_n_i
XBuffer/data_buffer_reg[622] QDFFRBN $PINS Q=Buffer/data_buffer[622] D=n1087
+ CK=CTS_36 RB=FE_OFN835_i_reset_n_i
XBuffer/data_buffer_reg[623] QDFFRBN $PINS Q=Buffer/data_buffer[623] D=n1086
+ CK=CTS_36 RB=FE_OFN834_i_reset_n_i
XBuffer/data_buffer_reg[624] QDFFRBN $PINS Q=Buffer/data_buffer[624] D=n1085
+ CK=CTS_39 RB=FE_OFN729_i_reset_n_i
XBuffer/data_buffer_reg[625] QDFFRBN $PINS Q=Buffer/data_buffer[625] D=n1084
+ CK=CTS_36 RB=FE_OFN707_i_reset_n_i
XBuffer/data_buffer_reg[626] QDFFRBN $PINS Q=Buffer/data_buffer[626] D=n1083
+ CK=CTS_36 RB=FE_OFN833_i_reset_n_i
XBuffer/data_buffer_reg[627] QDFFRBN $PINS Q=Buffer/data_buffer[627] D=n1082
+ CK=CTS_36 RB=FE_OFN833_i_reset_n_i
XBuffer/data_buffer_reg[628] QDFFRBN $PINS Q=Buffer/data_buffer[628] D=n1081
+ CK=CTS_36 RB=FE_OFN705_i_reset_n_i
XBuffer/data_buffer_reg[629] QDFFRBN $PINS Q=Buffer/data_buffer[629] D=n1080
+ CK=CTS_36 RB=FE_OFN585_i_reset_n_i
XBuffer/data_buffer_reg[630] QDFFRBN $PINS Q=Buffer/data_buffer[630] D=n1079
+ CK=CTS_36 RB=FE_OFN833_i_reset_n_i
XBuffer/data_buffer_reg[631] QDFFRBN $PINS Q=Buffer/data_buffer[631] D=n1078
+ CK=CTS_36 RB=FE_OFN834_i_reset_n_i
XBuffer/data_buffer_reg[632] QDFFRBN $PINS Q=Buffer/data_buffer[632] D=n1077
+ CK=CTS_39 RB=FE_OFN856_i_reset_n_i
XBuffer/data_buffer_reg[633] QDFFRBN $PINS Q=Buffer/data_buffer[633] D=n1076
+ CK=CTS_36 RB=FE_OFN706_i_reset_n_i
XBuffer/data_buffer_reg[634] QDFFRBN $PINS Q=Buffer/data_buffer[634] D=n1075
+ CK=CTS_36 RB=FE_OFN706_i_reset_n_i
XBuffer/data_buffer_reg[635] QDFFRBN $PINS Q=Buffer/data_buffer[635] D=n1074
+ CK=CTS_36 RB=FE_OFN705_i_reset_n_i
XBuffer/data_buffer_reg[636] QDFFRBN $PINS Q=Buffer/data_buffer[636] D=n1073
+ CK=CTS_36 RB=FE_OFN705_i_reset_n_i
XBuffer/data_buffer_reg[637] QDFFRBN $PINS Q=Buffer/data_buffer[637] D=n1072
+ CK=CTS_36 RB=FE_OFN585_i_reset_n_i
XBuffer/data_buffer_reg[638] QDFFRBN $PINS Q=Buffer/data_buffer[638] D=n1071
+ CK=CTS_36 RB=FE_OFN580_i_reset_n_i
XBuffer/data_buffer_reg[639] QDFFRBN $PINS Q=Buffer/data_buffer[639] D=n1070
+ CK=CTS_36 RB=FE_OFN707_i_reset_n_i
XBuffer/data_buffer_reg[640] QDFFRBN $PINS Q=Buffer/data_buffer[640] D=n1069
+ CK=CTS_10 RB=FE_OFN730_i_reset_n_i
XBuffer/data_buffer_reg[641] QDFFRBN $PINS Q=Buffer/data_buffer[641] D=n1068
+ CK=CTS_36 RB=FE_OFN580_i_reset_n_i
XBuffer/data_buffer_reg[642] QDFFRBN $PINS Q=Buffer/data_buffer[642] D=n1067
+ CK=CTS_36 RB=FE_OFN581_i_reset_n_i
XBuffer/data_buffer_reg[643] QDFFRBN $PINS Q=Buffer/data_buffer[643] D=n1066
+ CK=CTS_36 RB=FE_OFN580_i_reset_n_i
XBuffer/data_buffer_reg[644] QDFFRBN $PINS Q=Buffer/data_buffer[644] D=n1065
+ CK=CTS_39 RB=FE_OFN705_i_reset_n_i
XBuffer/data_buffer_reg[645] QDFFRBN $PINS Q=Buffer/data_buffer[645] D=n1064
+ CK=CTS_36 RB=FE_OFN585_i_reset_n_i
XBuffer/data_buffer_reg[646] QDFFRBN $PINS Q=Buffer/data_buffer[646] D=n1063
+ CK=CTS_36 RB=FE_OFN705_i_reset_n_i
XBuffer/data_buffer_reg[647] QDFFRBN $PINS Q=Buffer/data_buffer[647] D=n1062
+ CK=CTS_36 RB=FE_OFN707_i_reset_n_i
XBuffer/data_buffer_reg[648] QDFFRBN $PINS Q=Buffer/data_buffer[648] D=n1061
+ CK=CTS_10 RB=FE_OFN730_i_reset_n_i
XBuffer/data_buffer_reg[649] QDFFRBN $PINS Q=Buffer/data_buffer[649] D=n1060
+ CK=CTS_36 RB=FE_OFN482_i_reset_n_i
XBuffer/data_buffer_reg[650] QDFFRBN $PINS Q=Buffer/data_buffer[650] D=n1059
+ CK=CTS_36 RB=FE_OFN482_i_reset_n_i
XBuffer/data_buffer_reg[651] QDFFRBN $PINS Q=Buffer/data_buffer[651] D=n1058
+ CK=CTS_39 RB=FE_OFN704_i_reset_n_i
XBuffer/data_buffer_reg[652] QDFFRBN $PINS Q=Buffer/data_buffer[652] D=n1057
+ CK=CTS_39 RB=FE_OFN481_i_reset_n_i
XBuffer/data_buffer_reg[653] QDFFRBN $PINS Q=Buffer/data_buffer[653] D=n1056
+ CK=CTS_39 RB=FE_OFN581_i_reset_n_i
XBuffer/data_buffer_reg[654] QDFFRBN $PINS Q=Buffer/data_buffer[654] D=n1055
+ CK=CTS_39 RB=FE_OFN481_i_reset_n_i
XBuffer/data_buffer_reg[655] QDFFRBN $PINS Q=Buffer/data_buffer[655] D=n1054
+ CK=CTS_36 RB=FE_OFN585_i_reset_n_i
XBuffer/data_buffer_reg[656] QDFFRBN $PINS Q=Buffer/data_buffer[656] D=n1053
+ CK=CTS_10 RB=FE_OFN730_i_reset_n_i
XBuffer/data_buffer_reg[657] QDFFRBN $PINS Q=Buffer/data_buffer[657] D=n1052
+ CK=CTS_39 RB=FE_OFN413_i_reset_n_i
XBuffer/data_buffer_reg[658] QDFFRBN $PINS Q=Buffer/data_buffer[658] D=n1051
+ CK=CTS_39 RB=FE_OFN581_i_reset_n_i
XBuffer/data_buffer_reg[659] QDFFRBN $PINS Q=Buffer/data_buffer[659] D=n1050
+ CK=CTS_39 RB=FE_OFN704_i_reset_n_i
XBuffer/data_buffer_reg[660] QDFFRBN $PINS Q=Buffer/data_buffer[660] D=n1049
+ CK=CTS_39 RB=FE_OFN481_i_reset_n_i
XBuffer/data_buffer_reg[661] QDFFRBN $PINS Q=Buffer/data_buffer[661] D=n1048
+ CK=CTS_39 RB=FE_OFN482_i_reset_n_i
XBuffer/data_buffer_reg[662] QDFFRBN $PINS Q=Buffer/data_buffer[662] D=n1047
+ CK=CTS_39 RB=FE_OFN481_i_reset_n_i
XBuffer/data_buffer_reg[663] QDFFRBN $PINS Q=Buffer/data_buffer[663] D=n1046
+ CK=CTS_39 RB=FE_OFN585_i_reset_n_i
XBuffer/data_buffer_reg[664] QDFFRBN $PINS Q=Buffer/data_buffer[664] D=n1045
+ CK=CTS_10 RB=FE_OFN857_i_reset_n_i
XBuffer/data_buffer_reg[665] QDFFRBN $PINS Q=Buffer/data_buffer[665] D=n1044
+ CK=CTS_39 RB=FE_OFN413_i_reset_n_i
XBuffer/data_buffer_reg[666] QDFFRBN $PINS Q=Buffer/data_buffer[666] D=n1043
+ CK=CTS_39 RB=FE_OFN703_i_reset_n_i
XBuffer/data_buffer_reg[667] QDFFRBN $PINS Q=Buffer/data_buffer[667] D=n1042
+ CK=CTS_39 RB=FE_OFN579_i_reset_n_i
XBuffer/data_buffer_reg[668] QDFFRBN $PINS Q=Buffer/data_buffer[668] D=n1041
+ CK=CTS_39 RB=FE_OFN366_i_reset_n_i
XBuffer/data_buffer_reg[669] QDFFRBN $PINS Q=Buffer/data_buffer[669] D=n1040
+ CK=CTS_39 RB=FE_OFN703_i_reset_n_i
XBuffer/data_buffer_reg[670] QDFFRBN $PINS Q=Buffer/data_buffer[670] D=n1039
+ CK=CTS_39 RB=FE_OFN366_i_reset_n_i
XBuffer/data_buffer_reg[671] QDFFRBN $PINS Q=Buffer/data_buffer[671] D=n1038
+ CK=CTS_39 RB=FE_OFN581_i_reset_n_i
XBuffer/data_buffer_reg[672] QDFFRBN $PINS Q=Buffer/data_buffer[672] D=n1037
+ CK=CTS_10 RB=FE_OFN857_i_reset_n_i
XBuffer/data_buffer_reg[673] QDFFRBN $PINS Q=Buffer/data_buffer[673] D=n1036
+ CK=CTS_39 RB=FE_OFN856_i_reset_n_i
XBuffer/data_buffer_reg[674] QDFFRBN $PINS Q=Buffer/data_buffer[674] D=n1035
+ CK=CTS_39 RB=FE_OFN703_i_reset_n_i
XBuffer/data_buffer_reg[675] QDFFRBN $PINS Q=Buffer/data_buffer[675] D=n1034
+ CK=CTS_39 RB=FE_OFN481_i_reset_n_i
XBuffer/data_buffer_reg[676] QDFFRBN $PINS Q=Buffer/data_buffer[676] D=n1033
+ CK=CTS_39 RB=FE_OFN413_i_reset_n_i
XBuffer/data_buffer_reg[677] QDFFRBN $PINS Q=Buffer/data_buffer[677] D=n1032
+ CK=CTS_39 RB=FE_OFN703_i_reset_n_i
XBuffer/data_buffer_reg[678] QDFFRBN $PINS Q=Buffer/data_buffer[678] D=n1031
+ CK=CTS_39 RB=FE_OFN856_i_reset_n_i
XBuffer/data_buffer_reg[679] QDFFRBN $PINS Q=Buffer/data_buffer[679] D=n1030
+ CK=CTS_39 RB=FE_OFN703_i_reset_n_i
XBuffer/data_buffer_reg[680] QDFFRBN $PINS Q=Buffer/data_buffer[680] D=n1029
+ CK=CTS_10 RB=FE_OFN857_i_reset_n_i
XBuffer/data_buffer_reg[681] QDFFRBN $PINS Q=Buffer/data_buffer[681] D=n1028
+ CK=CTS_39 RB=FE_OFN856_i_reset_n_i
XBuffer/data_buffer_reg[682] QDFFRBN $PINS Q=Buffer/data_buffer[682] D=n1027
+ CK=CTS_39 RB=FE_OFN703_i_reset_n_i
XBuffer/data_buffer_reg[683] QDFFRBN $PINS Q=Buffer/data_buffer[683] D=n1026
+ CK=CTS_39 RB=FE_OFN481_i_reset_n_i
XBuffer/data_buffer_reg[684] QDFFRBN $PINS Q=Buffer/data_buffer[684] D=n1025
+ CK=CTS_39 RB=FE_OFN856_i_reset_n_i
XBuffer/data_buffer_reg[685] QDFFRBN $PINS Q=Buffer/data_buffer[685] D=n1024
+ CK=CTS_39 RB=FE_OFN855_i_reset_n_i
XBuffer/data_buffer_reg[686] QDFFRBN $PINS Q=Buffer/data_buffer[686] D=n1023
+ CK=CTS_39 RB=FE_OFN856_i_reset_n_i
XBuffer/data_buffer_reg[687] QDFFRBN $PINS Q=Buffer/data_buffer[687] D=n1022
+ CK=CTS_39 RB=FE_OFN489_i_reset_n_i
XBuffer/data_buffer_reg[688] QDFFRBN $PINS Q=Buffer/data_buffer[688] D=n1021
+ CK=CTS_10 RB=FE_OFN857_i_reset_n_i
XBuffer/data_buffer_reg[689] QDFFRBN $PINS Q=Buffer/data_buffer[689] D=n1020
+ CK=CTS_10 RB=FE_OFN729_i_reset_n_i
XBuffer/data_buffer_reg[690] QDFFRBN $PINS Q=Buffer/data_buffer[690] D=n1019
+ CK=CTS_39 RB=FE_OFN489_i_reset_n_i
XBuffer/data_buffer_reg[691] QDFFRBN $PINS Q=Buffer/data_buffer[691] D=n1018
+ CK=CTS_39 RB=FE_OFN855_i_reset_n_i
XBuffer/data_buffer_reg[692] QDFFRBN $PINS Q=Buffer/data_buffer[692] D=n1017
+ CK=CTS_10 RB=FE_OFN730_i_reset_n_i
XBuffer/data_buffer_reg[693] QDFFRBN $PINS Q=Buffer/data_buffer[693] D=n1016
+ CK=CTS_39 RB=FE_OFN855_i_reset_n_i
XBuffer/data_buffer_reg[694] QDFFRBN $PINS Q=Buffer/data_buffer[694] D=n1015
+ CK=CTS_39 RB=FE_OFN729_i_reset_n_i
XBuffer/data_buffer_reg[695] QDFFRBN $PINS Q=Buffer/data_buffer[695] D=n1014
+ CK=CTS_39 RB=FE_OFN489_i_reset_n_i
XBuffer/data_buffer_reg[696] QDFFRBN $PINS Q=Buffer/data_buffer[696] D=n1013
+ CK=CTS_10 RB=FE_OFN857_i_reset_n_i
XBuffer/data_buffer_reg[697] QDFFRBN $PINS Q=Buffer/data_buffer[697] D=n1012
+ CK=CTS_10 RB=FE_OFN599_i_reset_n_i
XBuffer/data_buffer_reg[698] QDFFRBN $PINS Q=Buffer/data_buffer[698] D=n1011
+ CK=CTS_39 RB=FE_OFN417_i_reset_n_i
XBuffer/data_buffer_reg[699] QDFFRBN $PINS Q=Buffer/data_buffer[699] D=n1010
+ CK=CTS_39 RB=FE_OFN855_i_reset_n_i
XBuffer/data_buffer_reg[700] QDFFRBN $PINS Q=Buffer/data_buffer[700] D=n1009
+ CK=CTS_10 RB=FE_OFN730_i_reset_n_i
XBuffer/data_buffer_reg[701] QDFFRBN $PINS Q=Buffer/data_buffer[701] D=n1008
+ CK=CTS_39 RB=FE_OFN855_i_reset_n_i
XBuffer/data_buffer_reg[702] QDFFRBN $PINS Q=Buffer/data_buffer[702] D=n1007
+ CK=CTS_10 RB=FE_OFN599_i_reset_n_i
XBuffer/data_buffer_reg[703] QDFFRBN $PINS Q=Buffer/data_buffer[703] D=n1006
+ CK=CTS_39 RB=FE_OFN489_i_reset_n_i
XBuffer/data_buffer_reg[704] QDFFRBN $PINS Q=Buffer/data_buffer[704] D=n1005
+ CK=CTS_10 RB=FE_OFN424_i_reset_n_i
XBuffer/data_buffer_reg[705] QDFFRBN $PINS Q=Buffer/data_buffer[705] D=n1004
+ CK=CTS_10 RB=FE_OFN599_i_reset_n_i
XBuffer/data_buffer_reg[706] QDFFRBN $PINS Q=Buffer/data_buffer[706] D=n1003
+ CK=CTS_39 RB=FE_OFN417_i_reset_n_i
XBuffer/data_buffer_reg[707] QDFFRBN $PINS Q=Buffer/data_buffer[707] D=n1002
+ CK=CTS_10 RB=FE_OFN728_i_reset_n_i
XBuffer/data_buffer_reg[708] QDFFRBN $PINS Q=Buffer/data_buffer[708] D=n1001
+ CK=CTS_10 RB=FE_OFN857_i_reset_n_i
XBuffer/data_buffer_reg[709] QDFFRBN $PINS Q=Buffer/data_buffer[709] D=n1000
+ CK=CTS_39 RB=FE_OFN855_i_reset_n_i
XBuffer/data_buffer_reg[710] QDFFRBN $PINS Q=Buffer/data_buffer[710] D=n999
+ CK=CTS_39 RB=FE_OFN728_i_reset_n_i
XBuffer/data_buffer_reg[711] QDFFRBN $PINS Q=Buffer/data_buffer[711] D=n998
+ CK=CTS_39 RB=FE_OFN488_i_reset_n_i
XBuffer/data_buffer_reg[712] QDFFRBN $PINS Q=Buffer/data_buffer[712] D=n997
+ CK=CTS_10 RB=FE_OFN499_i_reset_n_i
XBuffer/data_buffer_reg[713] QDFFRBN $PINS Q=Buffer/data_buffer[713] D=n996
+ CK=CTS_10 RB=FE_OFN728_i_reset_n_i
XBuffer/data_buffer_reg[714] QDFFRBN $PINS Q=Buffer/data_buffer[714] D=n995
+ CK=CTS_39 RB=FE_OFN715_i_reset_n_i
XBuffer/data_buffer_reg[715] QDFFRBN $PINS Q=Buffer/data_buffer[715] D=n994
+ CK=CTS_10 RB=FE_OFN600_i_reset_n_i
XBuffer/data_buffer_reg[716] QDFFRBN $PINS Q=Buffer/data_buffer[716] D=n993
+ CK=CTS_10 RB=FE_OFN499_i_reset_n_i
XBuffer/data_buffer_reg[717] QDFFRBN $PINS Q=Buffer/data_buffer[717] D=n992
+ CK=CTS_39 RB=FE_OFN728_i_reset_n_i
XBuffer/data_buffer_reg[718] QDFFRBN $PINS Q=Buffer/data_buffer[718] D=n991
+ CK=CTS_39 RB=FE_OFN417_i_reset_n_i
XBuffer/data_buffer_reg[719] QDFFRBN $PINS Q=Buffer/data_buffer[719] D=n990
+ CK=CTS_10 RB=FE_OFN488_i_reset_n_i
XBuffer/data_buffer_reg[720] QDFFRBN $PINS Q=Buffer/data_buffer[720] D=n989
+ CK=CTS_10 RB=FE_OFN600_i_reset_n_i
XBuffer/data_buffer_reg[721] QDFFRBN $PINS Q=Buffer/data_buffer[721] D=n988
+ CK=CTS_10 RB=FE_OFN490_i_reset_n_i
XBuffer/data_buffer_reg[722] QDFFRBN $PINS Q=Buffer/data_buffer[722] D=n987
+ CK=CTS_13 RB=FE_OFN846_i_reset_n_i
XBuffer/data_buffer_reg[723] QDFFRBN $PINS Q=Buffer/data_buffer[723] D=n986
+ CK=CTS_10 RB=FE_OFN369_i_reset_n_i
XBuffer/data_buffer_reg[724] QDFFRBN $PINS Q=Buffer/data_buffer[724] D=n985
+ CK=CTS_10 RB=FE_OFN370_i_reset_n_i
XBuffer/data_buffer_reg[725] QDFFRBN $PINS Q=Buffer/data_buffer[725] D=n984
+ CK=CTS_10 RB=FE_OFN369_i_reset_n_i
XBuffer/data_buffer_reg[726] QDFFRBN $PINS Q=Buffer/data_buffer[726] D=n983
+ CK=CTS_10 RB=FE_OFN490_i_reset_n_i
XBuffer/data_buffer_reg[727] QDFFRBN $PINS Q=Buffer/data_buffer[727] D=n982
+ CK=CTS_13 RB=FE_OFN490_i_reset_n_i
XBuffer/data_buffer_reg[728] QDFFRBN $PINS Q=Buffer/data_buffer[728] D=n981
+ CK=CTS_10 RB=FE_OFN600_i_reset_n_i
XBuffer/data_buffer_reg[729] QDFFRBN $PINS Q=Buffer/data_buffer[729] D=n980
+ CK=CTS_13 RB=FE_OFN490_i_reset_n_i
XBuffer/data_buffer_reg[730] QDFFRBN $PINS Q=Buffer/data_buffer[730] D=n979
+ CK=CTS_13 RB=FE_OFN846_i_reset_n_i
XBuffer/data_buffer_reg[731] QDFFRBN $PINS Q=Buffer/data_buffer[731] D=n978
+ CK=CTS_10 RB=FE_OFN370_i_reset_n_i
XBuffer/data_buffer_reg[732] QDFFRBN $PINS Q=Buffer/data_buffer[732] D=n977
+ CK=CTS_10 RB=FE_OFN418_i_reset_n_i
XBuffer/data_buffer_reg[733] QDFFRBN $PINS Q=Buffer/data_buffer[733] D=n976
+ CK=CTS_10 RB=FE_OFN370_i_reset_n_i
XBuffer/data_buffer_reg[734] QDFFRBN $PINS Q=Buffer/data_buffer[734] D=n975
+ CK=CTS_13 RB=FE_OFN490_i_reset_n_i
XBuffer/data_buffer_reg[735] QDFFRBN $PINS Q=Buffer/data_buffer[735] D=n974
+ CK=CTS_13 RB=FE_OFN491_i_reset_n_i
XBuffer/data_buffer_reg[736] QDFFRBN $PINS Q=Buffer/data_buffer[736] D=n973
+ CK=CTS_10 RB=FE_OFN600_i_reset_n_i
XBuffer/data_buffer_reg[737] QDFFRBN $PINS Q=Buffer/data_buffer[737] D=n972
+ CK=CTS_13 RB=FE_OFN416_i_reset_n_i
XBuffer/data_buffer_reg[738] QDFFRBN $PINS Q=Buffer/data_buffer[738] D=n971
+ CK=CTS_13 RB=FE_OFN491_i_reset_n_i
XBuffer/data_buffer_reg[739] QDFFRBN $PINS Q=Buffer/data_buffer[739] D=n970
+ CK=CTS_13 RB=FE_OFN368_i_reset_n_i
XBuffer/data_buffer_reg[740] QDFFRBN $PINS Q=Buffer/data_buffer[740] D=n969
+ CK=CTS_13 RB=FE_OFN1703_n
XBuffer/data_buffer_reg[741] QDFFRBN $PINS Q=Buffer/data_buffer[741] D=n968
+ CK=CTS_13 RB=FE_OFN419_i_reset_n_i
XBuffer/data_buffer_reg[742] QDFFRBN $PINS Q=Buffer/data_buffer[742] D=n967
+ CK=CTS_13 RB=FE_OFN416_i_reset_n_i
XBuffer/data_buffer_reg[743] QDFFRBN $PINS Q=Buffer/data_buffer[743] D=n966
+ CK=CTS_13 RB=FE_OFN491_i_reset_n_i
XBuffer/data_buffer_reg[744] QDFFRBN $PINS Q=Buffer/data_buffer[744] D=n965
+ CK=CTS_10 RB=FE_OFN1016_i_reset_n_i
XBuffer/data_buffer_reg[745] QDFFRBN $PINS Q=Buffer/data_buffer[745] D=n964
+ CK=CTS_16 RB=FE_OFN712_i_reset_n_i
XBuffer/data_buffer_reg[746] QDFFRBN $PINS Q=Buffer/data_buffer[746] D=n963
+ CK=CTS_16 RB=FE_OFN487_i_reset_n_i
XBuffer/data_buffer_reg[747] QDFFRBN $PINS Q=Buffer/data_buffer[747] D=n962
+ CK=CTS_16 RB=FE_OFN712_i_reset_n_i
XBuffer/data_buffer_reg[748] QDFFRBN $PINS Q=Buffer/data_buffer[748] D=n961
+ CK=CTS_16 RB=FE_OFN712_i_reset_n_i
XBuffer/data_buffer_reg[749] QDFFRBN $PINS Q=Buffer/data_buffer[749] D=n960
+ CK=CTS_13 RB=FE_OFN1059_i_reset_n_i
XBuffer/data_buffer_reg[750] QDFFRBN $PINS Q=Buffer/data_buffer[750] D=n959
+ CK=CTS_16 RB=FE_OFN487_i_reset_n_i
XBuffer/data_buffer_reg[751] QDFFRBN $PINS Q=Buffer/data_buffer[751] D=n958
+ CK=CTS_16 RB=FE_OFN416_i_reset_n_i
XBuffer/data_buffer_reg[752] QDFFRBN $PINS Q=Buffer/data_buffer[752] D=n957
+ CK=CTS_13 RB=FE_OFN1059_i_reset_n_i
XBuffer/data_buffer_reg[753] QDFFRBN $PINS Q=Buffer/data_buffer[753] D=n956
+ CK=CTS_16 RB=FE_OFN589_i_reset_n_i
XBuffer/data_buffer_reg[754] QDFFRBN $PINS Q=Buffer/data_buffer[754] D=n955
+ CK=CTS_16 RB=FE_OFN371_i_reset_n_i
XBuffer/data_buffer_reg[755] QDFFRBN $PINS Q=Buffer/data_buffer[755] D=n954
+ CK=CTS_16 RB=FE_OFN589_i_reset_n_i
XBuffer/data_buffer_reg[756] QDFFRBN $PINS Q=Buffer/data_buffer[756] D=n953
+ CK=CTS_16 RB=FE_OFN818_i_reset_n_i
XBuffer/data_buffer_reg[757] QDFFRBN $PINS Q=Buffer/data_buffer[757] D=n952
+ CK=CTS_16 RB=FE_OFN994_i_reset_n_i
XBuffer/data_buffer_reg[758] QDFFRBN $PINS Q=Buffer/data_buffer[758] D=n951
+ CK=CTS_16 RB=FE_OFN371_i_reset_n_i
XBuffer/data_buffer_reg[759] QDFFRBN $PINS Q=Buffer/data_buffer[759] D=n950
+ CK=CTS_16 RB=FE_OFN589_i_reset_n_i
XBuffer/data_buffer_reg[760] QDFFRBN $PINS Q=Buffer/data_buffer[760] D=n949
+ CK=CTS_16 RB=FE_OFN1059_i_reset_n_i
XBuffer/data_buffer_reg[761] QDFFRBN $PINS Q=Buffer/data_buffer[761] D=n948
+ CK=CTS_16 RB=FE_OFN494_i_reset_n_i
XBuffer/data_buffer_reg[762] QDFFRBN $PINS Q=Buffer/data_buffer[762] D=n947
+ CK=CTS_30 RB=FE_OFN494_i_reset_n_i
XBuffer/data_buffer_reg[763] QDFFRBN $PINS Q=Buffer/data_buffer[763] D=n946
+ CK=CTS_30 RB=FE_OFN593_i_reset_n_i
XBuffer/data_buffer_reg[764] QDFFRBN $PINS Q=Buffer/data_buffer[764] D=n945
+ CK=CTS_30 RB=FE_OFN819_i_reset_n_i
XBuffer/data_buffer_reg[765] QDFFRBN $PINS Q=Buffer/data_buffer[765] D=n944
+ CK=CTS_30 RB=FE_OFN494_i_reset_n_i
XBuffer/data_buffer_reg[766] QDFFRBN $PINS Q=Buffer/data_buffer[766] D=n943
+ CK=CTS_30 RB=FE_OFN593_i_reset_n_i
XBuffer/data_buffer_reg[767] QDFFRBN $PINS Q=Buffer/data_buffer[767] D=n942
+ CK=CTS_30 RB=FE_OFN594_i_reset_n_i
XBuffer/data_buffer_reg[768] QDFFRBN $PINS Q=Buffer/data_buffer[768] D=n941
+ CK=CTS_16 RB=FE_OFN994_i_reset_n_i
XBuffer/data_buffer_reg[769] QDFFRBN $PINS Q=Buffer/data_buffer[769] D=n940
+ CK=CTS_30 RB=FE_OFN847_i_reset_n_i
XBuffer/data_buffer_reg[770] QDFFRBN $PINS Q=Buffer/data_buffer[770] D=n939
+ CK=CTS_30 RB=FE_OFN847_i_reset_n_i
XBuffer/data_buffer_reg[771] QDFFRBN $PINS Q=Buffer/data_buffer[771] D=n938
+ CK=CTS_30 RB=FE_OFN847_i_reset_n_i
XBuffer/data_buffer_reg[772] QDFFRBN $PINS Q=Buffer/data_buffer[772] D=n937
+ CK=CTS_30 RB=FE_OFN927_i_reset_n_i
XBuffer/data_buffer_reg[773] QDFFRBN $PINS Q=Buffer/data_buffer[773] D=n936
+ CK=CTS_30 RB=FE_OFN847_i_reset_n_i
XBuffer/data_buffer_reg[774] QDFFRBN $PINS Q=Buffer/data_buffer[774] D=n935
+ CK=CTS_30 RB=FE_OFN847_i_reset_n_i
XBuffer/data_buffer_reg[775] QDFFRBN $PINS Q=Buffer/data_buffer[775] D=n934
+ CK=CTS_30 RB=FE_OFN720_i_reset_n_i
XBuffer/data_buffer_reg[776] QDFFRBN $PINS Q=Buffer/data_buffer[776] D=n933
+ CK=CTS_30 RB=FE_OFN819_i_reset_n_i
XBuffer/data_buffer_reg[777] QDFFRBN $PINS Q=Buffer/data_buffer[777] D=n932
+ CK=CTS_30 RB=FE_OFN929_i_reset_n_i
XBuffer/data_buffer_reg[778] QDFFRBN $PINS Q=Buffer/data_buffer[778] D=n931
+ CK=CTS_33 RB=FE_OFN399_i_reset_n_i
XBuffer/data_buffer_reg[779] QDFFRBN $PINS Q=Buffer/data_buffer[779] D=n930
+ CK=CTS_33 RB=FE_OFN814_i_reset_n_i
XBuffer/data_buffer_reg[780] QDFFRBN $PINS Q=Buffer/data_buffer[780] D=n929
+ CK=CTS_33 RB=FE_OFN682_i_reset_n_i
XBuffer/data_buffer_reg[781] QDFFRBN $PINS Q=Buffer/data_buffer[781] D=n928
+ CK=CTS_30 RB=FE_OFN929_i_reset_n_i
XBuffer/data_buffer_reg[782] QDFFRBN $PINS Q=Buffer/data_buffer[782] D=n927
+ CK=CTS_33 RB=FE_OFN399_i_reset_n_i
XBuffer/data_buffer_reg[783] QDFFRBN $PINS Q=Buffer/data_buffer[783] D=n926
+ CK=CTS_30 RB=FE_OFN929_i_reset_n_i
XBuffer/data_buffer_reg[784] QDFFRBN $PINS Q=Buffer/data_buffer[784] D=n925
+ CK=CTS_30 RB=FE_OFN819_i_reset_n_i
XBuffer/data_buffer_reg[785] QDFFRBN $PINS Q=Buffer/data_buffer[785] D=n924
+ CK=CTS_33 RB=FE_OFN996_i_reset_n_i
XBuffer/data_buffer_reg[786] QDFFRBN $PINS Q=Buffer/data_buffer[786] D=n923
+ CK=CTS_33 RB=FE_OFN996_i_reset_n_i
XBuffer/data_buffer_reg[787] QDFFRBN $PINS Q=Buffer/data_buffer[787] D=n922
+ CK=CTS_33 RB=FE_OFN814_i_reset_n_i
Xdata_1_r_reg[3] QDFFRBN $PINS Q=data_1_r[3] D=n1758 CK=CTS_25
+ RB=FE_OFN931_i_reset_n_i
XBuffer/data_buffer_reg[788] QDFFRBN $PINS Q=Buffer/data_buffer[788] D=n921
+ CK=CTS_33 RB=FE_OFN814_i_reset_n_i
XBuffer/data_buffer_reg[789] QDFFRBN $PINS Q=Buffer/data_buffer[789] D=n920
+ CK=CTS_33 RB=FE_OFN814_i_reset_n_i
XBuffer/data_buffer_reg[790] QDFFRBN $PINS Q=Buffer/data_buffer[790] D=n919
+ CK=CTS_33 RB=FE_OFN996_i_reset_n_i
Xdata_1_r_reg[6] QDFFRBN $PINS Q=data_1_r[6] D=n1761 CK=CTS_25
+ RB=FE_OFN997_i_reset_n_i
XBuffer/data_buffer_reg[791] QDFFRBN $PINS Q=Buffer/data_buffer[791] D=n918
+ CK=CTS_33 RB=FE_OFN677_i_reset_n_i
Xdata_1_r_reg[7] QDFFRBN $PINS Q=data_1_r[7] D=n1762 CK=CTS_25
+ RB=FE_OFN997_i_reset_n_i
XBuffer/data_buffer_reg[792] QDFFRBN $PINS Q=Buffer/data_buffer[792] D=n917
+ CK=CTS_30 RB=FE_OFN928_i_reset_n_i
Xdata_1_r_reg[8] QDFFRBN $PINS Q=data_1_r[8] D=n1763 CK=CTS_33
+ RB=FE_OFN810_i_reset_n_i
XBuffer/data_buffer_reg[793] QDFFRBN $PINS Q=Buffer/data_buffer[793] D=n916
+ CK=CTS_33 RB=FE_OFN441_i_reset_n_i
Xdata_1_r_reg[9] QDFFRBN $PINS Q=data_1_r[9] D=n1764 CK=CTS_25
+ RB=FE_OFN998_i_reset_n_i
XBuffer/data_buffer_reg[794] QDFFRBN $PINS Q=Buffer/data_buffer[794] D=n915
+ CK=CTS_33 RB=FE_OFN930_i_reset_n_i
Xdata_1_r_reg[10] QDFFRBN $PINS Q=data_1_r[10] D=n1765 CK=CTS_25
+ RB=FE_OFN768_i_reset_n_i
XBuffer/data_buffer_reg[795] QDFFRBN $PINS Q=Buffer/data_buffer[795] D=n914
+ CK=CTS_25 RB=FE_OFN528_i_reset_n_i
Xdata_1_r_reg[11] QDFFRBN $PINS Q=data_1_r[11] D=n1766 CK=CTS_25
+ RB=FE_OFN997_i_reset_n_i
XBuffer/data_buffer_reg[796] QDFFRBN $PINS Q=Buffer/data_buffer[796] D=n913
+ CK=CTS_25 RB=FE_OFN811_i_reset_n_i
XBuffer/data_buffer_reg[797] QDFFRBN $PINS Q=Buffer/data_buffer[797] D=n912
+ CK=CTS_33 RB=FE_OFN811_i_reset_n_i
Xdata_1_r_reg[13] QDFFRBN $PINS Q=data_1_r[13] D=n1768 CK=CTS_25
+ RB=FE_OFN997_i_reset_n_i
XBuffer/data_buffer_reg[798] QDFFRBN $PINS Q=Buffer/data_buffer[798] D=n911
+ CK=CTS_33 RB=FE_OFN996_i_reset_n_i
Xdata_1_r_reg[14] QDFFRBN $PINS Q=data_1_r[14] D=n1769 CK=CTS_25
+ RB=FE_OFN997_i_reset_n_i
XBuffer/data_buffer_reg[799] QDFFRBN $PINS Q=Buffer/data_buffer[799] D=n910
+ CK=CTS_25 RB=FE_OFN999_i_reset_n_i
Xdata_1_r_reg[15] QDFFRBN $PINS Q=data_1_r[15] D=n1770 CK=CTS_25
+ RB=FE_OFN998_i_reset_n_i
XBuffer/data_buffer_reg[800] QDFFRBN $PINS Q=Buffer/data_buffer[800] D=n909
+ CK=CTS_30 RB=FE_OFN929_i_reset_n_i
XBuffer/data_buffer_reg[801] QDFFRBN $PINS Q=Buffer/data_buffer[801] D=n908
+ CK=CTS_25 RB=FE_OFN442_i_reset_n_i
XBuffer/data_buffer_reg[802] QDFFRBN $PINS Q=Buffer/data_buffer[802] D=n907
+ CK=CTS_25 RB=FE_OFN641_i_reset_n_i
XBuffer/data_buffer_reg[803] QDFFRBN $PINS Q=Buffer/data_buffer[803] D=n906
+ CK=CTS_25 RB=FE_OFN527_i_reset_n_i
XBuffer/data_buffer_reg[804] QDFFRBN $PINS Q=Buffer/data_buffer[804] D=n905
+ CK=CTS_25 RB=FE_OFN440_i_reset_n_i
XBuffer/data_buffer_reg[805] QDFFRBN $PINS Q=Buffer/data_buffer[805] D=n904
+ CK=CTS_25 RB=FE_OFN527_i_reset_n_i
XBuffer/data_buffer_reg[806] QDFFRBN $PINS Q=Buffer/data_buffer[806] D=n903
+ CK=CTS_25 RB=FE_OFN531_i_reset_n_i
Xdata_1_r_reg[22] QDFFRBN $PINS Q=data_1_r[22] D=n1776 CK=CTS_51
+ RB=FE_OFN771_i_reset_n_i
XBuffer/data_buffer_reg[807] QDFFRBN $PINS Q=Buffer/data_buffer[807] D=n902
+ CK=CTS_25 RB=FE_OFN528_i_reset_n_i
XBuffer/data_buffer_reg[808] QDFFRBN $PINS Q=Buffer/data_buffer[808] D=n901
+ CK=CTS_30 RB=FE_OFN929_i_reset_n_i
Xdata_1_r_reg[24] QDFFRBN $PINS Q=data_1_r[24] D=n1778 CK=CTS_33
+ RB=FE_OFN810_i_reset_n_i
XBuffer/data_buffer_reg[809] QDFFRBN $PINS Q=Buffer/data_buffer[809] D=n900
+ CK=CTS_25 RB=FE_OCPN9784_FE_OFN385_i_reset_n_i
Xdata_1_r_reg[25] QDFFRBN $PINS Q=data_1_r[25] D=n1779 CK=CTS_51
+ RB=FE_OFN897_i_reset_n_i
XBuffer/data_buffer_reg[810] QDFFRBN $PINS Q=Buffer/data_buffer[810] D=n899
+ CK=CTS_28 RB=FE_OFN529_i_reset_n_i
Xdata_1_r_reg[26] QDFFRBN $PINS Q=data_1_r[26] D=n1780 CK=CTS_51
+ RB=FE_OFN897_i_reset_n_i
XBuffer/data_buffer_reg[811] QDFFRBN $PINS Q=Buffer/data_buffer[811] D=n898
+ CK=CTS_28 RB=FE_OCPN9784_FE_OFN385_i_reset_n_i
Xdata_1_r_reg[27] QDFFRBN $PINS Q=data_1_r[27] D=n1781 CK=CTS_51
+ RB=FE_OFN981_i_reset_n_i
XBuffer/data_buffer_reg[812] QDFFRBN $PINS Q=Buffer/data_buffer[812] D=n897
+ CK=CTS_25 RB=FE_OFN640_i_reset_n_i
Xdata_1_r_reg[28] QDFFRBN $PINS Q=data_1_r[28] D=n1782 CK=CTS_51
+ RB=FE_OFN981_i_reset_n_i
XBuffer/data_buffer_reg[813] QDFFRBN $PINS Q=Buffer/data_buffer[813] D=n896
+ CK=CTS_34 RB=FE_OFN440_i_reset_n_i
Xdata_1_r_reg[29] QDFFRBN $PINS Q=data_1_r[29] D=n1783 CK=CTS_51
+ RB=FE_OFN981_i_reset_n_i
XBuffer/data_buffer_reg[814] QDFFRBN $PINS Q=Buffer/data_buffer[814] D=n895
+ CK=CTS_28 RB=FE_OFN530_i_reset_n_i
Xdata_1_r_reg[30] QDFFRBN $PINS Q=data_1_r[30] D=n1784 CK=CTS_51
+ RB=FE_OFN981_i_reset_n_i
XBuffer/data_buffer_reg[815] QDFFRBN $PINS Q=Buffer/data_buffer[815] D=n894
+ CK=CTS_28 RB=FE_OFN530_i_reset_n_i
Xdata_1_r_reg[31] QDFFRBN $PINS Q=data_1_r[31] D=n1785 CK=CTS_51
+ RB=FE_OFN981_i_reset_n_i
XBuffer/data_buffer_reg[816] QDFFRBN $PINS Q=Buffer/data_buffer[816] D=n893
+ CK=CTS_30 RB=FE_OFN809_i_reset_n_i
XBuffer/data_buffer_reg[817] QDFFRBN $PINS Q=Buffer/data_buffer[817] D=n892
+ CK=CTS_28 RB=FE_OFN638_i_reset_n_i
XBuffer/data_buffer_reg[818] QDFFRBN $PINS Q=Buffer/data_buffer[818] D=n891
+ CK=CTS_28 RB=FE_OFN639_i_reset_n_i
XBuffer/data_buffer_reg[819] QDFFRBN $PINS Q=Buffer/data_buffer[819] D=n890
+ CK=CTS_28 RB=FE_OFN638_i_reset_n_i
Xdata_1_r_reg[35] QDFFRBN $PINS Q=data_1_r[35] D=n1788 CK=CTS_26
+ RB=FE_OFN894_i_reset_n_i
XBuffer/data_buffer_reg[820] QDFFRBN $PINS Q=Buffer/data_buffer[820] D=n889
+ CK=CTS_34 RB=FE_OFN526_i_reset_n_i
XBuffer/data_buffer_reg[821] QDFFRBN $PINS Q=Buffer/data_buffer[821] D=n888
+ CK=CTS_34 RB=FE_OFN526_i_reset_n_i
XBuffer/data_buffer_reg[822] QDFFRBN $PINS Q=Buffer/data_buffer[822] D=n887
+ CK=CTS_28 RB=FE_OFN893_i_reset_n_i
XBuffer/data_buffer_reg[823] QDFFRBN $PINS Q=Buffer/data_buffer[823] D=n886
+ CK=CTS_28 RB=FE_OFN639_i_reset_n_i
XBuffer/data_buffer_reg[824] QDFFRBN $PINS Q=Buffer/data_buffer[824] D=n885
+ CK=CTS_18 RB=FE_OFN676_i_reset_n_i
Xdata_1_r_reg[40] QDFFRBN $PINS Q=data_1_r[40] D=n1793 CK=CTS_34
+ RB=FE_OFN439_i_reset_n_i
XBuffer/data_buffer_reg[825] QDFFRBN $PINS Q=Buffer/data_buffer[825] D=n884
+ CK=CTS_28 RB=FE_OFN438_i_reset_n_i
XBuffer/data_buffer_reg[826] QDFFRBN $PINS Q=Buffer/data_buffer[826] D=n883
+ CK=CTS_28 RB=FE_OFN438_i_reset_n_i
Xdata_1_r_reg[42] QDFFRBN $PINS Q=data_1_r[42] D=n1795 CK=CTS_29
+ RB=FE_OFN1053_i_reset_n_i
XBuffer/data_buffer_reg[827] QDFFRBN $PINS Q=Buffer/data_buffer[827] D=n882
+ CK=CTS_28 RB=FE_OFN637_i_reset_n_i
Xdata_1_r_reg[43] QDFFRBN $PINS Q=data_1_r[43] D=n1796 CK=CTS_29
+ RB=FE_OFN1053_i_reset_n_i
XBuffer/data_buffer_reg[828] QDFFRBN $PINS Q=Buffer/data_buffer[828] D=n881
+ CK=CTS_34 RB=FE_OFN1004_i_reset_n_i
Xdata_1_r_reg[44] QDFFRBN $PINS Q=data_1_r[44] D=n1797 CK=CTS_29
+ RB=FE_OFN1053_i_reset_n_i
XBuffer/data_buffer_reg[829] QDFFRBN $PINS Q=Buffer/data_buffer[829] D=n880
+ CK=CTS_34 RB=FE_OFN827_i_reset_n_i
Xdata_1_r_reg[45] QDFFRBN $PINS Q=data_1_r[45] D=n1798 CK=CTS_29
+ RB=FE_OFN1053_i_reset_n_i
XBuffer/data_buffer_reg[830] QDFFRBN $PINS Q=Buffer/data_buffer[830] D=n879
+ CK=CTS_26 RB=FE_OFN980_i_reset_n_i
Xdata_1_r_reg[46] QDFFRBN $PINS Q=data_1_r[46] D=n1799 CK=CTS_29
+ RB=FE_OFN1053_i_reset_n_i
XBuffer/data_buffer_reg[831] QDFFRBN $PINS Q=Buffer/data_buffer[831] D=n878
+ CK=CTS_28 RB=FE_OFN525_i_reset_n_i
Xdata_1_r_reg[47] QDFFRBN $PINS Q=data_1_r[47] D=n1800 CK=CTS_29
+ RB=FE_OFN1053_i_reset_n_i
XBuffer/data_buffer_reg[832] QDFFRBN $PINS Q=Buffer/data_buffer[832] D=n877
+ CK=CTS_18 RB=FE_OFN808_i_reset_n_i
XBuffer/data_buffer_reg[833] QDFFRBN $PINS Q=Buffer/data_buffer[833] D=n876
+ CK=CTS_34 RB=FE_OFN827_i_reset_n_i
XBuffer/data_buffer_reg[834] QDFFRBN $PINS Q=Buffer/data_buffer[834] D=n875
+ CK=CTS_34 RB=FE_OFN692_i_reset_n_i
XBuffer/data_buffer_reg[835] QDFFRBN $PINS Q=Buffer/data_buffer[835] D=n874
+ CK=CTS_31 RB=FE_OFN812_i_reset_n_i
XBuffer/data_buffer_reg[836] QDFFRBN $PINS Q=Buffer/data_buffer[836] D=n873
+ CK=CTS_31 RB=FE_OFN825_i_reset_n_i
XBuffer/data_buffer_reg[837] QDFFRBN $PINS Q=Buffer/data_buffer[837] D=n872
+ CK=CTS_34 RB=FE_OFN827_i_reset_n_i
XBuffer/data_buffer_reg[838] QDFFRBN $PINS Q=Buffer/data_buffer[838] D=n871
+ CK=CTS_34 RB=FE_OFN692_i_reset_n_i
XBuffer/data_buffer_reg[839] QDFFRBN $PINS Q=Buffer/data_buffer[839] D=n870
+ CK=CTS_34 RB=FE_OFN827_i_reset_n_i
XBuffer/data_buffer_reg[840] QDFFRBN $PINS Q=Buffer/data_buffer[840] D=n869
+ CK=CTS_18 RB=FE_OFN821_i_reset_n_i
XBuffer/data_buffer_reg[841] QDFFRBN $PINS Q=Buffer/data_buffer[841] D=n868
+ CK=CTS_31 RB=FE_OFN813_i_reset_n_i
XBuffer/data_buffer_reg[842] QDFFRBN $PINS Q=Buffer/data_buffer[842] D=n867
+ CK=CTS_31 RB=FE_OFN701_i_reset_n_i
XBuffer/data_buffer_reg[843] QDFFRBN $PINS Q=Buffer/data_buffer[843] D=n866
+ CK=CTS_31 RB=FE_OFN400_i_reset_n_i
XBuffer/data_buffer_reg[844] QDFFRBN $PINS Q=Buffer/data_buffer[844] D=n865
+ CK=CTS_31 RB=FE_OFN813_i_reset_n_i
XBuffer/data_buffer_reg[845] QDFFRBN $PINS Q=Buffer/data_buffer[845] D=n864
+ CK=CTS_31 RB=FE_OFN813_i_reset_n_i
XBuffer/data_buffer_reg[846] QDFFRBN $PINS Q=Buffer/data_buffer[846] D=n863
+ CK=CTS_31 RB=FE_OFN813_i_reset_n_i
XBuffer/data_buffer_reg[847] QDFFRBN $PINS Q=Buffer/data_buffer[847] D=n862
+ CK=CTS_31 RB=FE_OFN825_i_reset_n_i
XBuffer/data_buffer_reg[848] QDFFRBN $PINS Q=Buffer/data_buffer[848] D=n861
+ CK=CTS_18 RB=FE_OFN821_i_reset_n_i
XBuffer/data_buffer_reg[849] QDFFRBN $PINS Q=Buffer/data_buffer[849] D=n860
+ CK=CTS_18 RB=FE_OFN817_i_reset_n_i
XBuffer/data_buffer_reg[850] QDFFRBN $PINS Q=Buffer/data_buffer[850] D=n859
+ CK=CTS_21 RB=FE_OFN1003_i_reset_n_i
XBuffer/data_buffer_reg[851] QDFFRBN $PINS Q=Buffer/data_buffer[851] D=n858
+ CK=CTS_21 RB=FE_OFN1003_i_reset_n_i
XBuffer/data_buffer_reg[852] QDFFRBN $PINS Q=Buffer/data_buffer[852] D=n857
+ CK=CTS_21 RB=FE_OFN1003_i_reset_n_i
XBuffer/data_buffer_reg[853] QDFFRBN $PINS Q=Buffer/data_buffer[853] D=n856
+ CK=CTS_21 RB=FE_OFN1003_i_reset_n_i
XBuffer/data_buffer_reg[854] QDFFRBN $PINS Q=Buffer/data_buffer[854] D=n855
+ CK=CTS_21 RB=FE_OFN1003_i_reset_n_i
XBuffer/data_buffer_reg[855] QDFFRBN $PINS Q=Buffer/data_buffer[855] D=n854
+ CK=CTS_18 RB=FE_OFN817_i_reset_n_i
XBuffer/data_buffer_reg[856] QDFFRBN $PINS Q=Buffer/data_buffer[856] D=n853
+ CK=CTS_18 RB=FE_OFN683_i_reset_n_i
XBuffer/data_buffer_reg[857] QDFFRBN $PINS Q=Buffer/data_buffer[857] D=n852
+ CK=CTS_18 RB=FE_OFN565_i_reset_n_i
XBuffer/data_buffer_reg[858] QDFFRBN $PINS Q=Buffer/data_buffer[858] D=n851
+ CK=CTS_21 RB=FE_OFN823_i_reset_n_i
XBuffer/data_buffer_reg[859] QDFFRBN $PINS Q=Buffer/data_buffer[859] D=n850
+ CK=CTS_21 RB=FE_OFN824_i_reset_n_i
XBuffer/data_buffer_reg[860] QDFFRBN $PINS Q=Buffer/data_buffer[860] D=n849
+ CK=CTS_21 RB=FE_OFN824_i_reset_n_i
XBuffer/data_buffer_reg[861] QDFFRBN $PINS Q=Buffer/data_buffer[861] D=n848
+ CK=CTS_21 RB=FE_OFN823_i_reset_n_i
XBuffer/data_buffer_reg[862] QDFFRBN $PINS Q=Buffer/data_buffer[862] D=n847
+ CK=CTS_21 RB=FE_OFN686_i_reset_n_i
XBuffer/data_buffer_reg[863] QDFFRBN $PINS Q=Buffer/data_buffer[863] D=n846
+ CK=CTS_21 RB=FE_OFN686_i_reset_n_i
XBuffer/data_buffer_reg[864] QDFFRBN $PINS Q=Buffer/data_buffer[864] D=n845
+ CK=CTS_6 RB=FE_OFN933_i_reset_n_i
XBuffer/data_buffer_reg[865] QDFFRBN $PINS Q=Buffer/data_buffer[865] D=n844
+ CK=CTS_21 RB=FE_OFN686_i_reset_n_i
XBuffer/data_buffer_reg[866] QDFFRBN $PINS Q=Buffer/data_buffer[866] D=n843
+ CK=CTS_21 RB=FE_OFN823_i_reset_n_i
XBuffer/data_buffer_reg[867] QDFFRBN $PINS Q=Buffer/data_buffer[867] D=n842
+ CK=CTS_21 RB=FE_OFN691_i_reset_n_i
XBuffer/data_buffer_reg[868] QDFFRBN $PINS Q=Buffer/data_buffer[868] D=n841
+ CK=CTS_21 RB=FE_OFN568_i_reset_n_i
XBuffer/data_buffer_reg[869] QDFFRBN $PINS Q=Buffer/data_buffer[869] D=n840
+ CK=CTS_21 RB=FE_OFN823_i_reset_n_i
XBuffer/data_buffer_reg[870] QDFFRBN $PINS Q=Buffer/data_buffer[870] D=n839
+ CK=CTS_21 RB=FE_OFN691_i_reset_n_i
XBuffer/data_buffer_reg[871] QDFFRBN $PINS Q=Buffer/data_buffer[871] D=n838
+ CK=CTS_21 RB=FE_OFN686_i_reset_n_i
XBuffer/data_buffer_reg[872] QDFFRBN $PINS Q=Buffer/data_buffer[872] D=n837
+ CK=CTS_6 RB=FE_OFN852_i_reset_n_i
XBuffer/data_buffer_reg[873] QDFFRBN $PINS Q=Buffer/data_buffer[873] D=n836
+ CK=CTS_21 RB=FE_OFN690_i_reset_n_i
XBuffer/data_buffer_reg[874] QDFFRBN $PINS Q=Buffer/data_buffer[874] D=n835
+ CK=CTS_21 RB=FE_OFN691_i_reset_n_i
XBuffer/data_buffer_reg[875] QDFFRBN $PINS Q=Buffer/data_buffer[875] D=n834
+ CK=CTS_21 RB=FE_OFN567_i_reset_n_i
XBuffer/data_buffer_reg[876] QDFFRBN $PINS Q=Buffer/data_buffer[876] D=n833
+ CK=CTS_21 RB=FE_OFN568_i_reset_n_i
XBuffer/data_buffer_reg[877] QDFFRBN $PINS Q=Buffer/data_buffer[877] D=n832
+ CK=CTS_21 RB=FE_OFN690_i_reset_n_i
XBuffer/data_buffer_reg[878] QDFFRBN $PINS Q=Buffer/data_buffer[878] D=n831
+ CK=CTS_21 RB=FE_OFN691_i_reset_n_i
XBuffer/data_buffer_reg[879] QDFFRBN $PINS Q=Buffer/data_buffer[879] D=n830
+ CK=CTS_21 RB=FE_OFN401_i_reset_n_i
XBuffer/data_buffer_reg[880] QDFFRBN $PINS Q=Buffer/data_buffer[880] D=n829
+ CK=CTS_6 RB=FE_OFN805_i_reset_n_i
XBuffer/data_buffer_reg[881] QDFFRBN $PINS Q=Buffer/data_buffer[881] D=n828
+ CK=CTS_21 RB=FE_OFN690_i_reset_n_i
XBuffer/data_buffer_reg[882] QDFFRBN $PINS Q=Buffer/data_buffer[882] D=n827
+ CK=CTS_21 RB=FE_OFN568_i_reset_n_i
XBuffer/data_buffer_reg[883] QDFFRBN $PINS Q=Buffer/data_buffer[883] D=n826
+ CK=CTS_21 RB=FE_OFN567_i_reset_n_i
XBuffer/data_buffer_reg[884] QDFFRBN $PINS Q=Buffer/data_buffer[884] D=n825
+ CK=CTS_21 RB=FE_OFN469_i_reset_n_i
XBuffer/data_buffer_reg[885] QDFFRBN $PINS Q=Buffer/data_buffer[885] D=n824
+ CK=CTS_17 RB=FE_OFN689_i_reset_n_i
XBuffer/data_buffer_reg[886] QDFFRBN $PINS Q=Buffer/data_buffer[886] D=n823
+ CK=CTS_21 RB=FE_OFN567_i_reset_n_i
XBuffer/data_buffer_reg[887] QDFFRBN $PINS Q=Buffer/data_buffer[887] D=n822
+ CK=CTS_17 RB=FE_OFN401_i_reset_n_i
XBuffer/data_buffer_reg[888] QDFFRBN $PINS Q=Buffer/data_buffer[888] D=n821
+ CK=CTS_7 RB=FE_OFN852_i_reset_n_i
XBuffer/data_buffer_reg[889] QDFFRBN $PINS Q=Buffer/data_buffer[889] D=n820
+ CK=CTS_17 RB=FE_OFN822_i_reset_n_i
XBuffer/data_buffer_reg[890] QDFFRBN $PINS Q=Buffer/data_buffer[890] D=n819
+ CK=CTS_21 RB=FE_OFN469_i_reset_n_i
XBuffer/data_buffer_reg[891] QDFFRBN $PINS Q=Buffer/data_buffer[891] D=n818
+ CK=CTS_21 RB=FE_OFN470_i_reset_n_i
XBuffer/data_buffer_reg[892] QDFFRBN $PINS Q=Buffer/data_buffer[892] D=n817
+ CK=CTS_21 RB=FE_OFN404_i_reset_n_i
XBuffer/data_buffer_reg[893] QDFFRBN $PINS Q=Buffer/data_buffer[893] D=n816
+ CK=CTS_17 RB=FE_OFN689_i_reset_n_i
XBuffer/data_buffer_reg[894] QDFFRBN $PINS Q=Buffer/data_buffer[894] D=n815
+ CK=CTS_21 RB=FE_OFN470_i_reset_n_i
XBuffer/data_buffer_reg[895] QDFFRBN $PINS Q=Buffer/data_buffer[895] D=n814
+ CK=CTS_17 RB=FE_OFN401_i_reset_n_i
XBuffer/data_buffer_reg[896] QDFFRBN $PINS Q=Buffer/data_buffer[896] D=n813
+ CK=CTS_7 RB=FE_OFN852_i_reset_n_i
XBuffer/data_buffer_reg[897] QDFFRBN $PINS Q=Buffer/data_buffer[897] D=n812
+ CK=CTS_17 RB=FE_OFN822_i_reset_n_i
XBuffer/data_buffer_reg[898] QDFFRBN $PINS Q=Buffer/data_buffer[898] D=n811
+ CK=CTS_21 RB=FE_OFN469_i_reset_n_i
XBuffer/data_buffer_reg[899] QDFFRBN $PINS Q=Buffer/data_buffer[899] D=n810
+ CK=CTS_21 RB=FE_OFN404_i_reset_n_i
XBuffer/data_buffer_reg[900] QDFFRBN $PINS Q=Buffer/data_buffer[900] D=n809
+ CK=CTS_21 RB=FE_OFN404_i_reset_n_i
XBuffer/data_buffer_reg[901] QDFFRBN $PINS Q=Buffer/data_buffer[901] D=n808
+ CK=CTS_17 RB=FE_OFN822_i_reset_n_i
XBuffer/data_buffer_reg[902] QDFFRBN $PINS Q=Buffer/data_buffer[902] D=n807
+ CK=CTS_14 RB=FE_OFN404_i_reset_n_i
XBuffer/data_buffer_reg[903] QDFFRBN $PINS Q=Buffer/data_buffer[903] D=n806
+ CK=CTS_17 RB=FE_OFN822_i_reset_n_i
XBuffer/data_buffer_reg[904] QDFFRBN $PINS Q=Buffer/data_buffer[904] D=n805
+ CK=CTS_6 RB=FE_OFN852_i_reset_n_i
XBuffer/data_buffer_reg[905] QDFFRBN $PINS Q=Buffer/data_buffer[905] D=n804
+ CK=CTS_17 RB=FE_OFN822_i_reset_n_i
XBuffer/data_buffer_reg[906] QDFFRBN $PINS Q=Buffer/data_buffer[906] D=n803
+ CK=CTS_14 RB=FE_OFN403_i_reset_n_i
XBuffer/data_buffer_reg[907] QDFFRBN $PINS Q=Buffer/data_buffer[907] D=n802
+ CK=CTS_14 RB=FE_OFN362_i_reset_n_i
XBuffer/data_buffer_reg[908] QDFFRBN $PINS Q=Buffer/data_buffer[908] D=n801
+ CK=CTS_14 RB=FE_OFN403_i_reset_n_i
XBuffer/data_buffer_reg[909] QDFFRBN $PINS Q=Buffer/data_buffer[909] D=n800
+ CK=CTS_17 RB=FE_OFN822_i_reset_n_i
XBuffer/data_buffer_reg[910] QDFFRBN $PINS Q=Buffer/data_buffer[910] D=n799
+ CK=CTS_14 RB=FE_OFN362_i_reset_n_i
XBuffer/data_buffer_reg[911] QDFFRBN $PINS Q=Buffer/data_buffer[911] D=n798
+ CK=CTS_17 RB=FE_OFN853_i_reset_n_i
XBuffer/data_buffer_reg[912] QDFFRBN $PINS Q=Buffer/data_buffer[912] D=n797
+ CK=CTS_17 RB=FE_OFN726_i_reset_n_i
XBuffer/data_buffer_reg[913] QDFFRBN $PINS Q=Buffer/data_buffer[913] D=n796
+ CK=CTS_17 RB=FE_OFN853_i_reset_n_i
XBuffer/data_buffer_reg[914] QDFFRBN $PINS Q=Buffer/data_buffer[914] D=n795
+ CK=CTS_14 RB=FE_OFN403_i_reset_n_i
XBuffer/data_buffer_reg[915] QDFFRBN $PINS Q=Buffer/data_buffer[915] D=n794
+ CK=CTS_14 RB=FE_OFN362_i_reset_n_i
XBuffer/data_buffer_reg[916] QDFFRBN $PINS Q=Buffer/data_buffer[916] D=n793
+ CK=CTS_14 RB=FE_OFN1014_i_reset_n_i
XBuffer/data_buffer_reg[917] QDFFRBN $PINS Q=Buffer/data_buffer[917] D=n792
+ CK=CTS_17 RB=FE_OFN854_i_reset_n_i
XBuffer/data_buffer_reg[918] QDFFRBN $PINS Q=Buffer/data_buffer[918] D=n791
+ CK=CTS_14 RB=FE_OFN362_i_reset_n_i
XBuffer/data_buffer_reg[919] QDFFRBN $PINS Q=Buffer/data_buffer[919] D=n790
+ CK=CTS_17 RB=FE_OFN853_i_reset_n_i
XBuffer/data_buffer_reg[920] QDFFRBN $PINS Q=Buffer/data_buffer[920] D=n789
+ CK=CTS_17 RB=FE_OFN598_i_reset_n_i
XBuffer/data_buffer_reg[921] QDFFRBN $PINS Q=Buffer/data_buffer[921] D=n788
+ CK=CTS_17 RB=FE_OFN853_i_reset_n_i
XBuffer/data_buffer_reg[922] QDFFRBN $PINS Q=Buffer/data_buffer[922] D=n787
+ CK=CTS_14 RB=FE_OFN1015_i_reset_n_i
XBuffer/data_buffer_reg[923] QDFFRBN $PINS Q=Buffer/data_buffer[923] D=n786
+ CK=CTS_14 RB=FE_OFN1014_i_reset_n_i
XBuffer/data_buffer_reg[924] QDFFRBN $PINS Q=Buffer/data_buffer[924] D=n785
+ CK=CTS_14 RB=FE_OFN1014_i_reset_n_i
XBuffer/data_buffer_reg[925] QDFFRBN $PINS Q=Buffer/data_buffer[925] D=n784
+ CK=CTS_14 RB=FE_OFN1015_i_reset_n_i
XBuffer/data_buffer_reg[926] QDFFRBN $PINS Q=Buffer/data_buffer[926] D=n783
+ CK=CTS_14 RB=FE_OFN723_i_reset_n_i
XBuffer/data_buffer_reg[927] QDFFRBN $PINS Q=Buffer/data_buffer[927] D=n782
+ CK=CTS_17 RB=FE_OFN727_i_reset_n_i
XBuffer/data_buffer_reg[928] QDFFRBN $PINS Q=Buffer/data_buffer[928] D=n781
+ CK=CTS_17 RB=FE_OFN598_i_reset_n_i
XBuffer/data_buffer_reg[929] QDFFRBN $PINS Q=Buffer/data_buffer[929] D=n780
+ CK=CTS_17 RB=FE_OFN727_i_reset_n_i
XBuffer/data_buffer_reg[930] QDFFRBN $PINS Q=Buffer/data_buffer[930] D=n779
+ CK=CTS_14 RB=FE_OFN850_i_reset_n_i
XBuffer/data_buffer_reg[931] QDFFRBN $PINS Q=Buffer/data_buffer[931] D=n778
+ CK=CTS_14 RB=FE_OFN1014_i_reset_n_i
XBuffer/data_buffer_reg[932] QDFFRBN $PINS Q=Buffer/data_buffer[932] D=n777
+ CK=CTS_14 RB=FE_OFN723_i_reset_n_i
XBuffer/data_buffer_reg[933] QDFFRBN $PINS Q=Buffer/data_buffer[933] D=n776
+ CK=CTS_14 RB=FE_OFN1015_i_reset_n_i
XBuffer/data_buffer_reg[934] QDFFRBN $PINS Q=Buffer/data_buffer[934] D=n775
+ CK=CTS_14 RB=FE_OFN723_i_reset_n_i
XBuffer/data_buffer_reg[935] QDFFRBN $PINS Q=Buffer/data_buffer[935] D=n774
+ CK=CTS_17 RB=FE_OFN727_i_reset_n_i
XBuffer/data_buffer_reg[936] QDFFRBN $PINS Q=Buffer/data_buffer[936] D=n773
+ CK=CTS_17 RB=FE_OFN598_i_reset_n_i
XBuffer/data_buffer_reg[937] QDFFRBN $PINS Q=Buffer/data_buffer[937] D=n772
+ CK=CTS_17 RB=FE_OFN725_i_reset_n_i
XBuffer/data_buffer_reg[938] QDFFRBN $PINS Q=Buffer/data_buffer[938] D=n771
+ CK=CTS_14 RB=FE_OFN850_i_reset_n_i
XBuffer/data_buffer_reg[939] QDFFRBN $PINS Q=Buffer/data_buffer[939] D=n770
+ CK=CTS_14 RB=FE_OFN722_i_reset_n_i
XBuffer/data_buffer_reg[940] QDFFRBN $PINS Q=Buffer/data_buffer[940] D=n769
+ CK=CTS_14 RB=FE_OFN722_i_reset_n_i
XBuffer/data_buffer_reg[941] QDFFRBN $PINS Q=Buffer/data_buffer[941] D=n768
+ CK=CTS_17 RB=FE_OFN721_i_reset_n_i
XBuffer/data_buffer_reg[942] QDFFRBN $PINS Q=Buffer/data_buffer[942] D=n767
+ CK=CTS_14 RB=FE_OFN596_i_reset_n_i
XBuffer/data_buffer_reg[943] QDFFRBN $PINS Q=Buffer/data_buffer[943] D=n766
+ CK=CTS_17 RB=FE_OFN854_i_reset_n_i
XBuffer/data_buffer_reg[944] QDFFRBN $PINS Q=Buffer/data_buffer[944] D=n765
+ CK=CTS_17 RB=FE_OFN498_i_reset_n_i
XBuffer/data_buffer_reg[945] QDFFRBN $PINS Q=Buffer/data_buffer[945] D=n764
+ CK=CTS_17 RB=FE_OFN725_i_reset_n_i
XBuffer/data_buffer_reg[946] QDFFRBN $PINS Q=Buffer/data_buffer[946] D=n763
+ CK=CTS_14 RB=FE_OFN850_i_reset_n_i
XBuffer/data_buffer_reg[947] QDFFRBN $PINS Q=Buffer/data_buffer[947] D=n762
+ CK=CTS_14 RB=FE_OFN722_i_reset_n_i
XBuffer/data_buffer_reg[948] QDFFRBN $PINS Q=Buffer/data_buffer[948] D=n761
+ CK=CTS_14 RB=FE_OFN722_i_reset_n_i
XBuffer/data_buffer_reg[949] QDFFRBN $PINS Q=Buffer/data_buffer[949] D=n760
+ CK=CTS_14 RB=FE_OFN721_i_reset_n_i
XBuffer/data_buffer_reg[950] QDFFRBN $PINS Q=Buffer/data_buffer[950] D=n759
+ CK=CTS_14 RB=FE_OFN596_i_reset_n_i
XBuffer/data_buffer_reg[951] QDFFRBN $PINS Q=Buffer/data_buffer[951] D=n758
+ CK=CTS_17 RB=FE_OFN854_i_reset_n_i
XBuffer/data_buffer_reg[952] QDFFRBN $PINS Q=Buffer/data_buffer[952] D=n757
+ CK=CTS_7 RB=FE_OFN724_i_reset_n_i
XBuffer/data_buffer_reg[953] QDFFRBN $PINS Q=Buffer/data_buffer[953] D=n756
+ CK=CTS_17 RB=FE_OFN725_i_reset_n_i
XBuffer/data_buffer_reg[954] QDFFRBN $PINS Q=Buffer/data_buffer[954] D=n755
+ CK=CTS_14 RB=FE_OFN851_i_reset_n_i
XBuffer/data_buffer_reg[955] QDFFRBN $PINS Q=Buffer/data_buffer[955] D=n754
+ CK=CTS_14 RB=FE_OFN851_i_reset_n_i
XBuffer/data_buffer_reg[956] QDFFRBN $PINS Q=Buffer/data_buffer[956] D=n753
+ CK=CTS_14 RB=FE_OFN596_i_reset_n_i
XBuffer/data_buffer_reg[957] QDFFRBN $PINS Q=Buffer/data_buffer[957] D=n752
+ CK=CTS_14 RB=FE_OFN851_i_reset_n_i
XBuffer/data_buffer_reg[958] QDFFRBN $PINS Q=Buffer/data_buffer[958] D=n751
+ CK=CTS_14 RB=FE_OFN596_i_reset_n_i
XBuffer/data_buffer_reg[959] QDFFRBN $PINS Q=Buffer/data_buffer[959] D=n750
+ CK=CTS_17 RB=FE_OFN721_i_reset_n_i
XBuffer/data_buffer_reg[960] QDFFRBN $PINS Q=Buffer/data_buffer[960] D=n749
+ CK=CTS_17 RB=FE_OFN597_i_reset_n_i
XBuffer/data_buffer_reg[961] QDFFRBN $PINS Q=Buffer/data_buffer[961] D=n748
+ CK=CTS_17 RB=FE_OFN725_i_reset_n_i
XBuffer/data_buffer_reg[962] QDFFRBN $PINS Q=Buffer/data_buffer[962] D=n747
+ CK=CTS_14 RB=FE_OFN721_i_reset_n_i
XBuffer/data_buffer_reg[963] QDFFRBN $PINS Q=Buffer/data_buffer[963] D=n746
+ CK=CTS_14 RB=FE_OFN496_i_reset_n_i
XBuffer/data_buffer_reg[964] QDFFRBN $PINS Q=Buffer/data_buffer[964] D=n745
+ CK=CTS_14 RB=FE_OFN851_i_reset_n_i
XBuffer/data_buffer_reg[965] QDFFRBN $PINS Q=Buffer/data_buffer[965] D=n744
+ CK=CTS_14 RB=FE_OFN851_i_reset_n_i
XBuffer/data_buffer_reg[966] QDFFRBN $PINS Q=Buffer/data_buffer[966] D=n743
+ CK=CTS_14 RB=FE_OFN496_i_reset_n_i
XBuffer/data_buffer_reg[967] QDFFRBN $PINS Q=Buffer/data_buffer[967] D=n742
+ CK=CTS_17 RB=FE_OFN725_i_reset_n_i
XBuffer/data_buffer_reg[968] QDFFRBN $PINS Q=Buffer/data_buffer[968] D=n741
+ CK=CTS_17 RB=FE_OFN498_i_reset_n_i
XBuffer/data_buffer_reg[969] QDFFRBN $PINS Q=Buffer/data_buffer[969] D=n740
+ CK=CTS_17 RB=FE_OFN423_i_reset_n_i
XBuffer/data_buffer_reg[970] QDFFRBN $PINS Q=Buffer/data_buffer[970] D=n739
+ CK=CTS_14 RB=FE_OFN595_i_reset_n_i
XBuffer/data_buffer_reg[971] QDFFRBN $PINS Q=Buffer/data_buffer[971] D=n738
+ CK=CTS_14 RB=FE_OFN496_i_reset_n_i
XBuffer/data_buffer_reg[972] QDFFRBN $PINS Q=Buffer/data_buffer[972] D=n737
+ CK=CTS_14 RB=FE_OFN851_i_reset_n_i
XBuffer/data_buffer_reg[973] QDFFRBN $PINS Q=Buffer/data_buffer[973] D=n736
+ CK=CTS_14 RB=FE_OFN495_i_reset_n_i
XBuffer/data_buffer_reg[974] QDFFRBN $PINS Q=Buffer/data_buffer[974] D=n735
+ CK=CTS_14 RB=FE_OFN496_i_reset_n_i
XBuffer/data_buffer_reg[975] QDFFRBN $PINS Q=Buffer/data_buffer[975] D=n734
+ CK=CTS_17 RB=FE_OFN721_i_reset_n_i
XBuffer/data_buffer_reg[976] QDFFRBN $PINS Q=Buffer/data_buffer[976] D=n733
+ CK=CTS_17 RB=FE_OFN498_i_reset_n_i
XBuffer/data_buffer_reg[977] QDFFRBN $PINS Q=Buffer/data_buffer[977] D=n732
+ CK=CTS_17 RB=FE_OFN595_i_reset_n_i
XBuffer/data_buffer_reg[978] QDFFRBN $PINS Q=Buffer/data_buffer[978] D=n731
+ CK=CTS_14 RB=FE_OFN495_i_reset_n_i
XBuffer/data_buffer_reg[979] QDFFRBN $PINS Q=Buffer/data_buffer[979] D=n730
+ CK=CTS_14 RB=FE_OFN346_i_reset_n_i
XBuffer/data_buffer_reg[980] QDFFRBN $PINS Q=Buffer/data_buffer[980] D=n729
+ CK=CTS_14 RB=FE_OCPN9778_FE_OFN346_i_reset_n_i
XBuffer/data_buffer_reg[981] QDFFRBN $PINS Q=Buffer/data_buffer[981] D=n728
+ CK=CTS_14 RB=FE_OFN495_i_reset_n_i
XBuffer/data_buffer_reg[982] QDFFRBN $PINS Q=Buffer/data_buffer[982] D=n727
+ CK=CTS_14 RB=FE_OFN496_i_reset_n_i
XBuffer/data_buffer_reg[983] QDFFRBN $PINS Q=Buffer/data_buffer[983] D=n726
+ CK=CTS_17 RB=FE_OFN721_i_reset_n_i
XBuffer/data_buffer_reg[984] QDFFRBN $PINS Q=Buffer/data_buffer[984] D=n725
+ CK=CTS_17 RB=FE_OFN597_i_reset_n_i
XBuffer/data_buffer_reg[985] QDFFRBN $PINS Q=Buffer/data_buffer[985] D=n724
+ CK=CTS_17 RB=FE_OFN423_i_reset_n_i
XBuffer/data_buffer_reg[986] QDFFRBN $PINS Q=Buffer/data_buffer[986] D=n723
+ CK=CTS_14 RB=FE_OFN595_i_reset_n_i
XBuffer/data_buffer_reg[987] QDFFRBN $PINS Q=Buffer/data_buffer[987] D=n722
+ CK=CTS_14 RB=FE_OCPN9778_FE_OFN346_i_reset_n_i
XBuffer/data_buffer_reg[988] QDFFRBN $PINS Q=Buffer/data_buffer[988] D=n721
+ CK=CTS_14 RB=FE_OFN495_i_reset_n_i
XBuffer/data_buffer_reg[989] QDFFRBN $PINS Q=Buffer/data_buffer[989] D=n720
+ CK=CTS_14 RB=FE_OFN421_i_reset_n_i
XBuffer/data_buffer_reg[990] QDFFRBN $PINS Q=Buffer/data_buffer[990] D=n719
+ CK=CTS_14 RB=FE_OFN346_i_reset_n_i
XBuffer/data_buffer_reg[991] QDFFRBN $PINS Q=Buffer/data_buffer[991] D=n718
+ CK=CTS_17 RB=FE_OFN595_i_reset_n_i
XBuffer/data_buffer_reg[992] QDFFRBN $PINS Q=Buffer/data_buffer[992] D=n717
+ CK=CTS_4 RB=FE_OFN505_i_reset_n_i
XBuffer/data_buffer_reg[993] QDFFRBN $PINS Q=Buffer/data_buffer[993] D=n716
+ CK=CTS_4 RB=FE_OFN603_i_reset_n_i
XBuffer/data_buffer_reg[994] QDFFRBN $PINS Q=Buffer/data_buffer[994] D=n715
+ CK=CTS_14 RB=FE_OFN421_i_reset_n_i
XBuffer/data_buffer_reg[995] QDFFRBN $PINS Q=Buffer/data_buffer[995] D=n714
+ CK=CTS_4 RB=FE_OFN376_i_reset_n_i
XBuffer/data_buffer_reg[996] QDFFRBN $PINS Q=Buffer/data_buffer[996] D=n713
+ CK=CTS_14 RB=FE_OFN421_i_reset_n_i
XBuffer/data_buffer_reg[997] QDFFRBN $PINS Q=Buffer/data_buffer[997] D=n712
+ CK=CTS_4 RB=FE_OFN376_i_reset_n_i
XBuffer/data_buffer_reg[998] QDFFRBN $PINS Q=Buffer/data_buffer[998] D=n711
+ CK=CTS_14 RB=FE_OFN421_i_reset_n_i
XBuffer/data_buffer_reg[999] QDFFRBN $PINS Q=Buffer/data_buffer[999] D=n710
+ CK=CTS_17 RB=FE_OFN423_i_reset_n_i
XBuffer/data_buffer_reg[1000] QDFFRBN $PINS Q=Buffer/data_buffer[1000] D=n709
+ CK=CTS_4 RB=FE_OFN427_i_reset_n_i
XBuffer/data_buffer_reg[1001] QDFFRBN $PINS Q=Buffer/data_buffer[1001] D=n708
+ CK=CTS_4 RB=FE_OFN504_i_reset_n_i
XBuffer/data_buffer_reg[1002] QDFFRBN $PINS Q=Buffer/data_buffer[1002] D=n707
+ CK=CTS_14 RB=FE_OFN504_i_reset_n_i
XBuffer/data_buffer_reg[1003] QDFFRBN $PINS Q=Buffer/data_buffer[1003] D=n706
+ CK=CTS_4 RB=FE_OFN504_i_reset_n_i
XBuffer/data_buffer_reg[1004] QDFFRBN $PINS Q=Buffer/data_buffer[1004] D=n705
+ CK=CTS_14 RB=FE_OFN603_i_reset_n_i
XBuffer/data_buffer_reg[1005] QDFFRBN $PINS Q=Buffer/data_buffer[1005] D=n704
+ CK=CTS_4 RB=FE_OFN504_i_reset_n_i
XBuffer/data_buffer_reg[1006] QDFFRBN $PINS Q=Buffer/data_buffer[1006] D=n703
+ CK=CTS_14 RB=FE_OFN595_i_reset_n_i
XBuffer/data_buffer_reg[1007] QDFFRBN $PINS Q=Buffer/data_buffer[1007] D=n702
+ CK=CTS_17 RB=FE_OFN497_i_reset_n_i
XBuffer/data_buffer_reg[1008] QDFFRBN $PINS Q=Buffer/data_buffer[1008] D=n701
+ CK=CTS_4 RB=FE_OFN733_i_reset_n_i
XBuffer/data_buffer_reg[1009] QDFFRBN $PINS Q=Buffer/data_buffer[1009] D=n700
+ CK=CTS_4 RB=FE_OCPN9740_FE_OFN344_i_reset_n_i
XBuffer/data_buffer_reg[1010] QDFFRBN $PINS Q=Buffer/data_buffer[1010] D=n699
+ CK=CTS_4 RB=FE_OCPN9739_FE_OFN344_i_reset_n_i
XBuffer/data_buffer_reg[1011] QDFFRBN $PINS Q=Buffer/data_buffer[1011] D=n698
+ CK=CTS_4 RB=FE_OFN504_i_reset_n_i
XBuffer/data_buffer_reg[1012] QDFFRBN $PINS Q=Buffer/data_buffer[1012] D=n697
+ CK=CTS_14 RB=FE_OFN603_i_reset_n_i
XBuffer/data_buffer_reg[1013] QDFFRBN $PINS Q=Buffer/data_buffer[1013] D=n696
+ CK=CTS_4 RB=FE_OCPN9739_FE_OFN344_i_reset_n_i
XBuffer/data_buffer_reg[1014] QDFFRBN $PINS Q=Buffer/data_buffer[1014] D=n695
+ CK=CTS_17 RB=FE_OFN603_i_reset_n_i
XBuffer/data_buffer_reg[1015] QDFFRBN $PINS Q=Buffer/data_buffer[1015] D=n694
+ CK=CTS_17 RB=FE_OFN423_i_reset_n_i
XBuffer/data_buffer_reg[1016] QDFFRBN $PINS Q=Buffer/data_buffer[1016] D=n693
+ CK=CTS_4 RB=FE_OFN860_i_reset_n_i
XBuffer/data_buffer_reg[1017] QDFFRBN $PINS Q=Buffer/data_buffer[1017] D=n692
+ CK=CTS_4 RB=FE_OFN426_i_reset_n_i
XBuffer/data_buffer_reg[1018] QDFFRBN $PINS Q=Buffer/data_buffer[1018] D=n691
+ CK=CTS_4 RB=FE_OCPN9740_FE_OFN344_i_reset_n_i
XBuffer/data_buffer_reg[1019] QDFFRBN $PINS Q=Buffer/data_buffer[1019] D=n690
+ CK=CTS_4 RB=FE_OCPN9739_FE_OFN344_i_reset_n_i
XBuffer/data_buffer_reg[1020] QDFFRBN $PINS Q=Buffer/data_buffer[1020] D=n689
+ CK=CTS_4 RB=FE_OFN603_i_reset_n_i
XBuffer/data_buffer_reg[1021] QDFFRBN $PINS Q=Buffer/data_buffer[1021] D=n688
+ CK=CTS_4 RB=FE_OCPN9739_FE_OFN344_i_reset_n_i
XBuffer/data_buffer_reg[1022] QDFFRBN $PINS Q=Buffer/data_buffer[1022] D=n687
+ CK=CTS_17 RB=FE_OFN376_i_reset_n_i
XBuffer/data_buffer_reg[1023] QDFFRBN $PINS Q=Buffer/data_buffer[1023] D=n686
+ CK=CTS_17 RB=FE_OFN498_i_reset_n_i
XBuffer/data_buffer_reg[1024] QDFFRBN $PINS Q=Buffer/data_buffer[1024] D=n685
+ CK=CTS_4 RB=FE_OFN501_i_reset_n_i
XBuffer/data_buffer_reg[1025] QDFFRBN $PINS Q=Buffer/data_buffer[1025] D=n684
+ CK=CTS_4 RB=FE_OFN426_i_reset_n_i
XBuffer/data_buffer_reg[1026] QDFFRBN $PINS Q=Buffer/data_buffer[1026] D=n683
+ CK=CTS_4 RB=FE_OFN426_i_reset_n_i
XBuffer/data_buffer_reg[1027] QDFFRBN $PINS Q=Buffer/data_buffer[1027] D=n682
+ CK=CTS_4 RB=FE_OFN427_i_reset_n_i
XBuffer/data_buffer_reg[1028] QDFFRBN $PINS Q=Buffer/data_buffer[1028] D=n681
+ CK=CTS_4 RB=FE_OFN505_i_reset_n_i
XBuffer/data_buffer_reg[1029] QDFFRBN $PINS Q=Buffer/data_buffer[1029] D=n680
+ CK=CTS_4 RB=FE_OCPN9740_FE_OFN344_i_reset_n_i
XBuffer/data_buffer_reg[1030] QDFFRBN $PINS Q=Buffer/data_buffer[1030] D=n679
+ CK=CTS_4 RB=FE_OFN603_i_reset_n_i
XBuffer/data_buffer_reg[1031] QDFFRBN $PINS Q=Buffer/data_buffer[1031] D=n678
+ CK=CTS_17 RB=FE_OFN497_i_reset_n_i
XBuffer/data_buffer_reg[1032] QDFFRBN $PINS Q=Buffer/data_buffer[1032] D=n677
+ CK=CTS_4 RB=FE_OFN602_i_reset_n_i
XBuffer/data_buffer_reg[1033] QDFFRBN $PINS Q=Buffer/data_buffer[1033] D=n676
+ CK=CTS_4 RB=FE_OFN426_i_reset_n_i
XBuffer/data_buffer_reg[1034] QDFFRBN $PINS Q=Buffer/data_buffer[1034] D=n675
+ CK=CTS_4 RB=FE_OFN502_i_reset_n_i
XBuffer/data_buffer_reg[1035] QDFFRBN $PINS Q=Buffer/data_buffer[1035] D=n674
+ CK=CTS_4 RB=FE_OFN427_i_reset_n_i
XBuffer/data_buffer_reg[1036] QDFFRBN $PINS Q=Buffer/data_buffer[1036] D=n673
+ CK=CTS_4 RB=FE_OFN505_i_reset_n_i
XBuffer/data_buffer_reg[1037] QDFFRBN $PINS Q=Buffer/data_buffer[1037] D=n672
+ CK=CTS_4 RB=FE_OFN502_i_reset_n_i
XBuffer/data_buffer_reg[1038] QDFFRBN $PINS Q=Buffer/data_buffer[1038] D=n671
+ CK=CTS_4 RB=FE_OFN863_i_reset_n_i
XBuffer/data_buffer_reg[1039] QDFFRBN $PINS Q=Buffer/data_buffer[1039] D=n670
+ CK=CTS_17 RB=FE_OFN863_i_reset_n_i
XBuffer/data_buffer_reg[1040] QDFFRBN $PINS Q=Buffer/data_buffer[1040] D=n669
+ CK=CTS_4 RB=FE_OFN602_i_reset_n_i
XBuffer/data_buffer_reg[1041] QDFFRBN $PINS Q=Buffer/data_buffer[1041] D=n668
+ CK=CTS_4 RB=FE_OFN501_i_reset_n_i
XBuffer/data_buffer_reg[1042] QDFFRBN $PINS Q=Buffer/data_buffer[1042] D=n667
+ CK=CTS_4 RB=FE_OFN501_i_reset_n_i
XBuffer/data_buffer_reg[1043] QDFFRBN $PINS Q=Buffer/data_buffer[1043] D=n666
+ CK=CTS_4 RB=FE_OFN427_i_reset_n_i
XBuffer/data_buffer_reg[1044] QDFFRBN $PINS Q=Buffer/data_buffer[1044] D=n665
+ CK=CTS_4 RB=FE_OFN505_i_reset_n_i
XBuffer/data_buffer_reg[1045] QDFFRBN $PINS Q=Buffer/data_buffer[1045] D=n664
+ CK=CTS_4 RB=FE_OFN502_i_reset_n_i
XBuffer/data_buffer_reg[1046] QDFFRBN $PINS Q=Buffer/data_buffer[1046] D=n663
+ CK=CTS_4 RB=FE_OFN863_i_reset_n_i
XBuffer/data_buffer_reg[1047] QDFFRBN $PINS Q=Buffer/data_buffer[1047] D=n662
+ CK=CTS_17 RB=FE_OFN863_i_reset_n_i
XBuffer/data_buffer_reg[1048] QDFFRBN $PINS Q=Buffer/data_buffer[1048] D=n661
+ CK=CTS_4 RB=FE_OFN602_i_reset_n_i
XBuffer/data_buffer_reg[1049] QDFFRBN $PINS Q=Buffer/data_buffer[1049] D=n660
+ CK=CTS_4 RB=FE_OFN860_i_reset_n_i
XBuffer/data_buffer_reg[1050] QDFFRBN $PINS Q=Buffer/data_buffer[1050] D=n659
+ CK=CTS_4 RB=FE_OFN501_i_reset_n_i
XBuffer/data_buffer_reg[1051] QDFFRBN $PINS Q=Buffer/data_buffer[1051] D=n658
+ CK=CTS_4 RB=FE_OFN733_i_reset_n_i
XBuffer/data_buffer_reg[1052] QDFFRBN $PINS Q=Buffer/data_buffer[1052] D=n657
+ CK=CTS_4 RB=FE_OFN505_i_reset_n_i
XBuffer/data_buffer_reg[1053] QDFFRBN $PINS Q=Buffer/data_buffer[1053] D=n656
+ CK=CTS_4 RB=FE_OFN733_i_reset_n_i
XBuffer/data_buffer_reg[1054] QDFFRBN $PINS Q=Buffer/data_buffer[1054] D=n655
+ CK=CTS_4 RB=FE_OFN863_i_reset_n_i
XBuffer/data_buffer_reg[1055] QDFFRBN $PINS Q=Buffer/data_buffer[1055] D=n654
+ CK=CTS_17 RB=FE_OFN863_i_reset_n_i
XBuffer/data_buffer_reg[1056] QDFFRBN $PINS Q=Buffer/data_buffer[1056] D=n653
+ CK=CTS_7 RB=FE_OFN602_i_reset_n_i
XBuffer/data_buffer_reg[1057] QDFFRBN $PINS Q=Buffer/data_buffer[1057] D=n652
+ CK=CTS_4 RB=FE_OFN861_i_reset_n_i
XBuffer/data_buffer_reg[1058] QDFFRBN $PINS Q=Buffer/data_buffer[1058] D=n651
+ CK=CTS_4 RB=FE_OFN501_i_reset_n_i
XBuffer/data_buffer_reg[1059] QDFFRBN $PINS Q=Buffer/data_buffer[1059] D=n650
+ CK=CTS_4 RB=FE_OFN734_i_reset_n_i
XBuffer/data_buffer_reg[1060] QDFFRBN $PINS Q=Buffer/data_buffer[1060] D=n649
+ CK=CTS_4 RB=FE_OFN862_i_reset_n_i
XBuffer/data_buffer_reg[1061] QDFFRBN $PINS Q=Buffer/data_buffer[1061] D=n648
+ CK=CTS_4 RB=FE_OFN859_i_reset_n_i
XBuffer/data_buffer_reg[1062] QDFFRBN $PINS Q=Buffer/data_buffer[1062] D=n647
+ CK=CTS_17 RB=FE_OFN724_i_reset_n_i
XBuffer/data_buffer_reg[1063] QDFFRBN $PINS Q=Buffer/data_buffer[1063] D=n646
+ CK=CTS_17 RB=FE_OFN724_i_reset_n_i
XBuffer/data_buffer_reg[1064] QDFFRBN $PINS Q=Buffer/data_buffer[1064] D=n645
+ CK=CTS_7 RB=FE_OFN602_i_reset_n_i
XBuffer/data_buffer_reg[1065] QDFFRBN $PINS Q=Buffer/data_buffer[1065] D=n644
+ CK=CTS_4 RB=FE_OFN859_i_reset_n_i
XBuffer/data_buffer_reg[1066] QDFFRBN $PINS Q=Buffer/data_buffer[1066] D=n643
+ CK=CTS_4 RB=FE_OFN861_i_reset_n_i
XBuffer/data_buffer_reg[1067] QDFFRBN $PINS Q=Buffer/data_buffer[1067] D=n642
+ CK=CTS_4 RB=FE_OFN862_i_reset_n_i
XBuffer/data_buffer_reg[1068] QDFFRBN $PINS Q=Buffer/data_buffer[1068] D=n641
+ CK=CTS_4 RB=FE_OFN862_i_reset_n_i
XBuffer/data_buffer_reg[1069] QDFFRBN $PINS Q=Buffer/data_buffer[1069] D=n640
+ CK=CTS_4 RB=FE_OFN861_i_reset_n_i
XBuffer/data_buffer_reg[1070] QDFFRBN $PINS Q=Buffer/data_buffer[1070] D=n639
+ CK=CTS_4 RB=FE_OFN862_i_reset_n_i
XBuffer/data_buffer_reg[1071] QDFFRBN $PINS Q=Buffer/data_buffer[1071] D=n638
+ CK=CTS_17 RB=FE_OFN724_i_reset_n_i
XBuffer/data_buffer_reg[1072] QDFFRBN $PINS Q=Buffer/data_buffer[1072] D=n637
+ CK=CTS_7 RB=FE_OCPN9741_FE_OFN344_i_reset_n_i
XBuffer/data_buffer_reg[1073] QDFFRBN $PINS Q=Buffer/data_buffer[1073] D=n636
+ CK=CTS_4 RB=FE_OFN859_i_reset_n_i
XBuffer/data_buffer_reg[1074] QDFFRBN $PINS Q=Buffer/data_buffer[1074] D=n635
+ CK=CTS_7 RB=FE_OFN602_i_reset_n_i
XBuffer/data_buffer_reg[1075] QDFFRBN $PINS Q=Buffer/data_buffer[1075] D=n634
+ CK=CTS_4 RB=FE_OFN862_i_reset_n_i
XBuffer/data_buffer_reg[1076] QDFFRBN $PINS Q=Buffer/data_buffer[1076] D=n633
+ CK=CTS_7 RB=FE_OFN859_i_reset_n_i
XBuffer/data_buffer_reg[1077] QDFFRBN $PINS Q=Buffer/data_buffer[1077] D=n632
+ CK=CTS_7 RB=FE_OFN861_i_reset_n_i
XBuffer/data_buffer_reg[1078] QDFFRBN $PINS Q=Buffer/data_buffer[1078] D=n631
+ CK=CTS_7 RB=FE_OFN724_i_reset_n_i
XBuffer/data_buffer_reg[1079] QDFFRBN $PINS Q=Buffer/data_buffer[1079] D=n630
+ CK=CTS_17 RB=FE_OFN724_i_reset_n_i
XBuffer/data_buffer_reg[1080] QDFFRBN $PINS Q=Buffer/data_buffer[1080] D=n629
+ CK=CTS_7 RB=FE_OCPN9741_FE_OFN344_i_reset_n_i
XBuffer/data_buffer_reg[1081] QDFFRBN $PINS Q=Buffer/data_buffer[1081] D=n628
+ CK=CTS_7 RB=FE_OFN861_i_reset_n_i
XBuffer/data_buffer_reg[1082] QDFFRBN $PINS Q=Buffer/data_buffer[1082] D=n627
+ CK=CTS_7 RB=FE_OFN861_i_reset_n_i
XBuffer/data_buffer_reg[1083] QDFFRBN $PINS Q=Buffer/data_buffer[1083] D=n626
+ CK=CTS_7 RB=FE_OFN1064_i_reset_n_i
XBuffer/data_buffer_reg[1084] QDFFRBN $PINS Q=Buffer/data_buffer[1084] D=n625
+ CK=CTS_7 RB=FE_OFN425_i_reset_n_i
XBuffer/data_buffer_reg[1085] QDFFRBN $PINS Q=Buffer/data_buffer[1085] D=n624
+ CK=CTS_7 RB=FE_OFN859_i_reset_n_i
XBuffer/data_buffer_reg[1086] QDFFRBN $PINS Q=Buffer/data_buffer[1086] D=n623
+ CK=CTS_7 RB=FE_OFN1095_i_reset_n_i
XBuffer/data_buffer_reg[1087] QDFFRBN $PINS Q=Buffer/data_buffer[1087] D=n622
+ CK=CTS_4 RB=FE_OFN1095_i_reset_n_i
XBuffer/data_buffer_reg[1088] QDFFRBN $PINS Q=Buffer/data_buffer[1088] D=n621
+ CK=CTS_10 RB=FE_OCPN9741_FE_OFN344_i_reset_n_i
XBuffer/data_buffer_reg[1089] QDFFRBN $PINS Q=Buffer/data_buffer[1089] D=n620
+ CK=CTS_7 RB=FE_OFN425_i_reset_n_i
XBuffer/data_buffer_reg[1090] QDFFRBN $PINS Q=Buffer/data_buffer[1090] D=n619
+ CK=CTS_7 RB=FE_OFN425_i_reset_n_i
XBuffer/data_buffer_reg[1091] QDFFRBN $PINS Q=Buffer/data_buffer[1091] D=n618
+ CK=CTS_7 RB=FE_OFN1064_i_reset_n_i
XBuffer/data_buffer_reg[1092] QDFFRBN $PINS Q=Buffer/data_buffer[1092] D=n617
+ CK=CTS_7 RB=FE_OFN500_i_reset_n_i
XBuffer/data_buffer_reg[1093] QDFFRBN $PINS Q=Buffer/data_buffer[1093] D=n616
+ CK=CTS_7 RB=FE_OFN425_i_reset_n_i
XBuffer/data_buffer_reg[1094] QDFFRBN $PINS Q=Buffer/data_buffer[1094] D=n615
+ CK=CTS_6 RB=FE_OFN1095_i_reset_n_i
XBuffer/data_buffer_reg[1095] QDFFRBN $PINS Q=Buffer/data_buffer[1095] D=n614
+ CK=CTS_4 RB=FE_OFN1095_i_reset_n_i
XBuffer/data_buffer_reg[1096] QDFFRBN $PINS Q=Buffer/data_buffer[1096] D=n613
+ CK=CTS_7 RB=FE_OFN731_i_reset_n_i
XBuffer/data_buffer_reg[1097] QDFFRBN $PINS Q=Buffer/data_buffer[1097] D=n612
+ CK=CTS_7 RB=FE_OFN425_i_reset_n_i
XBuffer/data_buffer_reg[1098] QDFFRBN $PINS Q=Buffer/data_buffer[1098] D=n611
+ CK=CTS_7 RB=FE_OCPN9741_FE_OFN344_i_reset_n_i
XBuffer/data_buffer_reg[1099] QDFFRBN $PINS Q=Buffer/data_buffer[1099] D=n610
+ CK=CTS_7 RB=FE_OFN1064_i_reset_n_i
XBuffer/data_buffer_reg[1100] QDFFRBN $PINS Q=Buffer/data_buffer[1100] D=n609
+ CK=CTS_7 RB=FE_OFN500_i_reset_n_i
XBuffer/data_buffer_reg[1101] QDFFRBN $PINS Q=Buffer/data_buffer[1101] D=n608
+ CK=CTS_7 RB=FE_OFN500_i_reset_n_i
XBuffer/data_buffer_reg[1102] QDFFRBN $PINS Q=Buffer/data_buffer[1102] D=n607
+ CK=CTS_7 RB=FE_OFN1064_i_reset_n_i
XBuffer/data_buffer_reg[1103] QDFFRBN $PINS Q=Buffer/data_buffer[1103] D=n606
+ CK=CTS_7 RB=FE_OFN1064_i_reset_n_i
XBuffer/data_buffer_reg[1104] QDFFRBN $PINS Q=Buffer/data_buffer[1104] D=n605
+ CK=CTS_10 RB=FE_OCPN9741_FE_OFN344_i_reset_n_i
XBuffer/data_buffer_reg[1105] QDFFRBN $PINS Q=Buffer/data_buffer[1105] D=n604
+ CK=CTS_7 RB=FE_OFN601_i_reset_n_i
XBuffer/data_buffer_reg[1106] QDFFRBN $PINS Q=Buffer/data_buffer[1106] D=n603
+ CK=CTS_7 RB=FE_OCPN9741_FE_OFN344_i_reset_n_i
XBuffer/data_buffer_reg[1107] QDFFRBN $PINS Q=Buffer/data_buffer[1107] D=n602
+ CK=CTS_7 RB=FE_OFN1020_i_reset_n_i
XBuffer/data_buffer_reg[1108] QDFFRBN $PINS Q=Buffer/data_buffer[1108] D=n601
+ CK=CTS_7 RB=FE_OFN500_i_reset_n_i
XBuffer/data_buffer_reg[1109] QDFFRBN $PINS Q=Buffer/data_buffer[1109] D=n600
+ CK=CTS_7 RB=FE_OFN601_i_reset_n_i
XBuffer/data_buffer_reg[1110] QDFFRBN $PINS Q=Buffer/data_buffer[1110] D=n599
+ CK=CTS_7 RB=FE_OFN1020_i_reset_n_i
XBuffer/data_buffer_reg[1111] QDFFRBN $PINS Q=Buffer/data_buffer[1111] D=n598
+ CK=CTS_7 RB=FE_OFN1095_i_reset_n_i
XBuffer/data_buffer_reg[1112] QDFFRBN $PINS Q=Buffer/data_buffer[1112] D=n597
+ CK=CTS_7 RB=FE_OFN424_i_reset_n_i
XBuffer/data_buffer_reg[1113] QDFFRBN $PINS Q=Buffer/data_buffer[1113] D=n596
+ CK=CTS_7 RB=FE_OFN601_i_reset_n_i
XBuffer/data_buffer_reg[1114] QDFFRBN $PINS Q=Buffer/data_buffer[1114] D=n595
+ CK=CTS_7 RB=FE_OFN731_i_reset_n_i
XBuffer/data_buffer_reg[1115] QDFFRBN $PINS Q=Buffer/data_buffer[1115] D=n594
+ CK=CTS_7 RB=FE_OFN1019_i_reset_n_i
XBuffer/data_buffer_reg[1116] QDFFRBN $PINS Q=Buffer/data_buffer[1116] D=n593
+ CK=CTS_7 RB=FE_OFN1020_i_reset_n_i
XBuffer/data_buffer_reg[1117] QDFFRBN $PINS Q=Buffer/data_buffer[1117] D=n592
+ CK=CTS_7 RB=FE_OFN500_i_reset_n_i
XBuffer/data_buffer_reg[1118] QDFFRBN $PINS Q=Buffer/data_buffer[1118] D=n591
+ CK=CTS_7 RB=FE_OFN1020_i_reset_n_i
XBuffer/data_buffer_reg[1119] QDFFRBN $PINS Q=Buffer/data_buffer[1119] D=n590
+ CK=CTS_7 RB=FE_OFN1095_i_reset_n_i
XBuffer/data_buffer_reg[1120] QDFFRBN $PINS Q=Buffer/data_buffer[1120] D=n589
+ CK=CTS_10 RB=FE_OFN349_i_reset_n_i
XBuffer/data_buffer_reg[1121] QDFFRBN $PINS Q=Buffer/data_buffer[1121] D=n588
+ CK=CTS_7 RB=FE_OFN731_i_reset_n_i
XBuffer/data_buffer_reg[1122] QDFFRBN $PINS Q=Buffer/data_buffer[1122] D=n587
+ CK=CTS_7 RB=FE_OFN731_i_reset_n_i
XBuffer/data_buffer_reg[1123] QDFFRBN $PINS Q=Buffer/data_buffer[1123] D=n586
+ CK=CTS_7 RB=FE_OFN1019_i_reset_n_i
XBuffer/data_buffer_reg[1124] QDFFRBN $PINS Q=Buffer/data_buffer[1124] D=n585
+ CK=CTS_7 RB=FE_OFN732_i_reset_n_i
XBuffer/data_buffer_reg[1125] QDFFRBN $PINS Q=Buffer/data_buffer[1125] D=n584
+ CK=CTS_7 RB=FE_OFN601_i_reset_n_i
XBuffer/data_buffer_reg[1126] QDFFRBN $PINS Q=Buffer/data_buffer[1126] D=n583
+ CK=CTS_7 RB=FE_OFN1020_i_reset_n_i
XBuffer/data_buffer_reg[1127] QDFFRBN $PINS Q=Buffer/data_buffer[1127] D=n582
+ CK=CTS_6 RB=FE_OFN397_i_reset_n_i
XBuffer/data_buffer_reg[1128] QDFFRBN $PINS Q=Buffer/data_buffer[1128] D=n581
+ CK=CTS_10 RB=FE_OFN349_i_reset_n_i
XBuffer/data_buffer_reg[1129] QDFFRBN $PINS Q=Buffer/data_buffer[1129] D=n580
+ CK=CTS_10 RB=FE_OFN424_i_reset_n_i
XBuffer/data_buffer_reg[1130] QDFFRBN $PINS Q=Buffer/data_buffer[1130] D=n579
+ CK=CTS_7 RB=FE_OFN731_i_reset_n_i
XBuffer/data_buffer_reg[1131] QDFFRBN $PINS Q=Buffer/data_buffer[1131] D=n578
+ CK=CTS_7 RB=FE_OFN858_i_reset_n_i
XBuffer/data_buffer_reg[1132] QDFFRBN $PINS Q=Buffer/data_buffer[1132] D=n577
+ CK=CTS_7 RB=FE_OFN732_i_reset_n_i
XBuffer/data_buffer_reg[1133] QDFFRBN $PINS Q=Buffer/data_buffer[1133] D=n576
+ CK=CTS_7 RB=FE_OFN732_i_reset_n_i
XBuffer/data_buffer_reg[1134] QDFFRBN $PINS Q=Buffer/data_buffer[1134] D=n575
+ CK=CTS_7 RB=FE_OFN858_i_reset_n_i
XBuffer/data_buffer_reg[1135] QDFFRBN $PINS Q=Buffer/data_buffer[1135] D=n574
+ CK=CTS_6 RB=FE_OFN459_i_reset_n_i
XBuffer/data_buffer_reg[1136] QDFFRBN $PINS Q=Buffer/data_buffer[1136] D=n573
+ CK=CTS_7 RB=FE_OFN349_i_reset_n_i
XBuffer/data_buffer_reg[1137] QDFFRBN $PINS Q=Buffer/data_buffer[1137] D=n572
+ CK=CTS_10 RB=FE_OFN1017_i_reset_n_i
XBuffer/data_buffer_reg[1138] QDFFRBN $PINS Q=Buffer/data_buffer[1138] D=n571
+ CK=CTS_10 RB=FE_OFN1017_i_reset_n_i
XBuffer/data_buffer_reg[1139] QDFFRBN $PINS Q=Buffer/data_buffer[1139] D=n570
+ CK=CTS_7 RB=FE_OFN1019_i_reset_n_i
XBuffer/data_buffer_reg[1140] QDFFRBN $PINS Q=Buffer/data_buffer[1140] D=n569
+ CK=CTS_10 RB=FE_OFN732_i_reset_n_i
XBuffer/data_buffer_reg[1141] QDFFRBN $PINS Q=Buffer/data_buffer[1141] D=n568
+ CK=CTS_7 RB=FE_OFN732_i_reset_n_i
XBuffer/data_buffer_reg[1142] QDFFRBN $PINS Q=Buffer/data_buffer[1142] D=n567
+ CK=CTS_10 RB=FE_OFN858_i_reset_n_i
XBuffer/data_buffer_reg[1143] QDFFRBN $PINS Q=Buffer/data_buffer[1143] D=n566
+ CK=CTS_7 RB=FE_OFN554_i_reset_n_i
XBuffer/data_buffer_reg[1144] QDFFRBN $PINS Q=Buffer/data_buffer[1144] D=n565
+ CK=CTS_10 RB=FE_OFN424_i_reset_n_i
XBuffer/data_buffer_reg[1145] QDFFRBN $PINS Q=Buffer/data_buffer[1145] D=n564
+ CK=CTS_10 RB=FE_OFN1017_i_reset_n_i
XBuffer/data_buffer_reg[1146] QDFFRBN $PINS Q=Buffer/data_buffer[1146] D=n563
+ CK=CTS_10 RB=FE_OFN949_i_reset_n_i
XBuffer/data_buffer_reg[1147] QDFFRBN $PINS Q=Buffer/data_buffer[1147] D=n562
+ CK=CTS_13 RB=FE_OFN554_i_reset_n_i
XBuffer/data_buffer_reg[1148] QDFFRBN $PINS Q=Buffer/data_buffer[1148] D=n561
+ CK=CTS_10 RB=FE_OFN949_i_reset_n_i
XBuffer/data_buffer_reg[1149] QDFFRBN $PINS Q=Buffer/data_buffer[1149] D=n560
+ CK=CTS_10 RB=FE_OFN1017_i_reset_n_i
XBuffer/data_buffer_reg[1150] QDFFRBN $PINS Q=Buffer/data_buffer[1150] D=n559
+ CK=CTS_13 RB=FE_OFN950_i_reset_n_i
XBuffer/data_buffer_reg[1151] QDFFRBN $PINS Q=Buffer/data_buffer[1151] D=n558
+ CK=CTS_7 RB=FE_OFN554_i_reset_n_i
XBuffer/data_buffer_reg[1152] QDFFRBN $PINS Q=Buffer/data_buffer[1152] D=n557
+ CK=CTS_10 RB=FE_OFN424_i_reset_n_i
XBuffer/data_buffer_reg[1153] QDFFRBN $PINS Q=Buffer/data_buffer[1153] D=n556
+ CK=CTS_10 RB=FE_OFN1016_i_reset_n_i
XBuffer/data_buffer_reg[1154] QDFFRBN $PINS Q=Buffer/data_buffer[1154] D=n555
+ CK=CTS_10 RB=FE_OFN1016_i_reset_n_i
XBuffer/data_buffer_reg[1155] QDFFRBN $PINS Q=Buffer/data_buffer[1155] D=n554
+ CK=CTS_6 RB=FE_OFN926_i_reset_n_i
XBuffer/data_buffer_reg[1156] QDFFRBN $PINS Q=Buffer/data_buffer[1156] D=n553
+ CK=CTS_10 RB=FE_OFN949_i_reset_n_i
XBuffer/data_buffer_reg[1157] QDFFRBN $PINS Q=Buffer/data_buffer[1157] D=n552
+ CK=CTS_10 RB=FE_OFN1016_i_reset_n_i
XBuffer/data_buffer_reg[1158] QDFFRBN $PINS Q=Buffer/data_buffer[1158] D=n551
+ CK=CTS_13 RB=FE_OFN995_i_reset_n_i
XBuffer/data_buffer_reg[1159] QDFFRBN $PINS Q=Buffer/data_buffer[1159] D=n550
+ CK=CTS_6 RB=FE_OFN459_i_reset_n_i
XBuffer/data_buffer_reg[1160] QDFFRBN $PINS Q=Buffer/data_buffer[1160] D=n549
+ CK=CTS_10 RB=FE_OFN499_i_reset_n_i
XBuffer/data_buffer_reg[1161] QDFFRBN $PINS Q=Buffer/data_buffer[1161] D=n548
+ CK=CTS_10 RB=FE_OFN370_i_reset_n_i
XBuffer/data_buffer_reg[1162] QDFFRBN $PINS Q=Buffer/data_buffer[1162] D=n547
+ CK=CTS_13 RB=FE_OFN1703_n
XBuffer/data_buffer_reg[1163] QDFFRBN $PINS Q=Buffer/data_buffer[1163] D=n546
+ CK=CTS_6 RB=FE_OFN926_i_reset_n_i
XBuffer/data_buffer_reg[1164] QDFFRBN $PINS Q=Buffer/data_buffer[1164] D=n545
+ CK=CTS_13 RB=FE_OFN950_i_reset_n_i
XBuffer/data_buffer_reg[1165] QDFFRBN $PINS Q=Buffer/data_buffer[1165] D=n544
+ CK=CTS_10 RB=FE_OFN1016_i_reset_n_i
XBuffer/data_buffer_reg[1166] QDFFRBN $PINS Q=Buffer/data_buffer[1166] D=n543
+ CK=CTS_13 RB=FE_OFN926_i_reset_n_i
XBuffer/data_buffer_reg[1167] QDFFRBN $PINS Q=Buffer/data_buffer[1167] D=n542
+ CK=CTS_6 RB=FE_OFN807_i_reset_n_i
XBuffer/data_buffer_reg[1168] QDFFRBN $PINS Q=Buffer/data_buffer[1168] D=n541
+ CK=CTS_10 RB=FE_OFN499_i_reset_n_i
XBuffer/data_buffer_reg[1169] QDFFRBN $PINS Q=Buffer/data_buffer[1169] D=n540
+ CK=CTS_13 RB=FE_OFN491_i_reset_n_i
XBuffer/data_buffer_reg[1170] QDFFRBN $PINS Q=Buffer/data_buffer[1170] D=n539
+ CK=CTS_13 RB=FE_OFN1703_n
XBuffer/data_buffer_reg[1171] QDFFRBN $PINS Q=Buffer/data_buffer[1171] D=n538
+ CK=CTS_13 RB=FE_OFN926_i_reset_n_i
XBuffer/data_buffer_reg[1172] QDFFRBN $PINS Q=Buffer/data_buffer[1172] D=n537
+ CK=CTS_13 RB=FE_OFN419_i_reset_n_i
XBuffer/data_buffer_reg[1173] QDFFRBN $PINS Q=Buffer/data_buffer[1173] D=n536
+ CK=CTS_13 RB=FE_OFN419_i_reset_n_i
XBuffer/data_buffer_reg[1174] QDFFRBN $PINS Q=Buffer/data_buffer[1174] D=n535
+ CK=CTS_13 RB=FE_OFN1703_n
XBuffer/data_buffer_reg[1175] QDFFRBN $PINS Q=Buffer/data_buffer[1175] D=n534
+ CK=CTS_6 RB=FE_OFN807_i_reset_n_i
XBuffer/data_buffer_reg[1176] QDFFRBN $PINS Q=Buffer/data_buffer[1176] D=n533
+ CK=CTS_10 RB=FE_OFN600_i_reset_n_i
XBuffer/data_buffer_reg[1177] QDFFRBN $PINS Q=Buffer/data_buffer[1177] D=n532
+ CK=CTS_13 RB=FE_OFN491_i_reset_n_i
XBuffer/data_buffer_reg[1178] QDFFRBN $PINS Q=Buffer/data_buffer[1178] D=n531
+ CK=CTS_13 RB=FE_OFN1059_i_reset_n_i
XBuffer/data_buffer_reg[1179] QDFFRBN $PINS Q=Buffer/data_buffer[1179] D=n530
+ CK=CTS_13 RB=FE_OFN1059_i_reset_n_i
XBuffer/data_buffer_reg[1180] QDFFRBN $PINS Q=Buffer/data_buffer[1180] D=n529
+ CK=CTS_13 RB=FE_OFN368_i_reset_n_i
XBuffer/data_buffer_reg[1181] QDFFRBN $PINS Q=Buffer/data_buffer[1181] D=n528
+ CK=CTS_13 RB=FE_OFN491_i_reset_n_i
XBuffer/data_buffer_reg[1182] QDFFRBN $PINS Q=Buffer/data_buffer[1182] D=n527
+ CK=CTS_13 RB=FE_OFN1703_n
XBuffer/data_buffer_reg[1183] QDFFRBN $PINS Q=Buffer/data_buffer[1183] D=n526
+ CK=CTS_6 RB=FE_OFN807_i_reset_n_i
XBuffer/data_buffer_reg[1184] QDFFRBN $PINS Q=Buffer/data_buffer[1184] D=n525
+ CK=CTS_10 RB=FE_OFN600_i_reset_n_i
XBuffer/data_buffer_reg[1185] QDFFRBN $PINS Q=Buffer/data_buffer[1185] D=n524
+ CK=CTS_13 RB=FE_OFN844_i_reset_n_i
XBuffer/data_buffer_reg[1186] QDFFRBN $PINS Q=Buffer/data_buffer[1186] D=n523
+ CK=CTS_16 RB=FE_OFN712_i_reset_n_i
XBuffer/data_buffer_reg[1187] QDFFRBN $PINS Q=Buffer/data_buffer[1187] D=n522
+ CK=CTS_16 RB=FE_OFN712_i_reset_n_i
XBuffer/data_buffer_reg[1188] QDFFRBN $PINS Q=Buffer/data_buffer[1188] D=n521
+ CK=CTS_13 RB=FE_OFN416_i_reset_n_i
XBuffer/data_buffer_reg[1189] QDFFRBN $PINS Q=Buffer/data_buffer[1189] D=n520
+ CK=CTS_13 RB=FE_OFN716_i_reset_n_i
XBuffer/data_buffer_reg[1190] QDFFRBN $PINS Q=Buffer/data_buffer[1190] D=n519
+ CK=CTS_13 RB=FE_OFN844_i_reset_n_i
XBuffer/data_buffer_reg[1191] QDFFRBN $PINS Q=Buffer/data_buffer[1191] D=n518
+ CK=CTS_16 RB=FE_OFN712_i_reset_n_i
XBuffer/data_buffer_reg[1192] QDFFRBN $PINS Q=Buffer/data_buffer[1192] D=n517
+ CK=CTS_10 RB=FE_OFN488_i_reset_n_i
XBuffer/data_buffer_reg[1193] QDFFRBN $PINS Q=Buffer/data_buffer[1193] D=n516
+ CK=CTS_13 RB=FE_OFN845_i_reset_n_i
XBuffer/data_buffer_reg[1194] QDFFRBN $PINS Q=Buffer/data_buffer[1194] D=n515
+ CK=CTS_16 RB=FE_OFN590_i_reset_n_i
XBuffer/data_buffer_reg[1195] QDFFRBN $PINS Q=Buffer/data_buffer[1195] D=n514
+ CK=CTS_16 RB=FE_OFN590_i_reset_n_i
XBuffer/data_buffer_reg[1196] QDFFRBN $PINS Q=Buffer/data_buffer[1196] D=n513
+ CK=CTS_16 RB=FE_OFN714_i_reset_n_i
XBuffer/data_buffer_reg[1197] QDFFRBN $PINS Q=Buffer/data_buffer[1197] D=n512
+ CK=CTS_13 RB=FE_OFN845_i_reset_n_i
XBuffer/data_buffer_reg[1198] QDFFRBN $PINS Q=Buffer/data_buffer[1198] D=n511
+ CK=CTS_16 RB=FE_OFN844_i_reset_n_i
XBuffer/data_buffer_reg[1199] QDFFRBN $PINS Q=Buffer/data_buffer[1199] D=n510
+ CK=CTS_16 RB=FE_OFN589_i_reset_n_i
XBuffer/data_buffer_reg[1200] QDFFRBN $PINS Q=Buffer/data_buffer[1200] D=n509
+ CK=CTS_39 RB=FE_OFN846_i_reset_n_i
XBuffer/data_buffer_reg[1201] QDFFRBN $PINS Q=Buffer/data_buffer[1201] D=n508
+ CK=CTS_16 RB=FE_OFN717_i_reset_n_i
XBuffer/data_buffer_reg[1202] QDFFRBN $PINS Q=Buffer/data_buffer[1202] D=n507
+ CK=CTS_20 RB=FE_OFN718_i_reset_n_i
XBuffer/data_buffer_reg[1203] QDFFRBN $PINS Q=Buffer/data_buffer[1203] D=n506
+ CK=CTS_16 RB=FE_OFN842_i_reset_n_i
XBuffer/data_buffer_reg[1204] QDFFRBN $PINS Q=Buffer/data_buffer[1204] D=n505
+ CK=CTS_16 RB=FE_OFN592_i_reset_n_i
XBuffer/data_buffer_reg[1205] QDFFRBN $PINS Q=Buffer/data_buffer[1205] D=n504
+ CK=CTS_16 RB=FE_OFN713_i_reset_n_i
XBuffer/data_buffer_reg[1206] QDFFRBN $PINS Q=Buffer/data_buffer[1206] D=n503
+ CK=CTS_12 RB=FE_OFN944_i_reset_n_i
XBuffer/data_buffer_reg[1207] QDFFRBN $PINS Q=Buffer/data_buffer[1207] D=n502
+ CK=CTS_16 RB=FE_OFN842_i_reset_n_i
XBuffer/data_buffer_reg[1208] QDFFRBN $PINS Q=Buffer/data_buffer[1208] D=n501
+ CK=CTS_13 RB=FE_OFN591_i_reset_n_i
Xdata_2_r_reg[8] QDFFRBN $PINS Q=data_2_r[8] D=n1808 CK=CTS_20
+ RB=FE_OFN1013_i_reset_n_i
XBuffer/data_buffer_reg[1209] QDFFRBN $PINS Q=Buffer/data_buffer[1209] D=n500
+ CK=CTS_20 RB=FE_OFN428_i_reset_n_i
Xdata_2_r_reg[9] QDFFRBN $PINS Q=data_2_r[9] D=n1809 CK=CTS_20
+ RB=FE_OFN737_i_reset_n_i
XBuffer/data_buffer_reg[1210] QDFFRBN $PINS Q=Buffer/data_buffer[1210] D=n499
+ CK=CTS_20 RB=FE_OFN428_i_reset_n_i
Xdata_2_r_reg[10] QDFFRBN $PINS Q=data_2_r[10] D=n1810 CK=CTS_20
+ RB=FE_OFN737_i_reset_n_i
XBuffer/data_buffer_reg[1211] QDFFRBN $PINS Q=Buffer/data_buffer[1211] D=n498
+ CK=CTS_30 RB=FE_OFN718_i_reset_n_i
Xdata_2_r_reg[11] QDFFRBN $PINS Q=data_2_r[11] D=n1811 CK=CTS_20
+ RB=FE_OFN737_i_reset_n_i
XBuffer/data_buffer_reg[1212] QDFFRBN $PINS Q=Buffer/data_buffer[1212] D=n497
+ CK=CTS_20 RB=FE_OFN428_i_reset_n_i
Xdata_2_r_reg[12] QDFFRBN $PINS Q=data_2_r[12] D=n1812 CK=CTS_20
+ RB=FE_OFN737_i_reset_n_i
XBuffer/data_buffer_reg[1213] QDFFRBN $PINS Q=Buffer/data_buffer[1213] D=n496
+ CK=CTS_12 RB=FE_OFN837_i_reset_n_i
Xdata_2_r_reg[13] QDFFRBN $PINS Q=data_2_r[13] D=n1813 CK=CTS_20
+ RB=FE_OFN865_i_reset_n_i
XBuffer/data_buffer_reg[1214] QDFFRBN $PINS Q=Buffer/data_buffer[1214] D=n495
+ CK=CTS_12 RB=FE_OFN944_i_reset_n_i
XBuffer/data_buffer_reg[1215] QDFFRBN $PINS Q=Buffer/data_buffer[1215] D=n494
+ CK=CTS_20 RB=FE_OFN508_i_reset_n_i
Xdata_2_r_reg[15] QDFFRBN $PINS Q=data_2_r[15] D=n1815 CK=CTS_20
+ RB=FE_OFN865_i_reset_n_i
XBuffer/data_buffer_reg[1216] QDFFRBN $PINS Q=Buffer/data_buffer[1216] D=n493
+ CK=CTS_13 RB=FE_OFN582_i_reset_n_i
XBuffer/data_buffer_reg[1217] QDFFRBN $PINS Q=Buffer/data_buffer[1217] D=n492
+ CK=CTS_20 RB=FE_OFN605_i_reset_n_i
XBuffer/data_buffer_reg[1218] QDFFRBN $PINS Q=Buffer/data_buffer[1218] D=n491
+ CK=CTS_20 RB=FE_OFN735_i_reset_n_i
XBuffer/data_buffer_reg[1219] QDFFRBN $PINS Q=Buffer/data_buffer[1219] D=n490
+ CK=CTS_20 RB=FE_OFN607_i_reset_n_i
XBuffer/data_buffer_reg[1220] QDFFRBN $PINS Q=Buffer/data_buffer[1220] D=n489
+ CK=CTS_20 RB=FE_OFN606_i_reset_n_i
Xdata_2_r_reg[20] QDFFRBN $PINS Q=data_2_r[20] D=n1819 CK=CTS_24
+ RB=FE_OFN1022_i_reset_n_i
XBuffer/data_buffer_reg[1221] QDFFRBN $PINS Q=Buffer/data_buffer[1221] D=n488
+ CK=CTS_12 RB=FE_OFN838_i_reset_n_i
XBuffer/data_buffer_reg[1222] QDFFRBN $PINS Q=Buffer/data_buffer[1222] D=n487
+ CK=CTS_12 RB=FE_OFN838_i_reset_n_i
XBuffer/data_buffer_reg[1223] QDFFRBN $PINS Q=Buffer/data_buffer[1223] D=n486
+ CK=CTS_20 RB=FE_OFN606_i_reset_n_i
XBuffer/data_buffer_reg[1224] QDFFRBN $PINS Q=Buffer/data_buffer[1224] D=n485
+ CK=CTS_13 RB=FE_OFN582_i_reset_n_i
Xdata_2_r_reg[24] QDFFRBN $PINS Q=data_2_r[24] D=n1823 CK=CTS_24
+ RB=FE_OFN864_i_reset_n_i
XBuffer/data_buffer_reg[1225] QDFFRBN $PINS Q=Buffer/data_buffer[1225] D=n484
+ CK=CTS_12 RB=FE_OFN605_i_reset_n_i
Xdata_2_r_reg[25] QDFFRBN $PINS Q=data_2_r[25] D=n1824 CK=CTS_55
+ RB=FE_OFN870_i_reset_n_i
XBuffer/data_buffer_reg[1226] QDFFRBN $PINS Q=Buffer/data_buffer[1226] D=n483
+ CK=CTS_24 RB=FE_OFN864_i_reset_n_i
Xdata_2_r_reg[26] QDFFRBN $PINS Q=data_2_r[26] D=n1825 CK=CTS_55
+ RB=FE_OFN870_i_reset_n_i
XBuffer/data_buffer_reg[1227] QDFFRBN $PINS Q=Buffer/data_buffer[1227] D=n482
+ CK=CTS_20 RB=FE_OFN735_i_reset_n_i
Xdata_2_r_reg[27] QDFFRBN $PINS Q=data_2_r[27] D=n1826 CK=CTS_55
+ RB=FE_OFN743_i_reset_n_i
XBuffer/data_buffer_reg[1235] QDFFRBN $PINS Q=Buffer/data_buffer[1235] D=n481
+ CK=CTS_12 RB=FE_OFN512_i_reset_n_i
XBuffer/data_buffer_reg[1243] QDFFRBN $PINS Q=Buffer/data_buffer[1243] D=n480
+ CK=CTS_12 RB=FE_OCPN9786_FE_OFN350_i_reset_n_i
Xdata_2_r_reg[43] QDFFRBP $PINS Q=data_2_r[43] D=n1841 CK=CTS_38
+ RB=FE_OFN744_i_reset_n_i
XBuffer/data_buffer_reg[1228] QDFFRBN $PINS Q=Buffer/data_buffer[1228] D=n479
+ CK=CTS_55 RB=FE_OFN870_i_reset_n_i
Xdata_2_r_reg[28] QDFFRBN $PINS Q=data_2_r[28] D=n1827 CK=CTS_55
+ RB=FE_OFN741_i_reset_n_i
XBuffer/data_buffer_reg[1236] QDFFRBN $PINS Q=Buffer/data_buffer[1236] D=n478
+ CK=CTS_12 RB=FE_OFN615_i_reset_n_i
XBuffer/data_buffer_reg[1244] QDFFRBN $PINS Q=Buffer/data_buffer[1244] D=n477
+ CK=CTS_38 RB=FE_OFN873_i_reset_n_i
Xdata_2_r_reg[44] QDFFRBN $PINS Q=data_2_r[44] D=n1842 CK=CTS_38
+ RB=FE_OFN745_i_reset_n_i
XBuffer/data_buffer_reg[1229] QDFFRBN $PINS Q=Buffer/data_buffer[1229] D=n476
+ CK=CTS_12 RB=FE_OFN836_i_reset_n_i
Xdata_2_r_reg[29] QDFFRBN $PINS Q=data_2_r[29] D=n1828 CK=CTS_55
+ RB=FE_OFN511_i_reset_n_i
XBuffer/data_buffer_reg[1237] QDFFRBN $PINS Q=Buffer/data_buffer[1237] D=n475
+ CK=CTS_12 RB=FE_OCPN9786_FE_OFN350_i_reset_n_i
XBuffer/data_buffer_reg[1245] QDFFRBN $PINS Q=Buffer/data_buffer[1245] D=n474
+ CK=CTS_38 RB=FE_OFN841_i_reset_n_i
Xdata_2_r_reg[45] QDFFRBN $PINS Q=data_2_r[45] D=n1843 CK=CTS_38
+ RB=FE_OFN745_i_reset_n_i
XBuffer/data_buffer_reg[1230] QDFFRBN $PINS Q=Buffer/data_buffer[1230] D=n473
+ CK=CTS_12 RB=FE_OFN742_i_reset_n_i
Xdata_2_r_reg[30] QDFFRBN $PINS Q=data_2_r[30] D=n1829 CK=CTS_55
+ RB=FE_OFN741_i_reset_n_i
XBuffer/data_buffer_reg[1238] QDFFRBN $PINS Q=Buffer/data_buffer[1238] D=n472
+ CK=CTS_12 RB=FE_OFN512_i_reset_n_i
Xdata_2_r_reg[38] QDFFRBN $PINS Q=data_2_r[38] D=n1836 CK=CTS_38
+ RB=FE_OFN744_i_reset_n_i
XBuffer/data_buffer_reg[1246] QDFFRBN $PINS Q=Buffer/data_buffer[1246] D=n471
+ CK=CTS_38 RB=FE_OFN1010_i_reset_n_i
Xdata_2_r_reg[46] QDFFRBN $PINS Q=data_2_r[46] D=n1844 CK=CTS_38
+ RB=FE_OFN745_i_reset_n_i
XBuffer/data_buffer_reg[1231] QDFFRBN $PINS Q=Buffer/data_buffer[1231] D=n470
+ CK=CTS_55 RB=FE_OFN743_i_reset_n_i
XBuffer/data_buffer_reg[1239] QDFFRBN $PINS Q=Buffer/data_buffer[1239] D=n469
+ CK=CTS_12 RB=FE_OFN615_i_reset_n_i
Xdata_2_r_reg[39] QDFFRBN $PINS Q=data_2_r[39] D=n1837 CK=CTS_38
+ RB=FE_OFN614_i_reset_n_i
XBuffer/data_buffer_reg[1247] QDFFRBN $PINS Q=Buffer/data_buffer[1247] D=n468
+ CK=CTS_38 RB=FE_OFN873_i_reset_n_i
Xdata_2_r_reg[47] QDFFRBN $PINS Q=data_2_r[47] D=n1845 CK=CTS_38
+ RB=FE_OFN745_i_reset_n_i
XBuffer/data_buffer_reg[1232] QDFFRBN $PINS Q=Buffer/data_buffer[1232] D=n467
+ CK=CTS_12 RB=FE_OFN584_i_reset_n_i
XBuffer/data_buffer_reg[1240] QDFFRBN $PINS Q=Buffer/data_buffer[1240] D=n466
+ CK=CTS_38 RB=FE_OFN708_i_reset_n_i
Xdata_2_r_reg[40] QDFFRBN $PINS Q=data_2_r[40] D=n1838 CK=CTS_38
+ RB=FE_OFN614_i_reset_n_i
XBuffer/data_buffer_reg[1233] QDFFRBN $PINS Q=Buffer/data_buffer[1233] D=n465
+ CK=CTS_12 RB=FE_OFN836_i_reset_n_i
Xdata_2_r_reg[33] QDFFRBN $PINS Q=data_2_r[33] D=n1831 CK=CTS_12
+ RB=FE_OFN513_i_reset_n_i
XBuffer/data_buffer_reg[1241] QDFFRBN $PINS Q=Buffer/data_buffer[1241] D=n464
+ CK=CTS_12 RB=FE_OFN836_i_reset_n_i
Xdata_2_r_reg[41] QDFFRBN $PINS Q=data_2_r[41] D=n1839 CK=CTS_38
+ RB=FE_OFN744_i_reset_n_i
XBuffer/data_buffer_reg[1234] QDFFRBN $PINS Q=Buffer/data_buffer[1234] D=n463
+ CK=CTS_12 RB=FE_OFN613_i_reset_n_i
XBuffer/data_buffer_reg[1242] QDFFRBN $PINS Q=Buffer/data_buffer[1242] D=n462
+ CK=CTS_12 RB=FE_OFN513_i_reset_n_i
Xdata_2_r_reg[42] QDFFRBN $PINS Q=data_2_r[42] D=n1840 CK=CTS_38
+ RB=FE_OFN614_i_reset_n_i
XBuffer/weight_buffer_reg[31] QDFFRBN $PINS Q=weight_1_w[7] D=n458 CK=CTS_28
+ RB=FE_OFN769_i_reset_n_i
XBuffer/weight_buffer_reg[39] QDFFRBN $PINS Q=weight_1_w[15] D=n457 CK=CTS_28
+ RB=FE_OFN445_i_reset_n_i
XBuffer/weight_buffer_reg[47] QDFFRBN $PINS Q=weight_1_w[23] D=n456 CK=CTS_28
+ RB=FE_OFN445_i_reset_n_i
XBuffer/weight_buffer_reg[6] QDFFRBN $PINS Q=weight_0_w[6] D=n453 CK=CTS_2
+ RB=FE_OFN381_i_reset_n_i
XBuffer/weight_buffer_reg[14] QDFFRBN $PINS Q=weight_0_w[14] D=n452 CK=CTS_2
+ RB=FE_OFN697_i_reset_n_i
XBuffer/weight_buffer_reg[30] QDFFRBN $PINS Q=weight_1_w[6] D=n450 CK=CTS_28
+ RB=FE_OFN444_i_reset_n_i
XBuffer/weight_buffer_reg[38] QDFFRBN $PINS Q=weight_1_w[14] D=n449 CK=CTS_28
+ RB=FE_OFN386_i_reset_n_i
XBuffer/weight_buffer_reg[46] QDFFRBN $PINS Q=weight_1_w[22] D=n448 CK=CTS_28
+ RB=FE_OFN643_i_reset_n_i
XBuffer/weight_buffer_reg[54] QDFFRBN $PINS Q=weight_2_w[6] D=n447 CK=CTS_33
+ RB=FE_OFN560_i_reset_n_i
XBuffer/weight_buffer_reg[62] QDFFRBN $PINS Q=weight_2_w[14] D=n446 CK=CTS_55
+ RB=FE_OFN610_i_reset_n_i
XBuffer/weight_buffer_reg[5] QDFFRBN $PINS Q=weight_0_w[5] D=n444 CK=CTS_2
+ RB=FE_OFN408_i_reset_n_i
XBuffer/weight_buffer_reg[13] QDFFRBN $PINS Q=weight_0_w[13] D=n443 CK=CTS_2
+ RB=FE_OFN474_i_reset_n_i
XBuffer/weight_buffer_reg[21] QDFFRBN $PINS Q=weight_0_w[21] D=n442 CK=CTS_2
+ RB=FE_OFN473_i_reset_n_i
XBuffer/weight_buffer_reg[29] QDFFRBN $PINS Q=weight_1_w[5] D=n441 CK=CTS_25
+ RB=FE_OFN644_i_reset_n_i
XBuffer/weight_buffer_reg[37] QDFFRBN $PINS Q=weight_1_w[13] D=n440 CK=CTS_28
+ RB=FE_OFN895_i_reset_n_i
XBuffer/weight_buffer_reg[45] QDFFRBN $PINS Q=weight_1_w[21] D=n439 CK=CTS_28
+ RB=FE_OFN642_i_reset_n_i
XBuffer/weight_buffer_reg[53] QDFFRBN $PINS Q=weight_2_w[5] D=n438 CK=CTS_33
+ RB=FE_OFN560_i_reset_n_i
XBuffer/weight_buffer_reg[61] QDFFRBN $PINS Q=weight_2_w[13] D=n437 CK=CTS_24
+ RB=FE_OFN608_i_reset_n_i
XBuffer/weight_buffer_reg[69] QDFFRBN $PINS Q=weight_2_w[21] D=n436 CK=CTS_55
+ RB=FE_OFN871_i_reset_n_i
XBuffer/weight_buffer_reg[4] QDFFRBN $PINS Q=weight_0_w[4] D=n435 CK=CTS_2
+ RB=FE_OFN696_i_reset_n_i
XBuffer/weight_buffer_reg[12] QDFFRBN $PINS Q=weight_0_w[12] D=n434 CK=CTS_2
+ RB=FE_OFN474_i_reset_n_i
XBuffer/weight_buffer_reg[20] QDFFRBN $PINS Q=weight_0_w[20] D=n433 CK=CTS_2
+ RB=FE_OFN473_i_reset_n_i
XBuffer/weight_buffer_reg[28] QDFFRBN $PINS Q=weight_1_w[4] D=n432 CK=CTS_25
+ RB=FE_OFN444_i_reset_n_i
XBuffer/weight_buffer_reg[36] QDFFRBN $PINS Q=weight_1_w[12] D=n431 CK=CTS_51
+ RB=FE_OFN386_i_reset_n_i
XBuffer/weight_buffer_reg[44] QDFFRBN $PINS Q=weight_1_w[20] D=n430 CK=CTS_28
+ RB=FE_OFN643_i_reset_n_i
XBuffer/weight_buffer_reg[52] QDFFRBN $PINS Q=weight_2_w[4] D=n429 CK=CTS_20
+ RB=FE_OFN463_i_reset_n_i
XBuffer/weight_buffer_reg[60] QDFFRBN $PINS Q=weight_2_w[12] D=n428 CK=CTS_55
+ RB=FE_OFN610_i_reset_n_i
XBuffer/weight_buffer_reg[3] QDFFRBN $PINS Q=weight_0_w[3] D=n426 CK=CTS_26
+ RB=FE_OFN477_i_reset_n_i
XBuffer/weight_buffer_reg[11] QDFFRBN $PINS Q=weight_0_w[11] D=n425 CK=CTS_2
+ RB=FE_OFN571_i_reset_n_i
XBuffer/weight_buffer_reg[19] QDFFRBN $PINS Q=weight_0_w[19] D=n424 CK=CTS_26
+ RB=FE_OFN571_i_reset_n_i
XBuffer/weight_buffer_reg[27] QDFFRBN $PINS Q=weight_1_w[3] D=n423 CK=CTS_28
+ RB=FE_OFN895_i_reset_n_i
XBuffer/weight_buffer_reg[35] QDFFRBN $PINS Q=weight_1_w[11] D=n422 CK=CTS_28
+ RB=FE_OFN386_i_reset_n_i
XBuffer/weight_buffer_reg[43] QDFFRBN $PINS Q=weight_1_w[19] D=n421 CK=CTS_28
+ RB=FE_OFN386_i_reset_n_i
XBuffer/weight_buffer_reg[51] QDFFRBN $PINS Q=weight_2_w[3] D=n420 CK=CTS_33
+ RB=FE_OFN560_i_reset_n_i
XBuffer/weight_buffer_reg[59] QDFFRBN $PINS Q=weight_2_w[11] D=n419 CK=CTS_24
+ RB=FE_OFN738_i_reset_n_i
XBuffer/weight_buffer_reg[67] QDFFRBN $PINS Q=weight_2_w[19] D=n418 CK=CTS_55
+ RB=FE_OFN429_i_reset_n_i
XBuffer/weight_buffer_reg[2] QDFFRBN $PINS Q=weight_0_w[2] D=n417 CK=CTS_29
+ RB=FE_OFN437_i_reset_n_i
XBuffer/weight_buffer_reg[10] QDFFRBN $PINS Q=weight_0_w[10] D=n416 CK=CTS_26
+ RB=FE_OFN697_i_reset_n_i
XBuffer/weight_buffer_reg[18] QDFFRBN $PINS Q=weight_0_w[18] D=n415 CK=CTS_26
+ RB=FE_OFN570_i_reset_n_i
XBuffer/weight_buffer_reg[26] QDFFRBN $PINS Q=weight_1_w[2] D=n414 CK=CTS_25
+ RB=FE_OFN644_i_reset_n_i
XBuffer/weight_buffer_reg[34] QDFFRBN $PINS Q=weight_1_w[10] D=n413 CK=CTS_28
+ RB=FE_OFN386_i_reset_n_i
XBuffer/weight_buffer_reg[42] QDFFRBN $PINS Q=weight_1_w[18] D=n412 CK=CTS_28
+ RB=FE_OFN643_i_reset_n_i
XBuffer/weight_buffer_reg[50] QDFFRBN $PINS Q=weight_2_w[2] D=n411 CK=CTS_30
+ RB=FE_OFN1012_i_reset_n_i
XBuffer/weight_buffer_reg[58] QDFFRBN $PINS Q=weight_2_w[10] D=n410 CK=CTS_55
+ RB=FE_OFN510_i_reset_n_i
XBuffer/weight_buffer_reg[66] QDFFRBN $PINS Q=weight_2_w[18] D=n409 CK=CTS_55
+ RB=FE_OFN1023_i_reset_n_i
XBuffer/weight_buffer_reg[1] QDFFRBN $PINS Q=weight_0_w[1] D=n408 CK=CTS_29
+ RB=FE_OFN437_i_reset_n_i
XBuffer/weight_buffer_reg[9] QDFFRBN $PINS Q=weight_0_w[9] D=n407 CK=CTS_26
+ RB=FE_OFN697_i_reset_n_i
XBuffer/weight_buffer_reg[17] QDFFRBN $PINS Q=weight_0_w[17] D=n406 CK=CTS_26
+ RB=FE_OFN694_i_reset_n_i
XBuffer/weight_buffer_reg[25] QDFFRBN $PINS Q=weight_1_w[1] D=n405 CK=CTS_28
+ RB=FE_OFN895_i_reset_n_i
XBuffer/weight_buffer_reg[41] QDFFRBN $PINS Q=weight_1_w[17] D=n403 CK=CTS_28
+ RB=FE_OFN643_i_reset_n_i
XBuffer/weight_buffer_reg[49] QDFFRBN $PINS Q=weight_2_w[1] D=n402 CK=CTS_33
+ RB=FE_OFN679_i_reset_n_i
XBuffer/weight_buffer_reg[57] QDFFRBN $PINS Q=weight_2_w[9] D=n401 CK=CTS_24
+ RB=FE_OFN738_i_reset_n_i
XBuffer/weight_buffer_reg[0] QDFFRBN $PINS Q=weight_0_w[0] D=n399 CK=CTS_34
+ RB=FE_OFN472_i_reset_n_i
XBuffer/weight_buffer_reg[8] QDFFRBN $PINS Q=weight_0_w[8] D=n398 CK=CTS_34
+ RB=FE_OFN471_i_reset_n_i
XBuffer/weight_buffer_reg[16] QDFFRBN $PINS Q=weight_0_w[16] D=n397 CK=CTS_34
+ RB=FE_OFN471_i_reset_n_i
XBuffer/weight_buffer_reg[24] QDFFRBN $PINS Q=weight_1_w[0] D=n396 CK=CTS_28
+ RB=FE_OFN644_i_reset_n_i
XBuffer/weight_buffer_reg[32] QDFFRBN $PINS Q=weight_1_w[8] D=n395 CK=CTS_28
+ RB=FE_OFN895_i_reset_n_i
XBuffer/weight_buffer_reg[40] QDFFRBN $PINS Q=weight_1_w[16] D=n394 CK=CTS_28
+ RB=FE_OFN895_i_reset_n_i
XBuffer/weight_buffer_reg[48] QDFFRBN $PINS Q=weight_2_w[0] D=n393 CK=CTS_33
+ RB=FE_OFN679_i_reset_n_i
XBuffer/weight_buffer_reg[64] QDFFRBN $PINS Q=weight_2_w[16] D=n391 CK=CTS_55
+ RB=FE_OFN871_i_reset_n_i
XBuffer/weight_buffer_reg[71] QDFFRBN $PINS Q=weight_2_w[23] D=n390 CK=CTS_55
+ RB=FE_OFN609_i_reset_n_i
XpConv_0/product_0_r_reg[0] QDFFRBN $PINS Q=pConv_0/product_0_r[0]
+ D=pConv_0/product_0_w[0] CK=CTS_26 RB=FE_OFN698_i_reset_n_i
XpConv_0/product_0_r_reg[1] QDFFRBN $PINS Q=pConv_0/product_0_r[1]
+ D=pConv_0/product_0_w[1] CK=CTS_26 RB=FE_OFN698_i_reset_n_i
XpConv_0/product_0_r_reg[2] QDFFRBN $PINS Q=pConv_0/product_0_r[2]
+ D=pConv_0/product_0_w[2] CK=CTS_26 RB=FE_OFN576_i_reset_n_i
XpConv_0/product_0_r_reg[3] QDFFRBN $PINS Q=pConv_0/product_0_r[3]
+ D=pConv_0/product_0_w[3] CK=CTS_26 RB=FE_OFN576_i_reset_n_i
XpConv_0/product_0_r_reg[4] QDFFRBN $PINS Q=pConv_0/product_0_r[4]
+ D=pConv_0/product_0_w[4] CK=CTS_26 RB=FE_OFN699_i_reset_n_i
XpConv_0/product_0_r_reg[5] QDFFRBN $PINS Q=pConv_0/product_0_r[5] D=n10391
+ CK=CTS_26 RB=FE_OFN699_i_reset_n_i
XpConv_0/product_0_r_reg[6] QDFFRBN $PINS Q=pConv_0/product_0_r[6]
+ D=pConv_0/product_0_w[6] CK=CTS_26 RB=FE_OFN699_i_reset_n_i
XpConv_0/product_0_r_reg[8] QDFFRBN $PINS Q=pConv_0/product_0_r[8]
+ D=pConv_0/product_0_w[8] CK=CTS_29 RB=FE_OFN477_i_reset_n_i
XpConv_0/product_0_r_reg[11] QDFFRBN $PINS Q=pConv_0/product_0_r[11]
+ D=pConv_0/product_0_w[11] CK=CTS_2 RB=FE_OFN573_i_reset_n_i
XpConv_0/product_0_r_reg[13] QDFFRBN $PINS Q=pConv_0/product_0_r[13]
+ D=pConv_0/product_0_w[13] CK=CTS_2 RB=FE_OFN476_i_reset_n_i
XpConv_0/product_2_r_reg[0] QDFFRBN $PINS Q=pConv_0/product_2_r[0]
+ D=pConv_0/product_2_w[0] CK=CTS_3 RB=FE_OFN831_i_reset_n_i
XpConv_0/product_2_r_reg[1] QDFFRBN $PINS Q=pConv_0/product_2_r[1]
+ D=pConv_0/product_2_w[1] CK=CTS_3 RB=FE_OFN702_i_reset_n_i
XpConv_0/product_2_r_reg[2] QDFFRBN $PINS Q=pConv_0/product_2_r[2]
+ D=pConv_0/product_2_w[2] CK=CTS_3 RB=FE_OFN832_i_reset_n_i
XpConv_0/product_2_r_reg[3] QDFFRBN $PINS Q=pConv_0/product_2_r[3]
+ D=pConv_0/product_2_w[3] CK=CTS_3 RB=FE_OFN939_i_reset_n_i
XpConv_0/product_2_r_reg[4] QDFFRBN $PINS Q=pConv_0/product_2_r[4]
+ D=pConv_0/product_2_w[4] CK=CTS_3 RB=FE_OFN832_i_reset_n_i
XpConv_0/product_2_r_reg[5] QDFFRBN $PINS Q=pConv_0/product_2_r[5] D=n10393
+ CK=CTS_3 RB=FE_OFN471_i_reset_n_i
XpConv_0/product_2_r_reg[6] QDFFRBN $PINS Q=pConv_0/product_2_r[6]
+ D=pConv_0/product_2_w[6] CK=CTS_3 RB=FE_OFN939_i_reset_n_i
XpConv_0/product_2_r_reg[7] QDFFRBN $PINS Q=pConv_0/product_2_r[7] D=n10402
+ CK=CTS_3 RB=FE_OFN1009_i_reset_n_i
XpConv_0/product_2_r_reg[8] QDFFRBN $PINS Q=pConv_0/product_2_r[8]
+ D=pConv_0/product_2_w[8] CK=CTS_3 RB=FE_OFN412_i_reset_n_i
XpConv_0/product_2_r_reg[9] QDFFRBN $PINS Q=pConv_0/product_2_r[9]
+ D=pConv_0/product_2_w[9] CK=CTS_3 RB=FE_OFN412_i_reset_n_i
XpConv_0/product_2_r_reg[10] QDFFRBN $PINS Q=pConv_0/product_2_r[10]
+ D=pConv_0/product_2_w[10] CK=CTS_3 RB=FE_OFN365_i_reset_n_i
XpConv_0/product_2_r_reg[11] QDFFRBN $PINS Q=pConv_0/product_2_r[11]
+ D=pConv_0/product_2_w[11] CK=CTS_3 RB=FE_OFN365_i_reset_n_i
XpConv_0/product_2_r_reg[12] QDFFRBN $PINS Q=pConv_0/product_2_r[12]
+ D=pConv_0/product_2_w[12] CK=CTS_3 RB=FE_OFN411_i_reset_n_i
XpConv_0/product_2_r_reg[13] QDFFRBN $PINS Q=pConv_0/product_2_r[13]
+ D=pConv_0/product_2_w[13] CK=CTS_3 RB=FE_OFN411_i_reset_n_i
XpConv_0/product_1_r_reg[0] QDFFRBN $PINS Q=pConv_0/product_1_r[0]
+ D=pConv_0/product_1_w[0] CK=CTS_3 RB=FE_OFN472_i_reset_n_i
XpConv_0/product_1_r_reg[1] QDFFRBN $PINS Q=pConv_0/product_1_r[1]
+ D=pConv_0/product_1_w[1] CK=CTS_3 RB=FE_OFN693_i_reset_n_i
XpConv_0/product_1_r_reg[2] QDFFRBN $PINS Q=pConv_0/product_1_r[2]
+ D=pConv_0/product_1_w[2] CK=CTS_3 RB=FE_OFN693_i_reset_n_i
XpConv_0/product_1_r_reg[3] QDFFRBN $PINS Q=pConv_0/product_1_r[3]
+ D=pConv_0/product_1_w[3] CK=CTS_3 RB=FE_OFN693_i_reset_n_i
XpConv_0/product_1_r_reg[4] QDFFRBN $PINS Q=pConv_0/product_1_r[4]
+ D=pConv_0/product_1_w[4] CK=CTS_3 RB=FE_OFN693_i_reset_n_i
XpConv_0/product_1_r_reg[5] QDFFRBN $PINS Q=pConv_0/product_1_r[5] D=n10392
+ CK=CTS_26 RB=FE_OFN570_i_reset_n_i
XpConv_0/product_1_r_reg[6] QDFFRBN $PINS Q=pConv_0/product_1_r[6]
+ D=pConv_0/product_1_w[6] CK=CTS_26 RB=FE_OFN570_i_reset_n_i
XpConv_0/product_1_r_reg[7] QDFFRBN $PINS Q=pConv_0/product_1_r[7] D=n10401
+ CK=CTS_2 RB=FE_OFN696_i_reset_n_i
XpConv_0/product_1_r_reg[8] QDFFRBN $PINS Q=pConv_0/product_1_r[8]
+ D=pConv_0/product_1_w[8] CK=CTS_2 RB=FE_OFN697_i_reset_n_i
XpConv_0/product_1_r_reg[9] QDFFRBN $PINS Q=pConv_0/product_1_r[9]
+ D=pConv_0/product_1_w[9] CK=CTS_2 RB=FE_OFN697_i_reset_n_i
XpConv_0/product_1_r_reg[10] QDFFRBN $PINS Q=pConv_0/product_1_r[10]
+ D=pConv_0/product_1_w[10] CK=CTS_2 RB=FE_OFN407_i_reset_n_i
XpConv_0/product_1_r_reg[11] QDFFRBN $PINS Q=pConv_0/product_1_r[11]
+ D=pConv_0/product_1_w[11] CK=CTS_2 RB=FE_OFN407_i_reset_n_i
XpConv_0/product_1_r_reg[13] QDFFRBN $PINS Q=pConv_0/product_1_r[13]
+ D=pConv_0/product_1_w[13] CK=CTS_2 RB=FE_OFN475_i_reset_n_i
XpConv_1/product_0_r_reg[0] QDFFRBN $PINS Q=pConv_1/product_0_r[0]
+ D=pConv_1/product_0_w[0] CK=CTS_49 RB=FE_OFN532_i_reset_n_i
XpConv_1/product_0_r_reg[1] QDFFRBN $PINS Q=pConv_1/product_0_r[1]
+ D=pConv_1/product_0_w[1] CK=CTS_49 RB=FE_OFN532_i_reset_n_i
XpConv_1/product_0_r_reg[2] QDFFRBN $PINS Q=pConv_1/product_0_r[2]
+ D=pConv_1/product_0_w[2] CK=CTS_28 RB=FE_OFN532_i_reset_n_i
XpConv_1/product_0_r_reg[3] QDFFRBN $PINS Q=pConv_1/product_0_r[3]
+ D=pConv_1/product_0_w[3] CK=CTS_49 RB=FE_OFN532_i_reset_n_i
XpConv_1/product_0_r_reg[4] QDFFRBN $PINS Q=pConv_1/product_0_r[4]
+ D=pConv_1/product_0_w[4] CK=CTS_49 RB=FE_OFN646_i_reset_n_i
XpConv_1/product_0_r_reg[5] QDFFRBN $PINS Q=pConv_1/product_0_r[5] D=n10394
+ CK=CTS_49 RB=FE_OFN770_i_reset_n_i
XpConv_1/product_0_r_reg[6] QDFFRBN $PINS Q=pConv_1/product_0_r[6]
+ D=pConv_1/product_0_w[6] CK=CTS_49 RB=FE_OFN770_i_reset_n_i
XpConv_1/product_0_r_reg[7] QDFFRBN $PINS Q=pConv_1/product_0_r[7] D=n10403
+ CK=CTS_51 RB=FE_OFN982_i_reset_n_i
XpConv_1/product_0_r_reg[8] QDFFRBN $PINS Q=pConv_1/product_0_r[8]
+ D=pConv_1/product_0_w[8] CK=CTS_51 RB=FE_OFN982_i_reset_n_i
XpConv_1/product_0_r_reg[9] QDFFRBN $PINS Q=pConv_1/product_0_r[9]
+ D=pConv_1/product_0_w[9] CK=CTS_51 RB=FE_OFN773_i_reset_n_i
XpConv_1/product_0_r_reg[10] QDFFRBN $PINS Q=pConv_1/product_0_r[10]
+ D=pConv_1/product_0_w[10] CK=CTS_51 RB=FE_OFN773_i_reset_n_i
XpConv_1/product_0_r_reg[11] QDFFRBN $PINS Q=pConv_1/product_0_r[11]
+ D=pConv_1/product_0_w[11] CK=CTS_49 RB=FE_OFN773_i_reset_n_i
XpConv_1/product_0_r_reg[12] QDFFRBN $PINS Q=pConv_1/product_0_r[12]
+ D=pConv_1/product_0_w[12] CK=CTS_49 RB=FE_OFN773_i_reset_n_i
XpConv_1/product_0_r_reg[13] QDFFRBN $PINS Q=pConv_1/product_0_r[13]
+ D=pConv_1/product_0_w[13] CK=CTS_49 RB=FE_OFN649_i_reset_n_i
XpConv_1/product_2_r_reg[0] QDFFRBN $PINS Q=pConv_1/product_2_r[0]
+ D=pConv_1/product_2_w[0] CK=CTS_49 RB=FE_OFN445_i_reset_n_i
XpConv_1/product_2_r_reg[1] QDFFRBN $PINS Q=pConv_1/product_2_r[1]
+ D=pConv_1/product_2_w[1] CK=CTS_28 RB=FE_OFN532_i_reset_n_i
XpConv_1/product_2_r_reg[2] QDFFRBN $PINS Q=pConv_1/product_2_r[2]
+ D=pConv_1/product_2_w[2] CK=CTS_49 RB=FE_OFN532_i_reset_n_i
XpConv_1/product_2_r_reg[3] QDFFRBN $PINS Q=pConv_1/product_2_r[3]
+ D=pConv_1/product_2_w[3] CK=CTS_28 RB=FE_OFN445_i_reset_n_i
XpConv_1/product_2_r_reg[4] QDFFRBN $PINS Q=pConv_1/product_2_r[4]
+ D=pConv_1/product_2_w[4] CK=CTS_49 RB=FE_OFN533_i_reset_n_i
XpConv_1/product_2_r_reg[5] QDFFRBN $PINS Q=pConv_1/product_2_r[5] D=n10396
+ CK=CTS_49 RB=FE_OFN533_i_reset_n_i
XpConv_1/product_2_r_reg[6] QDFFRBN $PINS Q=pConv_1/product_2_r[6]
+ D=pConv_1/product_2_w[6] CK=CTS_49 RB=FE_OFN533_i_reset_n_i
XpConv_1/product_2_r_reg[7] QDFFRBN $PINS Q=pConv_1/product_2_r[7] D=n10405
+ CK=CTS_51 RB=FE_OFN647_i_reset_n_i
XpConv_1/product_2_r_reg[8] QDFFRBN $PINS Q=pConv_1/product_2_r[8]
+ D=pConv_1/product_2_w[8] CK=CTS_51 RB=FE_OFN896_i_reset_n_i
XpConv_1/product_2_r_reg[9] QDFFRBN $PINS Q=pConv_1/product_2_r[9]
+ D=pConv_1/product_2_w[9] CK=CTS_51 RB=FE_OFN982_i_reset_n_i
XpConv_1/product_2_r_reg[10] QDFFRBN $PINS Q=pConv_1/product_2_r[10]
+ D=pConv_1/product_2_w[10] CK=CTS_51 RB=FE_OFN647_i_reset_n_i
XpConv_1/product_2_r_reg[11] QDFFRBN $PINS Q=pConv_1/product_2_r[11]
+ D=pConv_1/product_2_w[11] CK=CTS_51 RB=FE_OFN983_i_reset_n_i
XpConv_1/product_2_r_reg[13] QDFFRBN $PINS Q=pConv_1/product_2_r[13]
+ D=pConv_1/product_2_w[13] CK=CTS_51 RB=FE_OFN388_i_reset_n_i
XpConv_1/product_1_r_reg[0] QDFFRBN $PINS Q=pConv_1/product_1_r[0]
+ D=pConv_1/product_1_w[0] CK=CTS_49 RB=FE_OFN770_i_reset_n_i
XpConv_1/product_1_r_reg[1] QDFFRBN $PINS Q=pConv_1/product_1_r[1]
+ D=pConv_1/product_1_w[1] CK=CTS_49 RB=FE_OFN646_i_reset_n_i
XpConv_1/product_1_r_reg[2] QDFFRBN $PINS Q=pConv_1/product_1_r[2]
+ D=pConv_1/product_1_w[2] CK=CTS_49 RB=FE_OFN646_i_reset_n_i
XpConv_1/product_1_r_reg[3] QDFFRBN $PINS Q=pConv_1/product_1_r[3]
+ D=pConv_1/product_1_w[3] CK=CTS_49 RB=FE_OFN770_i_reset_n_i
XpConv_1/product_1_r_reg[4] QDFFRBN $PINS Q=pConv_1/product_1_r[4]
+ D=pConv_1/product_1_w[4] CK=CTS_49 RB=FE_OFN770_i_reset_n_i
XpConv_1/product_1_r_reg[5] QDFFRBN $PINS Q=pConv_1/product_1_r[5] D=n10395
+ CK=CTS_49 RB=FE_OFN770_i_reset_n_i
XpConv_1/product_1_r_reg[6] QDFFRBN $PINS Q=pConv_1/product_1_r[6]
+ D=pConv_1/product_1_w[6] CK=CTS_51 RB=FE_OFN982_i_reset_n_i
XpConv_1/product_1_r_reg[7] QDFFRBN $PINS Q=pConv_1/product_1_r[7] D=n10404
+ CK=CTS_51 RB=FE_OFN982_i_reset_n_i
XpConv_1/product_1_r_reg[8] QDFFRBN $PINS Q=pConv_1/product_1_r[8]
+ D=pConv_1/product_1_w[8] CK=CTS_51 RB=FE_OFN982_i_reset_n_i
XpConv_1/product_1_r_reg[9] QDFFRBN $PINS Q=pConv_1/product_1_r[9]
+ D=pConv_1/product_1_w[9] CK=CTS_51 RB=FE_OFN983_i_reset_n_i
XpConv_1/product_1_r_reg[10] QDFFRBN $PINS Q=pConv_1/product_1_r[10]
+ D=pConv_1/product_1_w[10] CK=CTS_51 RB=FE_OFN388_i_reset_n_i
XpConv_1/product_1_r_reg[11] QDFFRBN $PINS Q=pConv_1/product_1_r[11]
+ D=pConv_1/product_1_w[11] CK=CTS_51 RB=FE_OFN388_i_reset_n_i
XpConv_1/product_1_r_reg[13] QDFFRBN $PINS Q=pConv_1/product_1_r[13]
+ D=pConv_1/product_1_w[13] CK=CTS_51 RB=FE_OFN389_i_reset_n_i
XpConv_2/product_0_r_reg[0] QDFFRBN $PINS Q=pConv_2/product_0_r[0]
+ D=pConv_2/product_0_w[0] CK=CTS_24 RB=FE_OFN868_i_reset_n_i
XpConv_2/product_0_r_reg[1] QDFFRBN $PINS Q=pConv_2/product_0_r[1]
+ D=pConv_2/product_0_w[1] CK=CTS_24 RB=FE_OFN868_i_reset_n_i
XpConv_2/product_0_r_reg[2] QDFFRBN $PINS Q=pConv_2/product_0_r[2]
+ D=pConv_2/product_0_w[2] CK=CTS_24 RB=FE_OFN740_i_reset_n_i
XpConv_2/product_0_r_reg[3] QDFFRBN $PINS Q=pConv_2/product_0_r[3]
+ D=pConv_2/product_0_w[3] CK=CTS_24 RB=FE_OFN864_i_reset_n_i
XpConv_2/product_0_r_reg[4] QDFFRBN $PINS Q=pConv_2/product_0_r[4]
+ D=pConv_2/product_0_w[4] CK=CTS_24 RB=FE_OFN740_i_reset_n_i
XpConv_2/product_0_r_reg[5] QDFFRBN $PINS Q=pConv_2/product_0_r[5] D=n10397
+ CK=CTS_24 RB=FE_OFN868_i_reset_n_i
XpConv_2/product_0_r_reg[6] QDFFRBN $PINS Q=pConv_2/product_0_r[6]
+ D=pConv_2/product_0_w[6] CK=CTS_24 RB=FE_OFN868_i_reset_n_i
XpConv_2/product_0_r_reg[7] QDFFRBN $PINS Q=pConv_2/product_0_r[7] D=n10406
+ CK=CTS_24 RB=FE_OFN867_i_reset_n_i
XpConv_2/product_0_r_reg[8] QDFFRBN $PINS Q=pConv_2/product_0_r[8]
+ D=pConv_2/product_0_w[8] CK=CTS_24 RB=FE_OFN867_i_reset_n_i
XpConv_2/product_0_r_reg[9] QDFFRBN $PINS Q=pConv_2/product_0_r[9]
+ D=pConv_2/product_0_w[9] CK=CTS_24 RB=FE_OFN616_i_reset_n_i
XpConv_2/product_0_r_reg[10] QDFFRBN $PINS Q=pConv_2/product_0_r[10]
+ D=pConv_2/product_0_w[10] CK=CTS_24 RB=FE_OCPN9776_FE_OFN514_i_reset_n_i
XpConv_2/product_0_r_reg[11] QDFFRBN $PINS Q=pConv_2/product_0_r[11]
+ D=pConv_2/product_0_w[11] CK=CTS_24 RB=FE_OFN747_i_reset_n_i
XpConv_2/product_0_r_reg[12] QDFFRBN $PINS Q=pConv_2/product_0_r[12]
+ D=pConv_2/product_0_w[12] CK=CTS_24 RB=FE_OFN747_i_reset_n_i
XpConv_2/product_0_r_reg[13] QDFFRBN $PINS Q=pConv_2/product_0_r[13]
+ D=pConv_2/product_0_w[13] CK=CTS_24 RB=FE_OFN616_i_reset_n_i
XpConv_2/product_2_r_reg[0] QDFFRBN $PINS Q=pConv_2/product_2_r[0]
+ D=pConv_2/product_2_w[0] CK=CTS_24 RB=FE_OFN608_i_reset_n_i
XpConv_2/product_2_r_reg[1] QDFFRBN $PINS Q=pConv_2/product_2_r[1]
+ D=pConv_2/product_2_w[1] CK=CTS_55 RB=FE_OFN510_i_reset_n_i
XpConv_2/product_2_r_reg[2] QDFFRBN $PINS Q=pConv_2/product_2_r[2]
+ D=pConv_2/product_2_w[2] CK=CTS_55 RB=FE_OFN870_i_reset_n_i
XpConv_2/product_2_r_reg[3] QDFFRBN $PINS Q=pConv_2/product_2_r[3]
+ D=pConv_2/product_2_w[3] CK=CTS_55 RB=FE_OFN743_i_reset_n_i
XpConv_2/product_2_r_reg[4] QDFFRBN $PINS Q=pConv_2/product_2_r[4]
+ D=pConv_2/product_2_w[4] CK=CTS_55 RB=FE_OFN1024_i_reset_n_i
XpConv_2/product_2_r_reg[5] QDFFRBN $PINS Q=pConv_2/product_2_r[5] D=n10399
+ CK=CTS_24 RB=FE_OFN608_i_reset_n_i
XpConv_2/product_2_r_reg[6] QDFFRBN $PINS Q=pConv_2/product_2_r[6]
+ D=pConv_2/product_2_w[6] CK=CTS_24 RB=FE_OFN1022_i_reset_n_i
XpConv_2/product_2_r_reg[7] QDFFRBN $PINS Q=pConv_2/product_2_r[7] D=n10408
+ CK=CTS_55 RB=FE_OFN510_i_reset_n_i
XpConv_2/product_2_r_reg[8] QDFFRBN $PINS Q=pConv_2/product_2_r[8]
+ D=pConv_2/product_2_w[8] CK=CTS_55 RB=FE_OFN429_i_reset_n_i
XpConv_2/product_2_r_reg[9] QDFFRBN $PINS Q=pConv_2/product_2_r[9]
+ D=pConv_2/product_2_w[9] CK=CTS_55 RB=FE_OFN511_i_reset_n_i
XpConv_2/product_2_r_reg[10] QDFFRBN $PINS Q=pConv_2/product_2_r[10]
+ D=pConv_2/product_2_w[10] CK=CTS_55 RB=FE_OFN611_i_reset_n_i
XpConv_2/product_2_r_reg[11] QDFFRBN $PINS Q=pConv_2/product_2_r[11]
+ D=pConv_2/product_2_w[11] CK=CTS_55 RB=FE_OFN611_i_reset_n_i
XpConv_2/product_1_r_reg[0] QDFFRBN $PINS Q=pConv_2/product_1_r[0]
+ D=pConv_2/product_1_w[0] CK=CTS_24 RB=FE_OFN739_i_reset_n_i
XpConv_2/product_1_r_reg[1] QDFFRBN $PINS Q=pConv_2/product_1_r[1]
+ D=pConv_2/product_1_w[1] CK=CTS_24 RB=FE_OFN739_i_reset_n_i
XpConv_2/product_1_r_reg[2] QDFFRBN $PINS Q=pConv_2/product_1_r[2]
+ D=pConv_2/product_1_w[2] CK=CTS_24 RB=FE_OFN739_i_reset_n_i
XpConv_2/product_1_r_reg[3] QDFFRBN $PINS Q=pConv_2/product_1_r[3]
+ D=pConv_2/product_1_w[3] CK=CTS_24 RB=FE_OFN740_i_reset_n_i
XpConv_2/product_1_r_reg[4] QDFFRBN $PINS Q=pConv_2/product_1_r[4]
+ D=pConv_2/product_1_w[4] CK=CTS_24 RB=FE_OFN867_i_reset_n_i
XpConv_2/product_1_r_reg[5] QDFFRBN $PINS Q=pConv_2/product_1_r[5] D=n10398
+ CK=CTS_24 RB=FE_OFN867_i_reset_n_i
XpConv_2/product_1_r_reg[6] QDFFRBN $PINS Q=pConv_2/product_1_r[6]
+ D=pConv_2/product_1_w[6] CK=CTS_24 RB=FE_OFN867_i_reset_n_i
XpConv_2/product_1_r_reg[7] QDFFRBN $PINS Q=pConv_2/product_1_r[7] D=n10407
+ CK=CTS_24 RB=FE_OFN867_i_reset_n_i
XpConv_2/product_1_r_reg[8] QDFFRBN $PINS Q=pConv_2/product_1_r[8]
+ D=pConv_2/product_1_w[8] CK=CTS_24 RB=FE_OCPN9776_FE_OFN514_i_reset_n_i
XpConv_2/product_1_r_reg[9] QDFFRBN $PINS Q=pConv_2/product_1_r[9]
+ D=pConv_2/product_1_w[9] CK=CTS_24 RB=FE_OFN747_i_reset_n_i
XpConv_2/product_1_r_reg[10] QDFFRBN $PINS Q=pConv_2/product_1_r[10]
+ D=pConv_2/product_1_w[10] CK=CTS_24 RB=FE_OFN747_i_reset_n_i
XpConv_2/product_1_r_reg[11] QDFFRBN $PINS Q=pConv_2/product_1_r[11]
+ D=pConv_2/product_1_w[11] CK=CTS_24 RB=FE_OFN747_i_reset_n_i
XpConv_0/product_1_r_reg[14] QDFFRBN $PINS Q=pConv_0/product_1_r[14]
+ D=pConv_0/product_1_w[14] CK=CTS_2 RB=FE_OFN475_i_reset_n_i
XpConv_0/product_1_r_reg[17] QDFFRBS $PINS Q=pConv_0/product_1_r[17]
+ D=pConv_0/product_1_w[17] CK=CTS_2 RB=FE_OFN572_i_reset_n_i
XpConv_2/product_2_r_reg[14] QDFFRBN $PINS Q=pConv_2/product_2_r[14]
+ D=pConv_2/product_2_w[14] CK=CTS_55 RB=FE_OFN869_i_reset_n_i
Xweight_1_r_reg[0] QDFFRBN $PINS Q=weight_1_r[0] D=weight_1_w[0] CK=CTS_28
+ RB=FE_OFN769_i_reset_n_i
Xweight_1_r_reg[16] QDFFRBN $PINS Q=weight_1_r[16] D=weight_1_w[16] CK=CTS_28
+ RB=FE_OFN529_i_reset_n_i
Xweight_1_r_reg[3] QDFFRBP $PINS Q=weight_1_r[3] D=weight_1_w[3] CK=CTS_28
+ RB=FE_OFN769_i_reset_n_i
Xweight_2_r_reg[2] QDFFRBN $PINS Q=weight_2_r[2] D=weight_2_w[2] CK=CTS_20
+ RB=FE_OFN1012_i_reset_n_i
Xweight_0_r_reg[4] QDFFRBN $PINS Q=weight_0_r[4] D=weight_0_w[4] CK=CTS_2
+ RB=FE_OFN477_i_reset_n_i
Xweight_2_r_reg[19] QDFFRBP $PINS Q=weight_2_r[19] D=weight_2_w[19] CK=CTS_55
+ RB=FE_OFN1023_i_reset_n_i
Xdata_1_r_reg[17] QDFFRBP $PINS Q=data_1_r[17] D=n1771 CK=CTS_51
+ RB=FE_OFN896_i_reset_n_i
Xdata_0_r_reg[20] QDFFRBP $PINS Q=data_0_r[20] D=n1729 CK=CTS_3
+ RB=FE_OFN405_i_reset_n_i
Xdata_2_r_reg[1] QDFFRBN $PINS Q=data_2_r[1] D=n1801 CK=CTS_20
+ RB=FE_OFN865_i_reset_n_i
Xdata_0_r_reg[36] QDFFRBN $PINS Q=data_0_r[36] D=n1744 CK=CTS_3
+ RB=FE_OFN364_i_reset_n_i
Xweight_0_r_reg[3] QDFFRBP $PINS Q=weight_0_r[3] D=weight_0_w[3] CK=CTS_29
+ RB=FE_OFN477_i_reset_n_i
Xdata_1_r_reg[1] QDFFRBN $PINS Q=data_1_r[1] D=n1756 CK=CTS_25
+ RB=FE_OFN931_i_reset_n_i
Xdata_0_r_reg[4] QDFFRBN $PINS Q=data_0_r[4] D=n1714 CK=CTS_29
+ RB=FE_OFN938_i_reset_n_i
Xdata_1_r_reg[36] QDFFRBN $PINS Q=data_1_r[36] D=n1789 CK=CTS_29
+ RB=FE_OFN979_i_reset_n_i
Xdata_1_r_reg[4] QDFFRBN $PINS Q=data_1_r[4] D=n1759 CK=CTS_25
+ RB=FE_OFN931_i_reset_n_i
XBuffer/counter_temp_reg[0] QDFFRBN $PINS Q=Buffer/counter_temp[0] D=n389
+ CK=CTS_29 RB=FE_OFN634_i_reset_n_i
Xdata_1_r_reg[33] QDFFRBS $PINS Q=data_1_r[33] D=n1786 CK=CTS_28
+ RB=FE_OFN767_i_reset_n_i
Xdata_0_r_reg[17] QDFFRBN $PINS Q=data_0_r[17] D=n1726 CK=CTS_34
+ RB=FE_OFN472_i_reset_n_i
Xweight_0_r_reg[20] QDFFRBN $PINS Q=weight_0_r[20] D=weight_0_w[20] CK=CTS_3
+ RB=FE_OFN1062_i_reset_n_i
Xweight_1_r_reg[4] QDFFRBN $PINS Q=weight_1_r[4] D=weight_1_w[4] CK=CTS_25
+ RB=FE_OFN768_i_reset_n_i
Xweight_2_r_reg[1] QDFFRBP $PINS Q=weight_2_r[1] D=weight_2_w[1] CK=CTS_33
+ RB=FE_OFN679_i_reset_n_i
Xweight_1_r_reg[10] QDFFRBN $PINS Q=weight_1_r[10] D=weight_1_w[10] CK=CTS_49
+ RB=FE_OFN647_i_reset_n_i
Xweight_2_r_reg[3] QDFFRBP $PINS Q=weight_2_r[3] D=weight_2_w[3] CK=CTS_33
+ RB=FE_OFN560_i_reset_n_i
Xdata_2_r_reg[4] QDFFRBN $PINS Q=data_2_r[4] D=n1804 CK=CTS_20
+ RB=FE_OFN1013_i_reset_n_i
Xweight_0_r_reg[6] QDFFRBN $PINS Q=weight_0_r[6] D=weight_0_w[6] CK=CTS_2
+ RB=FE_OFN381_i_reset_n_i
Xweight_0_r_reg[5] QDFFRBP $PINS Q=weight_0_r[5] D=weight_0_w[5] CK=CTS_2
+ RB=FE_OFN408_i_reset_n_i
Xweight_2_r_reg[9] QDFFRBP $PINS Q=weight_2_r[9] D=weight_2_w[9] CK=CTS_24
+ RB=FE_OFN738_i_reset_n_i
Xdata_1_r_reg[18] QDFFRBN $PINS Q=data_1_r[18] D=n1772 CK=CTS_51
+ RB=FE_OFN533_i_reset_n_i
Xdata_1_r_reg[39] QDFFRBN $PINS Q=data_1_r[39] D=n1792 CK=CTS_28
+ RB=FE_OFN978_i_reset_n_i
XpConv_0/product_0_r_reg[7] DFFRBN $PINS Q=pConv_0/product_0_r[7] D=n10400
+ CK=CTS_26 RB=FE_OFN828_i_reset_n_i
XpConv_0/product_0_r_reg[9] DFFRBN $PINS Q=pConv_0/product_0_r[9]
+ D=pConv_0/product_0_w[9] CK=CTS_2 RB=FE_OFN408_i_reset_n_i
XpConv_1/product_1_r_reg[17] DFFRBN $PINS Q=pConv_1/product_1_r[17]
+ D=pConv_1/product_1_w[17] CK=CTS_51 RB=FE_OFN540_i_reset_n_i
XpConv_1/product_2_r_reg[17] DFFRBT $PINS Q=pConv_1/product_2_r[17]
+ D=pConv_1/product_2_w[17] CK=CTS_51 RB=FE_OFN448_i_reset_n_i
XpConv_2/product_1_r_reg[12] DFFRBN $PINS Q=pConv_2/product_1_r[12]
+ D=pConv_2/product_1_w[12] CK=CTS_46 RB=FE_OCPN9779_FE_OFN515_i_reset_n_i
XpConv_1/product_2_r_reg[12] DFFRBN $PINS Q=pConv_1/product_2_r[12]
+ D=pConv_1/product_2_w[12] CK=CTS_51 RB=FE_OFN897_i_reset_n_i
XpConv_0/product_0_r_reg[17] DFFRBN $PINS Q=pConv_0/product_0_r[17]
+ D=pConv_0/product_0_w[17] CK=CTS_2 RB=FE_OFN574_i_reset_n_i
XpConv_1/product_0_r_reg[19] DFFRBP $PINS Q=pConv_1/product_0_r[19]
+ D=pConv_1/product_0_w[19] CK=CTS_49 RB=FE_OFN649_i_reset_n_i
XpConv_2/product_1_r_reg[18] DFFRBN $PINS Q=pConv_2/product_1_r[18]
+ D=pConv_2/product_1_w[18] CK=CTS_46 RB=FE_OFN618_i_reset_n_i
XpConv_1/product_1_r_reg[16] DFFRBN $PINS Q=pConv_1/product_1_r[16]
+ D=pConv_1/product_1_w[16] CK=CTS_51 RB=FE_OFN540_i_reset_n_i
XpConv_0/product_1_r_reg[16] DFFRBS $PINS Q=pConv_0/product_1_r[16]
+ D=pConv_0/product_1_w[16] CK=CTS_2 RB=FE_OFN572_i_reset_n_i
XpConv_2/product_1_r_reg[13] DFFRBN $PINS Q=pConv_2/product_1_r[13]
+ D=pConv_2/product_1_w[13] CK=CTS_46 RB=FE_OCPN9779_FE_OFN515_i_reset_n_i
XpConv_2/product_1_r_reg[16] DFFRBS $PINS Q=pConv_2/product_1_r[16]
+ D=pConv_2/product_1_w[16] CK=CTS_46 RB=FE_OFN515_i_reset_n_i
XpConv_1/product_0_r_reg[18] DFFRBP $PINS Q=pConv_1/product_0_r[18]
+ D=pConv_1/product_0_w[18] CK=CTS_49 RB=FE_OFN649_i_reset_n_i
XpConv_0/product_0_r_reg[21] DFFRBS $PINS QB=DP_OP_56J1_122_9379/n252
+ D=pConv_0/product_0_w[21] CK=CTS_2 RB=FE_OFN573_i_reset_n_i
XpConv_2/product_2_r_reg[16] DFFRBN $PINS Q=pConv_2/product_2_r[16]
+ D=pConv_2/product_2_w[16] CK=CTS_55 RB=FE_OFN869_i_reset_n_i
XpConv_1/product_2_r_reg[16] DFFRBN $PINS Q=pConv_1/product_2_r[16]
+ D=pConv_1/product_2_w[16] CK=CTS_51 RB=FE_OFN981_i_reset_n_i
XpConv_1/product_1_r_reg[18] DFFRBP $PINS Q=pConv_1/product_1_r[18]
+ D=pConv_1/product_1_w[18] CK=CTS_51 RB=FE_OFN540_i_reset_n_i
XpConv_2/product_0_r_reg[21] DFFRBP $PINS QB=DP_OP_58J1_124_9379/n252
+ D=pConv_2/product_0_w[21] CK=CTS_24 RB=FE_OFN747_i_reset_n_i
XpConv_1/product_0_r_reg[16] DFFRBP $PINS Q=pConv_1/product_0_r[16]
+ D=pConv_1/product_0_w[16] CK=CTS_49 RB=FE_OFN773_i_reset_n_i
XpConv_2/product_2_r_reg[20] DFFRBP $PINS Q=pConv_2/product_2_r[20]
+ D=pConv_2/product_2_w[20] CK=CTS_55 RB=FE_OFN432_i_reset_n_i
XpConv_1/product_2_r_reg[19] DFFRBT $PINS Q=pConv_1/product_2_r[19]
+ D=pConv_1/product_2_w[19] CK=CTS_51 RB=FE_OFN448_i_reset_n_i
XpConv_1/product_1_r_reg[19] DFFRBP $PINS Q=pConv_1/product_1_r[19]
+ D=pConv_1/product_1_w[19] CK=CTS_51 RB=FE_OFN540_i_reset_n_i
XpConv_2/product_2_r_reg[19] DFFRBP $PINS Q=pConv_2/product_2_r[19]
+ D=pConv_2/product_2_w[19] CK=CTS_55 RB=FE_OFN869_i_reset_n_i
XpConv_0/product_2_r_reg[19] DFFRBS $PINS Q=pConv_0/product_2_r[19]
+ D=pConv_0/product_2_w[19] CK=CTS_3 RB=FE_OFN480_i_reset_n_i
XpConv_0/product_2_r_reg[16] DFFRBN $PINS Q=pConv_0/product_2_r[16]
+ D=pConv_0/product_2_w[16] CK=CTS_3 RB=FE_OFN480_i_reset_n_i
XpConv_0/product_2_r_reg[20] DFFRBS $PINS Q=pConv_0/product_2_r[20]
+ D=pConv_0/product_2_w[20] CK=CTS_3 RB=FE_OFN480_i_reset_n_i
XpConv_0/product_1_r_reg[20] DFFRBS $PINS Q=pConv_0/product_1_r[20]
+ D=pConv_0/product_1_w[20] CK=CTS_2 RB=FE_OFN572_i_reset_n_i
XpConv_2/product_1_r_reg[19] DFFRBP $PINS Q=pConv_2/product_1_r[19]
+ D=pConv_2/product_1_w[19] CK=CTS_56 RB=FE_OFN1026_i_reset_n_i
XpConv_0/product_2_r_reg[14] DFFRBS $PINS Q=pConv_0/product_2_r[14]
+ D=pConv_0/product_2_w[14] CK=CTS_3 RB=FE_OFN411_i_reset_n_i
XpConv_0/product_0_r_reg[20] DFFRBS $PINS Q=pConv_0/product_0_r[20]
+ D=pConv_0/product_0_w[20] CK=CTS_2 RB=FE_OFN574_i_reset_n_i
XpConv_2/product_2_r_reg[21] DFFRBP $PINS QB=DP_OP_58J1_124_9379/n251
+ D=pConv_2/product_2_w[21] CK=CTS_55 RB=FE_OFN741_i_reset_n_i
XpConv_1/product_2_r_reg[20] DFFRBP $PINS Q=pConv_1/product_2_r[20]
+ D=pConv_1/product_2_w[20] CK=CTS_51 RB=FE_OFN389_i_reset_n_i
XpConv_1/product_2_r_reg[21] DFFRBP $PINS QB=DP_OP_57J1_123_9379/n251
+ D=pConv_1/product_2_w[21] CK=CTS_51 RB=FE_OFN897_i_reset_n_i
XpConv_0/product_1_r_reg[19] DFFRBP $PINS Q=pConv_0/product_1_r[19]
+ D=pConv_0/product_1_w[19] CK=CTS_2 RB=FE_OFN572_i_reset_n_i
XpConv_2/product_0_r_reg[20] DFFRBS $PINS Q=pConv_2/product_0_r[20]
+ D=pConv_2/product_0_w[20] CK=CTS_24 RB=FE_OFN874_i_reset_n_i
XpConv_2/product_0_r_reg[18] DFFRBN $PINS Q=pConv_2/product_0_r[18]
+ D=pConv_2/product_0_w[18] CK=CTS_24 RB=FE_OFN748_i_reset_n_i
XpConv_0/product_2_r_reg[21] DFFRBP $PINS QB=DP_OP_56J1_122_9379/n251
+ D=pConv_0/product_2_w[21] CK=CTS_3 RB=FE_OFN411_i_reset_n_i
XpConv_0/product_2_r_reg[15] DFFRBS $PINS Q=pConv_0/product_2_r[15]
+ D=pConv_0/product_2_w[15] CK=CTS_3 RB=FE_OFN480_i_reset_n_i
XpConv_0/product_2_r_reg[17] DFFRBN $PINS Q=pConv_0/product_2_r[17]
+ D=pConv_0/product_2_w[17] CK=CTS_3 RB=FE_OFN480_i_reset_n_i
XpConv_0/product_2_r_reg[18] DFFRBP $PINS Q=pConv_0/product_2_r[18]
+ D=pConv_0/product_2_w[18] CK=CTS_3 RB=FE_OFN480_i_reset_n_i
XpConv_2/product_2_r_reg[18] DFFRBN $PINS Q=pConv_2/product_2_r[18]
+ D=pConv_2/product_2_w[18] CK=CTS_55 RB=FE_OFN869_i_reset_n_i
XpConv_1/product_0_r_reg[20] DFFRBN $PINS Q=pConv_1/product_0_r[20]
+ D=pConv_1/product_0_w[20] CK=CTS_49 RB=FE_OFN772_i_reset_n_i
XpConv_1/product_0_r_reg[21] DFFRBP $PINS QB=DP_OP_57J1_123_9379/n252
+ D=pConv_1/product_0_w[21] CK=CTS_49 RB=FE_OFN649_i_reset_n_i
XpConv_0/product_1_r_reg[21] DFFRBN $PINS Q=pConv_0/product_1_r[21]
+ QB=DP_OP_56J1_122_9379/n253 D=pConv_0/product_1_w[21] CK=CTS_2
+ RB=FE_OFN476_i_reset_n_i
XpConv_0/product_1_r_reg[18] DFFRBP $PINS Q=pConv_0/product_1_r[18]
+ D=pConv_0/product_1_w[18] CK=CTS_2 RB=FE_OFN572_i_reset_n_i
XpConv_2/product_0_r_reg[19] DFFRBS $PINS Q=pConv_2/product_0_r[19]
+ D=pConv_2/product_0_w[19] CK=CTS_24 RB=FE_OFN748_i_reset_n_i
XpConv_1/product_2_r_reg[18] DFFRBP $PINS Q=pConv_1/product_2_r[18]
+ D=pConv_1/product_2_w[18] CK=CTS_51 RB=FE_OFN540_i_reset_n_i
XpConv_1/product_0_r_reg[15] DFFRBN $PINS Q=pConv_1/product_0_r[15]
+ D=pConv_1/product_0_w[15] CK=CTS_49 RB=FE_OFN536_i_reset_n_i
XpConv_1/product_0_r_reg[14] DFFRBN $PINS Q=pConv_1/product_0_r[14]
+ D=pConv_1/product_0_w[14] CK=CTS_49 RB=FE_OFN536_i_reset_n_i
XpConv_0/product_0_r_reg[16] DFFRBN $PINS Q=pConv_0/product_0_r[16]
+ D=pConv_0/product_0_w[16] CK=CTS_2 RB=FE_OFN574_i_reset_n_i
Xweight_0_r_reg[23] QDFFRBP $PINS Q=weight_0_r[23] D=weight_0_w[23] CK=CTS_3
+ RB=FE_OFN1062_i_reset_n_i
Xweight_2_r_reg[8] QDFFRBN $PINS Q=weight_2_r[8] D=weight_2_w[8] CK=CTS_24
+ RB=FE_OFN738_i_reset_n_i
Xweight_2_r_reg[22] QDFFRBN $PINS Q=weight_2_r[22] D=weight_2_w[22] CK=CTS_55
+ RB=FE_OFN429_i_reset_n_i
Xweight_2_r_reg[14] QDFFRBN $PINS Q=weight_2_r[14] D=weight_2_w[14] CK=CTS_55
+ RB=FE_OFN611_i_reset_n_i
Xweight_1_r_reg[14] QDFFRBN $PINS Q=weight_1_r[14] D=weight_1_w[14] CK=CTS_51
+ RB=FE_OFN771_i_reset_n_i
Xdata_1_r_reg[2] QDFFRBN $PINS Q=data_1_r[2] D=n1757 CK=CTS_25
+ RB=FE_OFN997_i_reset_n_i
Xweight_0_r_reg[0] QDFFRBN $PINS Q=weight_0_r[0] D=weight_0_w[0] CK=CTS_26
+ RB=FE_OFN828_i_reset_n_i
Xdata_0_r_reg[35] QDFFRBN $PINS Q=data_0_r[35] D=n1743 CK=CTS_3
+ RB=FE_OFN410_i_reset_n_i
Xweight_1_r_reg[2] QDFFRBN $PINS Q=weight_1_r[2] D=weight_1_w[2] CK=CTS_25
+ RB=FE_OFN531_i_reset_n_i
Xweight_1_r_reg[8] QDFFRBN $PINS Q=weight_1_r[8] D=weight_1_w[8] CK=CTS_49
+ RB=FE_OFN646_i_reset_n_i
Xweight_0_r_reg[14] QDFFRBN $PINS Q=weight_0_r[14] D=weight_0_w[14] CK=CTS_2
+ RB=FE_OFN406_i_reset_n_i
Xweight_0_r_reg[11] QDFFRBP $PINS Q=weight_0_r[11] D=weight_0_w[11] CK=CTS_26
+ RB=FE_OFN473_i_reset_n_i
Xweight_2_r_reg[0] QDFFRBN $PINS Q=weight_2_r[0] D=weight_2_w[0] CK=CTS_33
+ RB=FE_OFN679_i_reset_n_i
Xweight_0_r_reg[16] QDFFRBP $PINS Q=weight_0_r[16] D=weight_0_w[16] CK=CTS_3
+ RB=FE_OFN831_i_reset_n_i
Xdata_2_r_reg[3] QDFFRBN $PINS Q=data_2_r[3] D=n1803 CK=CTS_20
+ RB=FE_OFN947_i_reset_n_i
XpConv_2/product_2_r_reg[15] QDFFRBN $PINS Q=pConv_2/product_2_r[15]
+ D=pConv_2/product_2_w[15] CK=CTS_55 RB=FE_OFN869_i_reset_n_i
Xweight_0_r_reg[1] QDFFRBP $PINS Q=weight_0_r[1] D=weight_0_w[1] CK=CTS_29
+ RB=FE_OFN437_i_reset_n_i
Xdata_1_r_reg[41] QDFFRBN $PINS Q=data_1_r[41] D=n1794 CK=CTS_29
+ RB=FE_OFN979_i_reset_n_i
XpConv_2/product_0_r_reg[14] QDFFRBN $PINS Q=pConv_2/product_0_r[14]
+ D=pConv_2/product_0_w[14] CK=CTS_24 RB=FE_OFN616_i_reset_n_i
Xdata_0_r_reg[5] QDFFRBN $PINS Q=data_0_r[5] D=n1715 CK=CTS_26
+ RB=FE_OFN829_i_reset_n_i
Xweight_0_r_reg[2] QDFFRBN $PINS Q=weight_0_r[2] D=weight_0_w[2] CK=CTS_29
+ RB=FE_OFN437_i_reset_n_i
Xweight_0_r_reg[18] QDFFRBN $PINS Q=weight_0_r[18] D=weight_0_w[18] CK=CTS_3
+ RB=FE_OFN1009_i_reset_n_i
XpConv_2/product_0_r_reg[15] QDFFRBN $PINS Q=pConv_2/product_0_r[15]
+ D=pConv_2/product_0_w[15] CK=CTS_24 RB=FE_OFN748_i_reset_n_i
Xdata_2_r_reg[34] QDFFRBN $PINS Q=data_2_r[34] D=n1832 CK=CTS_12
+ RB=FE_OFN615_i_reset_n_i
XpConv_2/product_0_r_reg[17] QDFFRBN $PINS Q=pConv_2/product_0_r[17]
+ D=pConv_2/product_0_w[17] CK=CTS_24 RB=FE_OFN748_i_reset_n_i
Xdata_2_r_reg[37] QDFFRBS $PINS Q=data_2_r[37] D=n1835 CK=CTS_38
+ RB=FE_OFN745_i_reset_n_i
Xdata_2_r_reg[22] QDFFRBN $PINS Q=data_2_r[22] D=n1821 CK=CTS_24
+ RB=FE_OFN1022_i_reset_n_i
Xweight_1_r_reg[21] QDFFRBP $PINS Q=weight_1_r[21] D=weight_1_w[21] CK=CTS_28
+ RB=FE_OFN893_i_reset_n_i
Xdata_0_r_reg[21] QDFFRBN $PINS Q=data_0_r[21] D=n1730 CK=CTS_3
+ RB=FE_OFN1009_i_reset_n_i
XpConv_0/product_0_r_reg[19] QDFFRBN $PINS Q=pConv_0/product_0_r[19]
+ D=pConv_0/product_0_w[19] CK=CTS_2 RB=FE_OFN574_i_reset_n_i
Xweight_0_r_reg[10] QDFFRBN $PINS Q=weight_0_r[10] D=weight_0_w[10] CK=CTS_26
+ RB=FE_OFN473_i_reset_n_i
Xdata_0_r_reg[19] QDFFRBN $PINS Q=data_0_r[19] D=n1728 CK=CTS_34
+ RB=FE_OFN472_i_reset_n_i
Xdata_2_r_reg[18] QDFFRBS $PINS Q=data_2_r[18] D=n1817 CK=CTS_24
+ RB=FE_OFN1022_i_reset_n_i
Xdata_0_r_reg[25] QDFFRBN $PINS Q=data_0_r[25] D=n1734 CK=CTS_3
+ RB=FE_OFN1062_i_reset_n_i
Xweight_2_r_reg[10] QDFFRBN $PINS Q=weight_2_r[10] D=weight_2_w[10] CK=CTS_24
+ RB=FE_OFN738_i_reset_n_i
XpConv_2/product_1_r_reg[14] QDFFRBS $PINS Q=pConv_2/product_1_r[14]
+ D=pConv_2/product_1_w[14] CK=CTS_46 RB=FE_OCPN9779_FE_OFN515_i_reset_n_i
XpConv_2/product_2_r_reg[13] QDFFRBN $PINS Q=pConv_2/product_2_r[13]
+ D=pConv_2/product_2_w[13] CK=CTS_55 RB=FE_OFN741_i_reset_n_i
Xdata_1_r_reg[23] QDFFRBN $PINS Q=data_1_r[23] D=n1777 CK=CTS_51
+ RB=FE_OFN771_i_reset_n_i
XpConv_2/product_1_r_reg[15] QDFFRBS $PINS Q=pConv_2/product_1_r[15]
+ D=pConv_2/product_1_w[15] CK=CTS_46 RB=FE_OCPN9779_FE_OFN515_i_reset_n_i
Xdata_2_r_reg[2] QDFFRBN $PINS Q=data_2_r[2] D=n1802 CK=CTS_20
+ RB=FE_OFN1013_i_reset_n_i
XpConv_1/product_0_r_reg[17] QDFFRBN $PINS Q=pConv_1/product_0_r[17]
+ D=pConv_1/product_0_w[17] CK=CTS_49 RB=FE_OFN772_i_reset_n_i
Xdata_1_r_reg[21] QDFFRBN $PINS Q=data_1_r[21] D=n1775 CK=CTS_51
+ RB=FE_OFN896_i_reset_n_i
Xweight_2_r_reg[4] QDFFRBN $PINS Q=weight_2_r[4] D=weight_2_w[4] CK=CTS_20
+ RB=FE_OFN1012_i_reset_n_i
Xweight_2_r_reg[18] QDFFRBN $PINS Q=weight_2_r[18] D=weight_2_w[18] CK=CTS_55
+ RB=FE_OFN1023_i_reset_n_i
Xweight_0_r_reg[9] QDFFRBP $PINS Q=weight_0_r[9] D=weight_0_w[9] CK=CTS_26
+ RB=FE_OFN570_i_reset_n_i
Xweight_0_r_reg[8] QDFFRBN $PINS Q=weight_0_r[8] D=weight_0_w[8] CK=CTS_3
+ RB=FE_OFN1009_i_reset_n_i
Xweight_1_r_reg[1] QDFFRBP $PINS Q=weight_1_r[1] D=weight_1_w[1] CK=CTS_28
+ RB=FE_OFN769_i_reset_n_i
Xdata_2_r_reg[17] QDFFRBN $PINS Q=data_2_r[17] D=n1816 CK=CTS_24
+ RB=FE_OFN864_i_reset_n_i
XpConv_2/product_2_r_reg[17] QDFFRBN $PINS Q=pConv_2/product_2_r[17]
+ D=pConv_2/product_2_w[17] CK=CTS_55 RB=FE_OFN869_i_reset_n_i
XpConv_0/product_1_r_reg[15] QDFFRBS $PINS Q=pConv_0/product_1_r[15]
+ D=pConv_0/product_1_w[15] CK=CTS_2 RB=FE_OFN572_i_reset_n_i
Xweight_0_r_reg[12] QDFFRBP $PINS Q=weight_0_r[12] D=weight_0_w[12] CK=CTS_2
+ RB=FE_OFN406_i_reset_n_i
XpConv_0/product_1_r_reg[12] QDFFRBN $PINS Q=pConv_0/product_1_r[12]
+ D=pConv_0/product_1_w[12] CK=CTS_2 RB=FE_OFN407_i_reset_n_i
Xweight_1_r_reg[11] QDFFRBN $PINS Q=weight_1_r[11] D=weight_1_w[11] CK=CTS_51
+ RB=FE_OFN647_i_reset_n_i
XpConv_1/product_1_r_reg[12] QDFFRBN $PINS Q=pConv_1/product_1_r[12]
+ D=pConv_1/product_1_w[12] CK=CTS_51 RB=FE_OFN388_i_reset_n_i
Xweight_2_r_reg[17] QDFFRBN $PINS Q=weight_2_r[17] D=weight_2_w[17] CK=CTS_55
+ RB=FE_OFN1024_i_reset_n_i
Xweight_1_r_reg[7] QDFFRBP $PINS Q=weight_1_r[7] D=weight_1_w[7] CK=CTS_25
+ RB=FE_OFN768_i_reset_n_i
Xweight_1_r_reg[15] QDFFRBP $PINS Q=weight_1_r[15] D=weight_1_w[15] CK=CTS_51
+ RB=FE_OFN897_i_reset_n_i
Xdata_0_r_reg[22] QDFFRBS $PINS Q=data_0_r[22] D=n1731 CK=CTS_3
+ RB=FE_OFN471_i_reset_n_i
Xweight_1_r_reg[9] QDFFRBP $PINS Q=weight_1_r[9] D=weight_1_w[9] CK=CTS_51
+ RB=FE_OFN647_i_reset_n_i
XpConv_1/product_1_r_reg[14] QDFFRBP $PINS Q=pConv_1/product_1_r[14]
+ D=pConv_1/product_1_w[14] CK=CTS_51 RB=FE_OFN448_i_reset_n_i
XpConv_1/product_2_r_reg[14] QDFFRBP $PINS Q=pConv_1/product_2_r[14]
+ D=pConv_1/product_2_w[14] CK=CTS_51 RB=FE_OFN389_i_reset_n_i
Xweight_0_r_reg[13] QDFFRBP $PINS Q=weight_0_r[13] D=weight_0_w[13] CK=CTS_2
+ RB=FE_OFN406_i_reset_n_i
Xdata_0_r_reg[18] QDFFRBN $PINS Q=data_0_r[18] D=n1727 CK=CTS_34
+ RB=FE_OFN472_i_reset_n_i
Xdata_0_r_reg[34] QDFFRBN $PINS Q=data_0_r[34] D=n1742 CK=CTS_3
+ RB=FE_OFN410_i_reset_n_i
Xdata_2_r_reg[23] QDFFRBN $PINS Q=data_2_r[23] D=n1822 CK=CTS_55
+ RB=FE_OFN1021_i_reset_n_i
Xweight_2_r_reg[5] QDFFRBP $PINS Q=weight_2_r[5] D=weight_2_w[5] CK=CTS_33
+ RB=FE_OFN560_i_reset_n_i
Xweight_1_r_reg[13] QDFFRBP $PINS Q=weight_1_r[13] D=weight_1_w[13] CK=CTS_51
+ RB=FE_OFN771_i_reset_n_i
Xweight_1_r_reg[22] QDFFRBN $PINS Q=weight_1_r[22] D=weight_1_w[22] CK=CTS_29
+ RB=FE_OFN979_i_reset_n_i
Xweight_0_r_reg[21] QDFFRBP $PINS Q=weight_0_r[21] D=weight_0_w[21] CK=CTS_3
+ RB=FE_OFN1062_i_reset_n_i
Xweight_2_r_reg[21] QDFFRBP $PINS Q=weight_2_r[21] D=weight_2_w[21] CK=CTS_55
+ RB=FE_OFN1024_i_reset_n_i
XpConv_0/product_0_r_reg[10] QDFFRBP $PINS Q=pConv_0/product_0_r[10]
+ D=pConv_0/product_0_w[10] CK=CTS_2 RB=FE_OFN573_i_reset_n_i
XpConv_0/product_0_r_reg[12] QDFFRBN $PINS Q=pConv_0/product_0_r[12]
+ D=pConv_0/product_0_w[12] CK=CTS_2 RB=FE_OFN573_i_reset_n_i
XpConv_0/product_0_r_reg[14] QDFFRBP $PINS Q=pConv_0/product_0_r[14]
+ D=pConv_0/product_0_w[14] CK=CTS_2 RB=FE_OFN476_i_reset_n_i
Xdata_0_r_reg[7] QDFFRBS $PINS Q=data_0_r[7] D=n1717 CK=CTS_29
+ RB=FE_OFN1006_i_reset_n_i
Xdata_0_r_reg[3] QDFFRBN $PINS Q=data_0_r[3] D=n1713 CK=CTS_29
+ RB=FE_OFN938_i_reset_n_i
Xweight_1_r_reg[20] QDFFRBN $PINS Q=weight_1_r[20] D=weight_1_w[20] CK=CTS_29
+ RB=FE_OFN979_i_reset_n_i
XpConv_1/product_2_r_reg[15] QDFFRBT $PINS Q=pConv_1/product_2_r[15]
+ D=pConv_1/product_2_w[15] CK=CTS_51 RB=FE_OFN389_i_reset_n_i
Xweight_2_r_reg[6] QDFFRBN $PINS Q=weight_2_r[6] D=weight_2_w[6] CK=CTS_20
+ RB=FE_OFN463_i_reset_n_i
Xdata_1_r_reg[20] QDFFRBN $PINS Q=data_1_r[20] D=n1774 CK=CTS_51
+ RB=FE_OFN896_i_reset_n_i
Xdata_1_r_reg[19] QDFFRBN $PINS Q=data_1_r[19] D=n1773 CK=CTS_51
+ RB=FE_OFN896_i_reset_n_i
XpConv_0/product_0_r_reg[15] QDFFRBN $PINS Q=pConv_0/product_0_r[15]
+ D=pConv_0/product_0_w[15] CK=CTS_2 RB=FE_OFN574_i_reset_n_i
Xweight_0_r_reg[22] QDFFRBN $PINS Q=weight_0_r[22] D=weight_0_w[22] CK=CTS_3
+ RB=FE_OFN1062_i_reset_n_i
Xweight_0_r_reg[15] QDFFRBP $PINS Q=weight_0_r[15] D=weight_0_w[15] CK=CTS_2
+ RB=FE_OFN406_i_reset_n_i
Xdata_0_r_reg[2] QDFFRBN $PINS Q=data_0_r[2] D=n1712 CK=CTS_29
+ RB=FE_OFN1006_i_reset_n_i
Xweight_1_r_reg[17] QDFFRBT $PINS Q=weight_1_r[17] D=weight_1_w[17] CK=CTS_28
+ RB=FE_OFN529_i_reset_n_i
Xdata_2_r_reg[35] QDFFRBN $PINS Q=data_2_r[35] D=n1833 CK=CTS_12
+ RB=FE_OFN615_i_reset_n_i
XpConv_2/product_0_r_reg[16] DFFRBN $PINS Q=pConv_2/product_0_r[16]
+ D=pConv_2/product_0_w[16] CK=CTS_24 RB=FE_OFN748_i_reset_n_i
Xdata_1_r_reg[38] QDFFRBS $PINS Q=data_1_r[38] D=n1791 CK=CTS_26
+ RB=FE_OFN978_i_reset_n_i
Xweight_1_r_reg[18] QDFFRBN $PINS Q=weight_1_r[18] D=weight_1_w[18] CK=CTS_28
+ RB=FE_OFN767_i_reset_n_i
Xdata_1_r_reg[37] QDFFRBN $PINS Q=data_1_r[37] D=n1790 CK=CTS_26
+ RB=FE_OFN894_i_reset_n_i
Xweight_1_r_reg[23] QDFFRBN $PINS Q=weight_1_r[23] D=weight_1_w[23] CK=CTS_28
+ RB=FE_OFN767_i_reset_n_i
Xdata_0_r_reg[23] QDFFRBN $PINS Q=data_0_r[23] D=n1732 CK=CTS_3
+ RB=FE_OFN693_i_reset_n_i
Xdata_2_r_reg[7] QDFFRBN $PINS Q=data_2_r[7] D=n1807 CK=CTS_20
+ RB=FE_OFN1012_i_reset_n_i
Xweight_2_r_reg[23] QDFFRBP $PINS Q=weight_2_r[23] D=weight_2_w[23] CK=CTS_55
+ RB=FE_OFN609_i_reset_n_i
Xdata_1_r_reg[34] QDFFRBN $PINS Q=data_1_r[34] D=n1787 CK=CTS_26
+ RB=FE_OFN978_i_reset_n_i
Xdata_1_r_reg[12] QDFFRBN $PINS Q=data_1_r[12] D=n1767 CK=CTS_25
+ RB=FE_OFN998_i_reset_n_i
Xdata_2_r_reg[6] QDFFRBN $PINS Q=data_2_r[6] D=n1806 CK=CTS_20
+ RB=FE_OFN947_i_reset_n_i
Xdata_2_r_reg[5] QDFFRBN $PINS Q=data_2_r[5] D=n1805 CK=CTS_20
+ RB=FE_OFN1013_i_reset_n_i
Xweight_1_r_reg[6] QDFFRBN $PINS Q=weight_1_r[6] D=weight_1_w[6] CK=CTS_25
+ RB=FE_OFN768_i_reset_n_i
Xdata_2_r_reg[36] QDFFRBN $PINS Q=data_2_r[36] D=n1834 CK=CTS_38
+ RB=FE_OFN614_i_reset_n_i
Xweight_0_r_reg[19] QDFFRBP $PINS Q=weight_0_r[19] D=weight_0_w[19] CK=CTS_3
+ RB=FE_OFN1009_i_reset_n_i
Xdata_2_r_reg[19] QDFFRBN $PINS Q=data_2_r[19] D=n1818 CK=CTS_24
+ RB=FE_OFN864_i_reset_n_i
Xweight_1_r_reg[12] QDFFRBP $PINS Q=weight_1_r[12] D=weight_1_w[12] CK=CTS_51
+ RB=FE_OFN896_i_reset_n_i
Xweight_1_r_reg[19] QDFFRBP $PINS Q=weight_1_r[19] D=weight_1_w[19] CK=CTS_28
+ RB=FE_OFN893_i_reset_n_i
Xweight_2_r_reg[11] QDFFRBP $PINS Q=weight_2_r[11] D=weight_2_w[11] CK=CTS_24
+ RB=FE_OFN738_i_reset_n_i
Xweight_1_r_reg[5] QDFFRBP $PINS Q=weight_1_r[5] D=weight_1_w[5] CK=CTS_25
+ RB=FE_OFN769_i_reset_n_i
Xweight_2_r_reg[15] QDFFRBN $PINS Q=weight_2_r[15] D=weight_2_w[15] CK=CTS_55
+ RB=FE_OFN611_i_reset_n_i
Xdata_2_r_reg[31] QDFFRBN $PINS Q=data_2_r[31] D=n1830 CK=CTS_55
+ RB=FE_OFN741_i_reset_n_i
XpConv_1/product_1_r_reg[15] QDFFRBP $PINS Q=pConv_1/product_1_r[15]
+ D=pConv_1/product_1_w[15] CK=CTS_51 RB=FE_OFN448_i_reset_n_i
Xweight_2_r_reg[13] QDFFRBP $PINS Q=weight_2_r[13] D=weight_2_w[13] CK=CTS_55
+ RB=FE_OFN610_i_reset_n_i
XpConv_2/product_1_r_reg[17] DFFRBS $PINS Q=n1975 D=pConv_2/product_1_w[17]
+ CK=CTS_46 RB=FE_OFN618_i_reset_n_i
Xdata_1_r_reg[5] QDFFRBN $PINS Q=data_1_r[5] D=n1760 CK=CTS_25
+ RB=FE_OFN810_i_reset_n_i
Xweight_0_r_reg[7] QDFFRBP $PINS Q=weight_0_r[7] D=weight_0_w[7] CK=CTS_2
+ RB=FE_OFN381_i_reset_n_i
XpConv_2/product_1_r_reg[20] QDFFRBS $PINS Q=n1914 D=pConv_2/product_1_w[20]
+ CK=CTS_46 RB=FE_OFN618_i_reset_n_i
XpConv_1/product_1_r_reg[21] DFFRBT $PINS Q=pConv_1/product_1_r[21]
+ QB=DP_OP_57J1_123_9379/n253 D=pConv_1/product_1_w[21] CK=CTS_51
+ RB=FE_OFN388_i_reset_n_i
Xweight_0_r_reg[17] QDFFRBP $PINS Q=weight_0_r[17] D=weight_0_w[17] CK=CTS_3
+ RB=FE_OFN939_i_reset_n_i
XpConv_0/product_0_r_reg[18] DFFRBN $PINS Q=pConv_0/product_0_r[18]
+ D=pConv_0/product_0_w[18] CK=CTS_2 RB=FE_OFN574_i_reset_n_i
XpConv_2/product_2_r_reg[12] QDFFRBN $PINS Q=pConv_2/product_2_r[12]
+ D=pConv_2/product_2_w[12] CK=CTS_55 RB=FE_OFN611_i_reset_n_i
Xdata_2_r_reg[21] QDFFRBN $PINS Q=data_2_r[21] D=n1820 CK=CTS_55
+ RB=FE_OFN1021_i_reset_n_i
Xdata_2_r_reg[14] QDFFRBN $PINS Q=data_2_r[14] D=n1814 CK=CTS_20
+ RB=FE_OFN865_i_reset_n_i
Xweight_2_r_reg[20] QDFFRBN $PINS Q=weight_2_r[20] D=weight_2_w[20] CK=CTS_55
+ RB=FE_OFN609_i_reset_n_i
XpConv_2/product_1_r_reg[21] DFFRBP $PINS Q=pConv_2/product_1_r[21]
+ QB=DP_OP_58J1_124_9379/n253 D=pConv_2/product_1_w[21] CK=CTS_46
+ RB=FE_OFN515_i_reset_n_i
Xweight_2_r_reg[7] QDFFRBP $PINS Q=weight_2_r[7] D=weight_2_w[7] CK=CTS_33
+ RB=FE_OFN679_i_reset_n_i
Xweight_2_r_reg[12] QDFFRBN $PINS Q=weight_2_r[12] D=weight_2_w[12] CK=CTS_55
+ RB=FE_OFN610_i_reset_n_i
Xweight_2_r_reg[16] QDFFRBN $PINS Q=weight_2_r[16] D=weight_2_w[16] CK=CTS_55
+ RB=FE_OFN1023_i_reset_n_i
Xpconv_1_r_reg[20] QDFFRBN $PINS Q=pconv_1_r[20] D=pconv_1_w[20] CK=CTS_52
+ RB=FE_OFN777_i_reset_n_i
XpConv_1/product_1_r_reg[20] DFFRBP $PINS Q=pConv_1/product_1_r[20]
+ D=pConv_1/product_1_w[20] CK=CTS_51 RB=FE_OFN540_i_reset_n_i
XBuffer/counter_temp_reg[2] QDFFRBN $PINS Q=Buffer/counter_temp[2] D=n387
+ CK=CTS_29 RB=FE_OFN634_i_reset_n_i
XBuffer/counter_temp_reg[1] QDFFRBN $PINS Q=Buffer/counter_temp[1] D=n388
+ CK=CTS_29 RB=FE_OFN634_i_reset_n_i
XBuffer/weight_buffer_reg[7] QDFFRBN $PINS Q=weight_0_w[7] D=n461 CK=CTS_29
+ RB=FE_OFN381_i_reset_n_i
XBuffer/weight_buffer_reg[23] QDFFRBN $PINS Q=weight_0_w[23] D=n459 CK=CTS_2
+ RB=FE_OFN474_i_reset_n_i
XBuffer/weight_buffer_reg[15] QDFFRBN $PINS Q=weight_0_w[15] D=n460 CK=CTS_2
+ RB=FE_OFN697_i_reset_n_i
XBuffer/weight_buffer_reg[55] QDFFRBN $PINS Q=weight_2_w[7] D=n455 CK=CTS_33
+ RB=FE_OFN810_i_reset_n_i
XBuffer/weight_buffer_reg[63] QDFFRBN $PINS Q=weight_2_w[15] D=n454 CK=CTS_55
+ RB=FE_OFN610_i_reset_n_i
XBuffer/weight_buffer_reg[22] QDFFRBN $PINS Q=weight_0_w[22] D=n451 CK=CTS_2
+ RB=FE_OFN571_i_reset_n_i
XBuffer/weight_buffer_reg[33] QDFFRBN $PINS Q=weight_1_w[9] D=n404 CK=CTS_28
+ RB=FE_OFN895_i_reset_n_i
XBuffer/weight_buffer_reg[56] QDFFRBN $PINS Q=weight_2_w[8] D=n392 CK=CTS_24
+ RB=FE_OFN740_i_reset_n_i
XBuffer/weight_buffer_reg[65] QDFFRBN $PINS Q=weight_2_w[17] D=n400 CK=CTS_55
+ RB=FE_OFN870_i_reset_n_i
XBuffer/weight_buffer_reg[68] QDFFRBN $PINS Q=weight_2_w[20] D=n427 CK=CTS_55
+ RB=FE_OFN511_i_reset_n_i
XBuffer/weight_buffer_reg[70] QDFFRBN $PINS Q=weight_2_w[22] D=n445 CK=CTS_55
+ RB=FE_OFN429_i_reset_n_i
XU1972 INV1S $PINS O=n8313 I=Buffer/data_buffer[373]
XU1973 INV1S $PINS O=n8499 I=Buffer/data_buffer[372]
XU1974 INV1S $PINS O=n7936 I=Buffer/data_buffer[371]
XU1975 INV1S $PINS O=n8117 I=Buffer/data_buffer[369]
XU1977 INV1S $PINS O=n8118 I=Buffer/data_buffer[377]
XU1978 INV1S $PINS O=n7549 I=Buffer/data_buffer[375]
XU1983 INV1S $PINS O=n7739 I=Buffer/data_buffer[378]
XU1984 INV1S $PINS O=n7363 I=Buffer/data_buffer[382]
XU1985 INV1S $PINS O=n8500 I=Buffer/data_buffer[380]
XU1986 INV1S $PINS O=n7937 I=Buffer/data_buffer[379]
XU1987 INV1S $PINS O=n8314 I=Buffer/data_buffer[381]
XU1988 INV1S $PINS O=n8692 I=Buffer/data_buffer[376]
XU1989 INV1S $PINS O=n7362 I=Buffer/data_buffer[374]
XU1990 INV1S $PINS O=n7738 I=Buffer/data_buffer[370]
XU1992 INV1S $PINS O=n8658 I=Buffer/data_buffer[152]
XU1993 INV1S $PINS O=n7706 I=Buffer/data_buffer[154]
XU1994 INV1S $PINS O=n7904 I=Buffer/data_buffer[155]
XU1995 INV1S $PINS O=n8464 I=Buffer/data_buffer[156]
XU1996 INV1S $PINS O=n7329 I=Buffer/data_buffer[158]
XU1997 INV1S $PINS O=n8085 I=Buffer/data_buffer[145]
XU1998 INV1S $PINS O=n7902 I=Buffer/data_buffer[147]
XU1999 INV1S $PINS O=n8463 I=Buffer/data_buffer[148]
XU2000 INV1S $PINS O=n8280 I=Buffer/data_buffer[149]
XU2001 INV1S $PINS O=n8087 I=Buffer/data_buffer[153]
XU2002 INV1S $PINS O=n7328 I=Buffer/data_buffer[150]
XU2003 INV1S $PINS O=n7705 I=Buffer/data_buffer[146]
XU2004 INV1S $PINS O=n7516 I=Buffer/data_buffer[151]
XU2005 INV1S $PINS O=n7517 I=Buffer/data_buffer[159]
XU2018 AOI12HS $PINS O=n9070 A1=n9068 B1=n2975 B2=n9069
XU2033 INV1S $PINS O=n1913 I=n2011
XU2034 INV1S $PINS O=n1900 I=n1967
XU2035 INV1S $PINS O=n1903 I=n9746
XU2036 AOI12HS $PINS O=n6396 A1=n9163 B1=n9165 B2=n6390
XU2039 AOI12HS $PINS O=n6499 A1=n6498 B1=FE_OCPN9765_n6986 B2=n7271
XU2040 AOI12HS $PINS O=n9408 A1=n9405 B1=FE_OCPN9754_n6785 B2=n9406
XU2041 AOI12HS $PINS O=n6864 A1=n2758 B1=FE_OCPN9720_n6857 B2=n6863
XU2042 AOI12HS $PINS O=n9316 A1=n9313 B1=n7290 B2=n9314
XU2043 INV1S $PINS O=n1917 I=n6879
XU2044 INV1S $PINS O=n1996 I=n2763
XU2049 ND2 $PINS O=n8940 I1=n8935 I2=n8934
XU2050 NR2 $PINS O=n7111 I1=n9173 I2=n7110
XU2051 ND2S $PINS O=n5540 I1=n9324 I2=n2722
XU2052 INV1S $PINS O=n2016 I=n2865
XU2053 INV1S $PINS O=n1902 I=n2056
XU2054 INV1S $PINS O=n1907 I=n1909
XU2055 INV1S $PINS O=n1966 I=n2866
XU2056 INV1S $PINS O=n1987 I=n2862
XU2057 INV1S $PINS O=n1925 I=n2903
XU2066 INV1S $PINS O=n7275 I=n7273
XU2067 INV1S $PINS O=n9383 I=n2477
XU2073 INV1S $PINS O=n8837 I=n8836
XU2075 INV1S $PINS O=n9314 I=n7289
XU2076 INV1S $PINS O=n5678 I=n3250
XU2077 INV2 $PINS O=n3781 I=n3060
XU2080 INV1S $PINS O=n8846 I=n6112
XU2081 OA12 $PINS O=n2846 A1=n9764 B1=n7268 B2=n9766
XU2082 INV1S $PINS O=n7271 I=n6513
XU2083 INV1S $PINS O=n9542 I=n7214
XU2087 INV1S $PINS O=n7280 I=n6391
XU2092 AOI12HS $PINS O=n2967 A1=n4711 B1=n4765 B2=n4712
XU2093 AOI12HS $PINS O=n2968 A1=n4933 B1=n4987 B2=n4934
XU2100 NR2 $PINS O=n2331 I1=n9743 I2=n9742
XU2101 NR2 $PINS O=n2601 I1=n3145 I2=n3627
XU2102 INV1S $PINS O=n8935 I=n7253
XU2104 ND2P $PINS O=n9258 I1=n9275 I2=n9257
XU2105 ND2P $PINS O=n3791 I1=n8928 I2=n3792
XU2109 INV1S $PINS O=n8938 I=n7252
XU2113 NR2P $PINS O=n3451 I1=n8830 I2=n3452
XU2116 ND3 $PINS O=n8957 I1=n8955 I2=FE_OCPN9753_n6521 I3=n8954
XU2121 ND2S $PINS O=n3547 I1=n7117 I2=n3389
XU2122 ND3 $PINS O=n9783 I1=n3572 I2=FE_OCPN9765_n6986 I3=n9781
XU2128 NR2T $PINS O=n6837 I1=n6835 I2=n6836
XU2129 OR2 $PINS O=n2344 I1=n9636 I2=n9640
XU2132 INV1S $PINS O=n8921 I=n8919
XU2135 INV1S $PINS O=n9282 I=n2857
XU2140 INV1S $PINS O=n3804 I=n9140
XU2141 INV1S $PINS O=n9781 I=n6985
XU2144 NR2 $PINS O=n3452 I1=n8831 I2=n8833
XU2148 NR2 $PINS O=n6383 I1=n6382 I2=n9354
XU2151 INV1S $PINS O=n9147 I=n3057
XU2152 INV1S $PINS O=n8954 I=n6526
XU2153 NR2P $PINS O=n3421 I1=n9511 I2=n9510
XU2154 INV1S $PINS O=n9139 I=n9136
XU2155 INV1S $PINS O=n9067 I=n3363
XU2156 INV1S $PINS O=n9376 I=n3484
XU2157 INV1S $PINS O=n9767 I=n3145
XU2158 NR2P $PINS O=n3641 I1=n3404 I2=n9063
XU2159 INV1S $PINS O=n9615 I=n9608
XU2161 INV1S $PINS O=n9149 I=n7276
XU2162 NR2 $PINS O=n4934 I1=n4932 I2=n5019
XU2163 NR2 $PINS O=n4712 I1=n4710 I2=n4797
XU2169 INV1S $PINS O=n2297 I=n6442
XU2172 NR2 $PINS O=n2595 I1=n7253 I2=n7252
XU2175 MOAI1S $PINS O=n9123 A1=FE_OFN1612_n5691 A2=n9121 B1=FE_OFN1547_n9120
+ B2=FE_OFN1340_weight_1_r_7
XU2176 OA12P $PINS O=n6648 A1=n9654 B1=n9659 B2=n9653
XU2179 MOAI1S $PINS O=n9046 A1=FE_OFN1602_n4195 A2=n9045
+ B1=FE_OFN1366_weight_2_r_23 B2=FE_DBTN45_n6822
XU2180 INV4CK $PINS O=n3881 I=n3882
XU2181 INV2 $PINS O=n9145 I=n3805
XU2182 INV3CK $PINS O=n3551 I=n4356
XU2184 INV2 $PINS O=n3455 I=n3741
XU2186 ND2 $PINS O=n9608 I1=n7091 I2=n3852
XU2188 ND2 $PINS O=n6873 I1=n6375 I2=n6374
XU2189 ND2 $PINS O=n6815 I1=FE_DBTN4_n9073 I2=n1961
XU2191 AOI12HS $PINS O=n5131 A1=n5129 B1=n5130 B2=n5284
XU2192 AOI12HS $PINS O=n4909 A1=n4907 B1=n4908 B2=n5062
XU2193 ND2 $PINS O=n9265 I1=n9248 I2=n9247
XU2196 INV1S $PINS O=n9636 I=n3032
XU2197 ND2S $PINS O=n8920 I1=n4657 I2=n4656
XU2199 NR2 $PINS O=n8825 I1=n6439 I2=n6440
XU2200 INV2 $PINS O=n2526 I=n9153
XU2201 NR2 $PINS O=n5222 I1=n5227 I2=n5230
XU2202 NR2 $PINS O=n4778 I1=n4783 I2=n4786
XU2203 NR2 $PINS O=n5000 I1=n5005 I2=n5008
XU2204 NR2 $PINS O=n9747 I1=n9736 I2=n9737
XU2205 NR2 $PINS O=n9384 I1=n6368 I2=n6369
XU2206 MOAI1S $PINS O=n4364 A1=FE_OFN1605_n4596 A2=n4367 B1=FE_OFN9137_n
+ B2=FE_OFN9140_n3387
XU2207 INV2 $PINS O=n2617 I=n6056
XU2208 INV1S $PINS O=n2406 I=n9770
XU2209 INV1S $PINS O=n2602 I=n8842
XU2210 NR2 $PINS O=n4920 I1=n5022 I2=n5025
XU2211 NR2 $PINS O=n5142 I1=n5244 I2=n5247
XU2212 INV1S $PINS O=n2398 I=n9539
XU2213 NR2T $PINS O=n3883 I1=n9648 I2=n9645
XU2214 OAI12HS $PINS O=n4858 A1=n4867 B1=n4866 B2=n4870
XU2215 OAI12HS $PINS O=n5080 A1=n5089 B1=n5088 B2=n5092
XU2216 OAI12HS $PINS O=n5302 A1=n5311 B1=n5310 B2=n5314
XU2217 NR2 $PINS O=n9772 I1=n2638 I2=n6990
XU2218 INV1S $PINS O=n3715 I=n9527
XU2219 NR2 $PINS O=n4698 I1=n4800 I2=n4803
XU2220 NR2P $PINS O=n2405 I1=n9769 I2=n9775
XU2221 NR2 $PINS O=n5206 I1=n5149 I2=n5150
XU2222 NR2 $PINS O=n4984 I1=n4927 I2=n4928
XU2223 NR2 $PINS O=n4762 I1=n4705 I2=n4706
XU2224 NR2 $PINS O=n4827 I1=n4683 I2=n4684
XU2225 NR2 $PINS O=n4866 I1=n4669 I2=n4670
XU2226 NR2 $PINS O=n4822 I1=n4689 I2=n4690
XU2227 NR2 $PINS O=n5088 I1=n4891 I2=n4892
XU2228 NR2 $PINS O=n5310 I1=n5113 I2=n5114
XU2229 NR2 $PINS O=n7214 I1=n6679 I2=n6678
XU2230 ND2 $PINS O=n9304 I1=n4040 I2=n4041
XU2231 ND2 $PINS O=n6859 I1=n6772 I2=n2834
XU2232 NR2 $PINS O=n4786 I1=n4699 I2=n4700
XU2233 NR2 $PINS O=n5008 I1=n4921 I2=n4922
XU2234 NR2 $PINS O=n5230 I1=n5143 I2=n5144
XU2235 NR2 $PINS O=n5083 I1=n4893 I2=n4894
XU2236 NR2P $PINS O=n6851 I1=n6645 I2=n2450
XU2237 ND2 $PINS O=n9171 I1=n5755 I2=n5754
XU2238 ND2 $PINS O=n3583 I1=n1927 I2=n4042
XU2239 NR2 $PINS O=n4803 I1=n4693 I2=n4694
XU2240 NR2 $PINS O=n5025 I1=n4915 I2=n4916
XU2241 ND2P $PINS O=n6307 I1=n9399 I2=n6301
XU2242 NR2 $PINS O=n5247 I1=n5137 I2=n5138
XU2243 ND2 $PINS O=n5045 I1=n4912 I2=n4911
XU2244 NR2P $PINS O=n9306 I1=n7289 I2=n9311
XU2245 ND2P $PINS O=n3619 I1=n9664 I2=n3533
XU2246 XNR2HS $PINS O=n6376 I1=n6151 I2=n3659
XU2247 ND3 $PINS O=n9072 I1=n2761 I2=n3576 I3=n3579
XU2248 MOAI1 $PINS O=n6380 A1=n2530 A2=n2531 B1=n6201 B2=n6202
XU2249 MOAI1 $PINS O=n6437 A1=n3736 A2=n3737 B1=n6431 B2=n6432
XU2250 INV2 $PINS O=n5388 I=layer_num[0]
XU2251 OAI12HS $PINS O=n2516 A1=n7158 B1=n7159 B2=n2519
XU2253 FA1 $PINS S=n4355 CO=n4357 A=n4339 B=n4338 CI=n4337
XU2254 INV1S $PINS O=n2238 I=n6329
XU2255 OAI12HS $PINS O=n2379 A1=n2380 B1=n2384 B2=n9732
XU2256 ND2S $PINS O=n5884 I1=n2299 I2=n2298
XU2257 INV1S $PINS O=n2531 I=n6200
XU2258 ND2P $PINS O=n7270 I1=n6497 I2=n6496
XU2259 INV1S $PINS O=n3736 I=n6430
XU2260 INV1S $PINS O=n2517 I=n7159
XU2261 INV1S $PINS O=n2115 I=n6435
XU2262 ND2 $PINS O=n9788 I1=n2828 I2=n6486
XU2263 INV1S $PINS O=n2237 I=n6330
XU2264 INV1S $PINS O=n2383 I=n2384
XU2265 NR2 $PINS O=n3737 I1=n6432 I2=n6431
XU2266 INV1S $PINS O=n3718 I=n7229
XU2267 INV1S $PINS O=n2668 I=n6930
XU2268 INV1S $PINS O=n3868 I=n7023
XU2269 NR2 $PINS O=n3869 I1=n7025 I2=n7024
XU2270 XOR2HS $PINS O=n3171 I1=n9485 I2=n9484
XU2271 ND2P $PINS O=n3494 I1=n9319 I2=n9320
XU2272 MOAI1S $PINS O=n6419 A1=n3397 A2=n3396 B1=n6425 B2=n3395
XU2273 INV1S $PINS O=n3236 I=n6931
XU2274 INV2 $PINS O=n9172 I=n3353
XU2275 OAI12HS $PINS O=n9478 A1=n3416 B1=n3418 B2=n3417
XU2276 XNR2HS $PINS O=n4642 I1=n4637 I2=n3259
XU2277 INV1S $PINS O=n2652 I=n6082
XU2278 INV1S $PINS O=n3836 I=n6828
XU2279 NR3HP $PINS O=n7293 I1=Buffer/counter_temp[2] I2=Buffer/counter_temp[1]
+ I3=Buffer/counter_temp[0]
XU2280 INV1S $PINS O=n2387 I=n9732
XU2281 INV1S $PINS O=n2114 I=n6434
XU2282 INV1S $PINS O=n3717 I=n7230
XU2283 INV1S $PINS O=n2518 I=n2519
XU2284 NR2 $PINS O=n2530 I1=n6202 I2=n6201
XU2285 OAI12HS $PINS O=n5879 A1=n2525 B1=n3037 B2=n3036
XU2286 XNR2HS $PINS O=n2638 I1=n6970 I2=n3237
XU2287 OAI12HS $PINS O=n6053 A1=n2287 B1=n2289 B2=n2288
XU2289 FA1S $PINS S=n9054 CO=n9051 A=n9050 B=n9049 CI=n9048
XU2290 INV1S $PINS O=n5384 I=layer_num[1]
XU2291 OAI12HS $PINS O=n3081 A1=n6631 B1=n6632 B2=n6633
XU2292 MAO222 $PINS O=n4560 A1=n4556 B1=n4557 C1=n2637
XU2293 INV1S $PINS O=n3592 I=n2820
XU2294 INV1S $PINS O=n2505 I=n5799
XU2295 INV1S $PINS O=n3104 I=n6637
XU2296 OAI12HS $PINS O=n3513 A1=n4562 B1=n4564 B2=n4563
XU2297 INV1S $PINS O=n3418 I=n3419
XU2298 INV1S $PINS O=n3142 I=n6349
XU2299 ND2 $PINS O=n2298 I1=n5869 I2=n5870
XU2300 NR2 $PINS O=n2193 I1=n4304 I2=n4303
XU2301 OAI22S $PINS O=n9708 A1=n6448 A2=n9712 B1=n9703 B2=n9713
XU2302 INV1S $PINS O=n3153 I=n3154
XU2303 OAI12HS $PINS O=n2608 A1=n4083 B1=n4084 B2=n4085
XU2304 INV1S $PINS O=n3814 I=n5793
XU2305 OAI12HS $PINS O=n3416 A1=n9474 B1=n9475 B2=n3419
XU2307 INV1S $PINS O=n3042 I=n6109
XU2308 INV1S $PINS O=n2257 I=n6361
XU2309 INV1S $PINS O=n2319 I=n7217
XU2310 INV1S $PINS O=n2318 I=n7216
XU2311 ND2 $PINS O=n6496 I1=n3726 I2=n3725
XU2312 INV1S $PINS O=n3749 I=n3750
XU2313 OAI22S $PINS O=n9595 A1=n6997 A2=FE_OFN1626_n6531 B1=FE_OFN1455_n2727
+ B2=n9591
XU2314 NR2 $PINS O=n2507 I1=n5801 I2=n5800
XU2315 INV1S $PINS O=n3037 I=n5814
XU2316 INV2 $PINS O=n3617 I=n9673
XU2317 ND2P $PINS O=n1861 I1=n3351 I2=n6780
XU2318 INV1S $PINS O=n3813 I=n5792
XU2319 INV1S $PINS O=n2649 I=n4400
XU2320 INV1S $PINS O=n2632 I=n4224
XU2321 INV1S $PINS O=n2174 I=n4574
XU2322 XNR2HS $PINS O=n4105 I1=n3074 I2=n3073
XU2323 INV1S $PINS O=n3310 I=n4085
XU2324 NR2 $PINS O=n2702 I1=n5803 I2=n5802
XU2325 INV1S $PINS O=n2492 I=n2493
XU2326 INV1S $PINS O=n3437 I=n6166
XU2327 INV1S $PINS O=n3209 I=n7054
XU2328 INV1S $PINS O=n3309 I=n4084
XU2329 INV1S $PINS O=n2491 I=n6346
XU2330 INV1S $PINS O=n3682 I=n6722
XU2331 XNR2HS $PINS O=n6205 I1=n3434 I2=n6165
XU2332 XNR2HS $PINS O=n6973 I1=n2145 I2=n1860
XU2333 XNR2HS $PINS O=n6127 I1=n3742 I2=n3743
XU2334 OAI12HS $PINS O=n6433 A1=n3085 B1=n3086 B2=n3087
XU2335 XNR2HS $PINS O=n6122 I1=n2711 I2=n2710
XU2336 INV1S $PINS O=n2288 I=n6038
XU2337 XNR2HS $PINS O=n2715 I1=n3243 I2=n3244
XU2338 INV1S $PINS O=n3417 I=n9475
XU2339 INV1S $PINS O=n6598 I=n6595
XU2340 INV1S $PINS O=n3462 I=n4453
XU2341 INV1S $PINS O=n3036 I=n5813
XU2342 INV1S $PINS O=n2503 I=n7158
XU2344 INV1S $PINS O=n2175 I=n4573
XU2345 XNR2HS $PINS O=n3035 I1=n5814 I2=n5813
XU2346 INV1S $PINS O=n2289 I=n6039
XU2347 XNR2HS $PINS O=n3525 I1=n9731 I2=n9729
XU2348 XNR2H $PINS O=n6600 I1=n2364 I2=n6601
XU2349 XOR2HS $PINS O=n2729 I1=n2015 I2=n7058
XU2350 FA1S $PINS S=n6152 CO=n6143 A=n6147 B=n6146 CI=n6145
XU2352 INV1S $PINS O=n6694 I=n6691
XU2354 FA1 $PINS S=n7090 CO=n7054 A=n7048 B=n7046 CI=n7047
XU2355 INV1S $PINS O=n3933 I=n3992
XU2356 INV2 $PINS O=n3932 I=n3991
XU2357 INV2 $PINS O=n2130 I=n6761
XU2358 INV1S $PINS O=n2147 I=n6510
XU2359 INV1S $PINS O=n4141 I=n4341
XU2361 INV1S $PINS O=n2072 I=n5920
XU2362 INV1S $PINS O=n2699 I=n6098
XU2364 INV1S $PINS O=n2104 I=n6195
XU2365 ND2 $PINS O=n6827 I1=FE_OFN1366_weight_2_r_23 I2=data_2_r[37]
XU2366 INV1S $PINS O=n3086 I=n6428
XU2367 INV1S $PINS O=n2381 I=n9728
XU2368 NR2 $PINS O=n3810 I1=n3808 I2=n5862
XU2369 NR2 $PINS O=n2448 I1=n6753 I2=n6659
XU2371 ND2 $PINS O=n7002 I1=weight_0_r[15] I2=data_0_r[21]
XU2372 INV1S $PINS O=n3240 I=n6972
XU2373 NR2 $PINS O=n3330 I1=n7230 I2=n7229
XU2374 INV2 $PINS O=n3770 I=n9797
XU2375 XNR2HS $PINS O=n6077 I1=n3730 I2=n6075
XU2376 INV1S $PINS O=n2324 I=n6764
XU2377 INV1S $PINS O=n2612 I=n2613
XU2378 ND2P $PINS O=n3067 I1=n8971 I2=n8969
XU2379 INV1S $PINS O=n2611 I=n4036
XU2380 XOR2HS $PINS O=n6639 I1=n6627 I2=n6541
XU2381 OR2 $PINS O=n3552 I1=n2385 I2=n3528
XU2382 MOAI1S $PINS O=n5867 A1=FE_OFN1669_n5855 A2=n5690 B1=n5689
+ B2=FE_OFN1526_n5853
XU2383 ND2 $PINS O=n7149 I1=FE_OFN1341_weight_1_r_7 I2=data_1_r[5]
XU2384 MOAI1H $PINS O=n4094 A1=n2682 A2=n2681 B1=n2683 B2=n4016
XU2385 INV1S $PINS O=n3262 I=n3263
XU2386 INV1S $PINS O=n2353 I=n2624
XU2387 XOR2HS $PINS O=n1860 I1=n6945 I2=n6944
XU2388 INV1S $PINS O=n2148 I=n3524
XU2389 INV1S $PINS O=n6147 I=n6158
XU2390 NR2 $PINS O=n2382 I1=n9727 I2=n9726
XU2391 MOAI1 $PINS O=n6595 A1=n2307 A2=n2306 B1=n6593 B2=n6592
XU2392 INV1S $PINS O=n2292 I=n6094
XU2393 OR2 $PINS O=n9562 I1=n5652 I2=n5651
XU2394 XNR2HS $PINS O=n2105 I1=n6196 I2=n6195
XU2395 ND3 $PINS O=n4224 I1=n4210 I2=n4211 I3=n4209
XU2396 MOAI1S $PINS O=n6079 A1=FE_DBTN18_n6407 A2=n6061 B1=n1874 B2=n6060
XU2397 MOAI1 $PINS O=n7197 A1=FE_OFN1631_n6658 A2=n7181 B1=FE_OFN9144_n9457
+ B2=n7178
XU2400 XOR2HS $PINS O=n6740 I1=n6751 I2=n6750
XU2401 XNR2HS $PINS O=n7227 I1=n2220 I2=n2219
XU2402 NR2 $PINS O=n3860 I1=n4345 I2=n3861
XU2403 XNR2HS $PINS O=n6363 I1=n6331 I2=n6332
XU2404 XNR2HS $PINS O=n2582 I1=n4609 I2=n4607
XU2405 ND3 $PINS O=n6722 I1=n2020 I2=n2021 I3=n2022
XU2406 INV1S $PINS O=n3630 I=n3631
XU2407 MOAI1 $PINS O=n4422 A1=FE_OFN1480_n4623 A2=n4410 B1=FE_OFN1474_n4495
+ B2=n4409
XU2408 XNR2HS $PINS O=n3084 I1=n3746 I2=n3745
XU2409 XNR2HS $PINS O=n3476 I1=n4296 I2=n3580
XU2410 XNR2HS $PINS O=n3859 I1=n3861 I2=n4345
XU2411 XNR2HS $PINS O=n3825 I1=n4416 I2=FE_OFN9749_n
XU2412 XNR2HS $PINS O=n3474 I1=FE_OFN1694_weight_2_r_17 I2=n4341
XU2413 XNR2HS $PINS O=n2364 I1=n2368 I2=n6602
XU2414 INV1S $PINS O=n2015 I=n7059
XU2416 INV1S $PINS O=n7014 I=n7048
XU2418 INV1S $PINS O=n3279 I=n3280
XU2419 INV1S $PINS O=n4603 I=n4618
XU2420 INV1S $PINS O=n2673 I=n3543
XU2421 ND2 $PINS O=n8969 I1=n4518 I2=n4519
XU2422 ND2 $PINS O=n3904 I1=FE_OFN1673_n4077 I2=n4076
XU2424 INV1S $PINS O=n6059 I=n6060
XU2425 XOR2HS $PINS O=n2556 I1=n2683 I2=n4016
XU2427 INV1S $PINS O=n3517 I=n6483
XU2428 INV1S $PINS O=n3896 I=n4059
XU2431 NR2 $PINS O=n2306 I1=n6592 I2=n6593
XU2432 OR2 $PINS O=n3579 I1=n4298 I2=n4297
XU2433 NR2 $PINS O=n7220 I1=n7213 I2=n7212
XU2434 XOR2HS $PINS O=n2742 I1=n4456 I2=n3182
XU2435 XNR2HS $PINS O=n6194 I1=n3456 I2=n3457
XU2436 ND2 $PINS O=n9179 I1=n5618 I2=n5619
XU2437 INV1S $PINS O=n3112 I=n4301
XU2438 XNR2HS $PINS O=n2219 I1=n7218 I2=n7219
XU2439 INV1S $PINS O=n3840 I=n5751
XU2440 MOAI1 $PINS O=n6896 A1=FE_OFN1587_n1873 A2=n6883
+ B1=FE_OFN1260_weight_0_r_19 B2=FE_OFN1569_FE_DBTN25_n6937
XU2441 ND2P $PINS O=n2572 I1=n2573 I2=n2722
XU2442 NR2 $PINS O=n3528 I1=n2054 I2=FE_OFN1685_n5496
XU2443 INV2 $PINS O=n2662 I=n9413
XU2444 INV1S $PINS O=n4322 I=n4319
XU2445 OAI12HS $PINS O=n2201 A1=n6628 B1=n6629 B2=n2204
XU2446 INV1S $PINS O=n2207 I=n6249
XU2447 XNR2HS $PINS O=n4564 I1=n4549 I2=n4548
XU2448 INV2 $PINS O=n2681 I=n4015
XU2449 MOAI1 $PINS O=n2248 A1=n6101 A2=FE_OFN1436_FE_DBTN18_n6407 B1=n2863
+ B2=n6100
XU2450 MOAI1 $PINS O=n7052 A1=n7037 A2=FE_OFN1635_n7070 B1=n7035
+ B2=FE_OFN1676_n7036
XU2451 XNR2HS $PINS O=n6416 I1=FE_OFN1399_weight_2_r_7 I2=data_2_r[13]
XU2452 INV1S $PINS O=n2735 I=n6297
XU2453 INV1S $PINS O=n4608 I=n4607
XU2454 INV1S $PINS O=n2203 I=n2204
XU2455 XOR2HS $PINS O=n6719 I1=n6711 I2=n3677
XU2456 OAI22S $PINS O=n6962 A1=FE_OFN1587_n1873 A2=n6938 B1=FE_OFN1539_n6937
+ B2=n6936
XU2457 INV1S $PINS O=n2087 I=n6984
XU2458 INV1S $PINS O=n3691 I=n3946
XU2459 INV1S $PINS O=n2202 I=n6629
XU2460 INV1S $PINS O=n3841 I=n5752
XU2461 OAI12HS $PINS O=n4599 A1=n1858 B1=FE_OFN1443_FE_DBTN7_n4532 B2=n4601
XU2462 ND2S $PINS O=n3844 I1=n2703 I2=n5701
XU2463 NR2 $PINS O=n2385 I1=FE_OFN1565_FE_DBTN36_n9707 I2=n9711
XU2464 MOAI1S $PINS O=n6120 A1=FE_OFN1128_FE_DBTN39_n3378 A2=n6102 B1=n6085
+ B2=FE_OFN1528_n6086
XU2465 XNR2HS $PINS O=n4035 I1=n2760 I2=n3420
XU2466 ND2S $PINS O=n2022 I1=n6697 I2=n6696
XU2467 MOAI1H $PINS O=n2613 A1=n3538 A2=n3539 B1=n4032 B2=n4031
XU2468 INV1S $PINS O=n3595 I=n5974
XU2469 MOAI1 $PINS O=n7084 A1=FE_OFN1634_n7070 A2=n7068 B1=FE_OFN1676_n7036
+ B2=n7034
XU2470 INV2 $PINS O=n6959 I=n6958
XU2472 INV1S $PINS O=n4330 I=n4327
XU2473 INV1S $PINS O=n3858 I=n4239
XU2474 INV1S $PINS O=n2712 I=n7008
XU2475 INV1S $PINS O=n3326 I=n3327
XU2478 INV1S $PINS O=n6050 I=n6048
XU2479 NR2 $PINS O=n3772 I1=n5504 I2=n5503
XU2480 OAI12HS $PINS O=n3731 A1=n6075 B1=n6076 B2=n3733
XU2481 ND2 $PINS O=n9187 I1=n2563 I2=n2564
XU2482 INV1S $PINS O=n9677 I=n3305
XU2483 OAI12HS $PINS O=n2494 A1=n5698 B1=n5699 B2=n3808
XU2484 XNR2HS $PINS O=n6261 I1=n6270 I2=n6268
XU2485 INV1S $PINS O=n6717 I=n6716
XU2486 ND2 $PINS O=n2760 I1=n2560 I2=n2726
XU2487 INV1S $PINS O=n2674 I=n6245
XU2488 INV2 $PINS O=n2071 I=n9410
XU2489 INV1S $PINS O=n3314 I=n3380
XU2490 NR2 $PINS O=n9102 I1=n3565 I2=n2270
XU2491 INV1S $PINS O=n2418 I=n2419
XU2492 ND2 $PINS O=n2576 I1=FE_OFN1452_n2589 I2=n2741
XU2493 INV2 $PINS O=n3568 I=n6217
XU2494 INV1S $PINS O=n3339 I=n3340
XU2495 XOR2HS $PINS O=n4301 I1=n4282 I2=n4283
XU2496 INV1S $PINS O=n6883 I=n6886
XU2497 ND2 $PINS O=n3608 I1=n6187 I2=FE_OFN1442_FE_DBTN9_n3607
XU2498 OAI12HS $PINS O=n4335 A1=n3473 B1=n7115 B2=FE_OFN1694_weight_2_r_17
XU2499 OR2 $PINS O=n3636 I1=n3637 I2=n7050
XU2500 INV1S $PINS O=n3732 I=n6076
XU2501 XNR2HS $PINS O=n6025 I1=n6009 I2=n6011
XU2502 INV1S $PINS O=n6887 I=n6915
XU2503 INV1S $PINS O=n3878 I=n3879
XU2504 XNR2HS $PINS O=n3895 I1=data_1_r[31]
+ I2=FE_OCPN9731_FE_OFN1327_weight_1_r_11
XU2505 INV1S $PINS O=n3877 I=n7080
XU2506 INV1S $PINS O=n4072 I=n4071
XU2508 NR2 $PINS O=n3709 I1=n3710 I2=n6681
XU2509 INV1S $PINS O=n3182 I=n4457
XU2510 NR2 $PINS O=n2471 I1=n3899 I2=FE_DBTN21_n3428
XU2511 XNR2HS $PINS O=n6297 I1=n6293 I2=n6291
XU2513 INV1S $PINS O=n2393 I=n9462
XU2514 XNR2HS $PINS O=n6492 I1=n6477 I2=n6478
XU2515 INV1S $PINS O=n6341 I=n6340
XU2516 INV1S $PINS O=n4056 I=n4096
XU2517 XNR2HS $PINS O=n6662 I1=data_0_r[10] I2=FE_OFN1288_weight_0_r_5
XU2518 XNR2HS $PINS O=n6003 I1=n5998 I2=n6000
XU2520 INV1S $PINS O=n2743 I=n4440
XU2521 ND3 $PINS O=n2665 I1=n6234 I2=n6232 I3=n6233
XU2522 INV1S $PINS O=n4067 I=n4068
XU2523 XNR2HS $PINS O=n2442 I1=n4220 I2=n4221
XU2526 NR2P $PINS O=n5776 I1=n5778 I2=n5757
XU2527 INV1S $PINS O=n7212 I=n7211
XU2528 NR2 $PINS O=n3295 I1=n9456 I2=FE_OFN1631_n6658
XU2529 XOR2HS $PINS O=n2019 I1=n6696 I2=n6697
XU2530 XOR2HS $PINS O=n9462 I1=data_0_r[15] I2=FE_OCPN9757_weight_0_r_5
XU2532 INV1S $PINS O=n3733 I=n6424
XU2533 INV1S $PINS O=n3900 I=n4065
XU2534 INV1S $PINS O=n6581 I=n6609
XU2535 INV1S $PINS O=n3999 I=n3998
XU2536 MAO222 $PINS O=n3989 A1=n3982 B1=n3983 C1=n2303
XU2537 INV1S $PINS O=n4546 I=n4545
XU2538 NR2 $PINS O=n3560 I1=n6730 I2=n9457
XU2539 INV2 $PINS O=n6051 I=n2692
XU2540 ND2S $PINS O=n6899 I1=FE_OFN1587_n1873 I2=FE_OFN1539_n6937
XU2541 XOR2HS $PINS O=n4436 I1=data_2_r[26] I2=FE_OFN1661_weight_2_r_9
XU2542 INV1S $PINS O=n3211 I=n6711
XU2543 NR2 $PINS O=n9234 I1=n3672 I2=FE_OFN1431_FE_DBTN26_weight_1_r_15
XU2544 INV1S $PINS O=n4292 I=n4311
XU2545 ND2 $PINS O=n7048 I1=FE_OFN1267_weight_0_r_15 I2=data_0_r[18]
XU2546 XOR2HS $PINS O=n9463 I1=FE_OCPN9757_weight_0_r_5 I2=data_0_r[14]
XU2548 ND2 $PINS O=n6193 I1=FE_OFN1304_weight_1_r_23 I2=data_1_r[34]
XU2549 XNR2HS $PINS O=n7187 I1=FE_OFN9130_weight_0_r_3 I2=data_0_r[14]
XU2550 INV1S $PINS O=n6623 I=n6621
XU2551 INV1S $PINS O=n3678 I=n3423
XU2552 INV1S $PINS O=n7195 I=n7204
XU2553 INV1S $PINS O=n3647 I=n6264
XU2554 NR2 $PINS O=n3368 I1=n4312 I2=FE_OFN1559_FE_DBTN41_n4329
XU2555 INV1S $PINS O=n6544 I=n6543
XU2556 INV1S $PINS O=n3839 I=n5760
XU2557 NR2 $PINS O=n3431 I1=FE_DBTN10_n9120 I2=n3505
XU2558 NR2 $PINS O=n3320 I1=n5988 I2=n5987
XU2559 NR2P $PINS O=n5757 I1=n3288 I2=n3289
XU2560 NR2 $PINS O=n3559 I1=n6731 I2=n6658
XU2561 INV1S $PINS O=n2680 I=n6286
XU2562 NR2 $PINS O=n3247 I1=n4198 I2=n4197
XU2563 INV1S $PINS O=n4218 I=n4232
XU2564 INV1S $PINS O=n6021 I=n6020
XU2565 ND2 $PINS O=n2151 I1=n9697 I2=n6942
XU2567 ND2P $PINS O=n9106 I1=n4160 I2=n3764
XU2568 NR2 $PINS O=n9577 I1=n2377 I2=n5668
XU2569 INV1S $PINS O=n3808 I=n7146
XU2570 AN2 $PINS O=n2059 I1=n6090 I2=FE_OFN1450_n2480
XU2571 AOI22S $PINS O=n6022 A1=n6012 A2=FE_OFN1410_weight_2_r_0 B1=n6005
+ B2=FE_OFN1457_n3162
XU2572 INV1S $PINS O=n3819 I=n3820
XU2574 INV1S $PINS O=n3894 I=n3898
XU2575 XNR2HS $PINS O=n7034 I1=data_0_r[30] I2=FE_DBTN34_weight_0_r_11
XU2576 INV1S $PINS O=n2687 I=n2688
XU2577 XNR2HS $PINS O=n7176 I1=FE_OFN9130_weight_0_r_3 I2=data_0_r[15]
XU2578 INV1S $PINS O=n3220 I=n6656
XU2580 XOR2HS $PINS O=n6181 I1=data_1_r[44] I2=FE_OFN1530_n6178
XU2581 ND2S $PINS O=n2520 I1=n5816 I2=FE_OFN1547_n9120
XU2582 INV1S $PINS O=n3818 I=n5724
XU2583 XOR2HS $PINS O=n2357 I1=n5983 I2=n5982
XU2584 XNR2HS $PINS O=n6535 I1=n3078 I2=FE_OFN1276_weight_0_r_11
XU2585 XOR2HS $PINS O=n6953 I1=data_0_r[41] I2=FE_OFN1551_n9711
XU2586 NR2 $PINS O=n3535 I1=n6270 I2=n6269
XU2587 INV1S $PINS O=n2560 I=n4028
XU2588 XOR2HS $PINS O=n7208 I1=FE_OFN1288_weight_0_r_5 I2=data_0_r[11]
XU2589 XOR2HS $PINS O=n2672 I1=n6286 I2=n2677
XU2590 AOI22S $PINS O=n6342 A1=n6316 A2=FE_DBTN2_weight_1_r_16
+ B1=FE_OFN1442_FE_DBTN9_n3607 B2=n6281
XU2591 MOAI1 $PINS O=n6354 A1=n6334 A2=FE_OFN1568_FE_DBTN31_n6225 B1=n6288
+ B2=FE_OFN9124_n3656
XU2592 INV1S $PINS O=n3704 I=n5675
XU2593 INV1S $PINS O=n6625 I=n6624
XU2594 INV1S $PINS O=n3341 I=n6534
XU2595 XNR2HS $PINS O=n5979 I1=n5986 I2=n5988
XU2596 XNR2HS $PINS O=n5758 I1=FE_OFN1345_weight_1_r_5 I2=data_1_r[8]
XU2597 XNR2HS $PINS O=n3899 I1=FE_OFN1319_weight_1_r_15 I2=data_1_r[26]
XU2601 INV1S $PINS O=n5717 I=n5721
XU2602 INV1S $PINS O=n6655 I=n6667
XU2603 INV2 $PINS O=n2677 I=n2678
XU2604 NR2 $PINS O=n7146 I1=n3492 I2=FE_OFN1429_FE_DBTN32_weight_1_r_7
XU2605 XOR2HS $PINS O=n6603 I1=FE_OFN1278_weight_0_r_9 I2=data_0_r[25]
XU2606 INV1S $PINS O=n5694 I=n5835
XU2607 MAO222 $PINS O=n5582 A1=n5587 B1=n5588 C1=n5589
XU2608 INV1S $PINS O=n7043 I=n7039
XU2611 NR2 $PINS O=n5675 I1=n5671 I2=n5670
XU2614 XNR2HS $PINS O=n6685 I1=FE_OFN1291_weight_0_r_5 I2=data_0_r[3]
XU2615 NR2 $PINS O=n4510 I1=n3443 I2=n4497
XU2616 INV1S $PINS O=n4447 I=n4524
XU2619 ND2 $PINS O=n3350 I1=n7039 I2=FE_OFN1628_n6532
XU2620 NR2 $PINS O=n2133 I1=n6000 I2=n5999
XU2621 XNR2HS $PINS O=n6316 I1=data_1_r[45] I2=FE_OFN1531_n6191
XU2622 MOAI1S $PINS O=n4207 A1=n7115 A2=n4190 B1=FE_OFN1470_n4306 B2=n4189
XU2624 XOR2HS $PINS O=n7171 I1=FE_OCPN9757_weight_0_r_5 I2=data_0_r[13]
XU2625 INV1S $PINS O=n3880 I=n7040
XU2626 XOR2HS $PINS O=n4065 I1=FE_OFN1320_weight_1_r_15 I2=data_1_r[25]
XU2627 INV1S $PINS O=n2411 I=n5566
XU2628 XNR2HS $PINS O=n6337 I1=FE_OFN1312_weight_1_r_19 I2=data_1_r[44]
XU2629 XOR2HS $PINS O=n2428 I1=data_1_r[42] I2=FE_OFN1530_n6178
XU2630 XNR2HS $PINS O=n4132 I1=data_2_r[44] I2=FE_OFN9147_n
XU2632 XNR2HS $PINS O=n5763 I1=FE_OFN1340_weight_1_r_7 I2=data_1_r[6]
XU2633 INV1S $PINS O=n3936 I=n3935
XU2634 INV1S $PINS O=n2410 I=n5567
XU2635 NR2P $PINS O=n8869 I1=n5591 I2=n5590
XU2636 XNR2HS $PINS O=n4021 I1=FE_OFN1328_weight_1_r_11 I2=data_1_r[23]
XU2637 INV1S $PINS O=n5668 I=n5666
XU2638 INV1S $PINS O=n4241 I=n4240
XU2639 INV1S $PINS O=n3529 I=n6934
XU2640 XNR2HS $PINS O=n4196 I1=data_2_r[33] I2=FE_OFN9145_n
XU2641 INV1S $PINS O=n2495 I=n5692
XU2642 XNR2HS $PINS O=n5715 I1=data_1_r[3] I2=FE_OCPN9750_weight_1_r_5
XU2643 XNR2HS $PINS O=n6586 I1=weight_0_r[15] I2=FE_OFN1301_data_0_r_17
XU2645 XNR2HS $PINS O=n6668 I1=FE_OFN1284_weight_0_r_7 I2=data_0_r[6]
XU2646 OR2 $PINS O=n2444 I1=n4288 I2=FE_OFN1702_n6822
XU2649 INV2 $PINS O=n6292 I=n6291
XU2651 INV1S $PINS O=n6913 I=n2012
XU2653 MOAI1 $PINS O=n5705 A1=n5612 A2=n5680 B1=n7135 B2=n1969
XU2654 ND2 $PINS O=n2705 I1=FE_OFN1526_n5853 I2=FE_OFN1350_weight_1_r_3
XU2655 XOR2HS $PINS O=n6656 I1=data_0_r[8] I2=FE_OFN1288_weight_0_r_5
XU2657 NR2 $PINS O=n3313 I1=FE_OFN1677_n7036 I2=n6582
XU2659 INV2 $PINS O=n6278 I=n6277
XU2661 INV1S $PINS O=n2744 I=n4259
XU2663 INV1S $PINS O=n5967 I=n5984
XU2664 INV1S $PINS O=n6017 I=n6016
XU2671 XOR2HS $PINS O=n4013 I1=FE_OFN1333_weight_1_r_9 I2=data_1_r[26]
XU2673 XOR2HS $PINS O=n4012 I1=FE_OFN1333_weight_1_r_9 I2=data_1_r[25]
XU2675 INV1S $PINS O=n3482 I=n6321
XU2676 XOR2HS $PINS O=n6090 I1=FE_OFN1399_weight_2_r_7 I2=data_2_r[9]
XU2677 XNR2HS $PINS O=n7035 I1=data_0_r[31] I2=FE_DBTN34_weight_0_r_11
XU2679 INV1S $PINS O=n3735 I=data_2_r[2]
XU2680 INV1S $PINS O=n2358 I=n5544
XU2682 NR2 $PINS O=n6590 I1=FE_OFN1456_n2771 I2=n2727
XU2683 INV1S $PINS O=n7006 I=data_0_r[19]
XU2684 NR2 $PINS O=n3972 I1=n3959 I2=n3609
XU2685 INV1S $PINS O=n2486 I=n5474
XU2686 NR2 $PINS O=n3773 I1=n6710 I2=n6658
XU2687 INV1S $PINS O=n3648 I=n3649
XU2688 XNR2HS $PINS O=n6714 I1=data_0_r[5] I2=FE_OFN1290_weight_0_r_5
XU2689 OAI22S $PINS O=n5672 A1=n5642 A2=n2891 B1=FE_OFN1699_n7188 B2=n5650
XU2690 XNR2HS $PINS O=n4230 I1=data_2_r[35] I2=weight_2_r[23]
XU2691 XNR2HS $PINS O=n4003 I1=FE_OFN1320_weight_1_r_15 I2=data_1_r[21]
XU2692 INV1S $PINS O=n3765 I=n4162
XU2693 XOR2HS $PINS O=n5645 I1=FE_OFN1291_weight_0_r_5 I2=data_0_r[1]
XU2694 XOR2HS $PINS O=n6713 I1=data_0_r[4] I2=FE_OFN1291_weight_0_r_5
XU2695 XOR2HS $PINS O=n5740 I1=data_1_r[2] I2=weight_1_r[7]
XU2696 INV1S $PINS O=n6010 I=n6009
XU2697 XOR2HS $PINS O=n6458 I1=FE_OFN1263_weight_0_r_17 I2=data_0_r[41]
XU2699 XOR2HS $PINS O=n5692 I1=data_1_r[11] I2=FE_OFN1342_weight_1_r_7
XU2700 NR2 $PINS O=n3875 I1=n2771 I2=FE_OFN1677_n7036
XU2701 INV1S $PINS O=n2283 I=n6257
XU2702 XNR2HS $PINS O=n6605 I1=FE_OFN1267_weight_0_r_15 I2=data_0_r[20]
XU2703 XOR2HS $PINS O=n6449 I1=FE_OFN1253_weight_0_r_21 I2=data_0_r[36]
XU2704 AOI22S $PINS O=n6000 A1=n5989 A2=FE_OFN1410_weight_2_r_0
+ B1=FE_OFN1650_n3162 B2=n2426
XU2705 XNR2HS $PINS O=n6699 I1=weight_0_r[7] I2=data_0_r[1]
XU2706 INV1S $PINS O=n3443 I=n3444
XU2707 INV1S $PINS O=n2487 I=n2488
XU2709 INV1S $PINS O=n3342 I=data_0_r[24]
XU2710 XNR2HS $PINS O=n5567 I1=n5559 I2=n5558
XU2711 OR2 $PINS O=n3604 I1=FE_OFN9129_weight_0_r_3 I2=n6688
XU2713 INV1S $PINS O=n2160 I=data_0_r[45]
XU2714 INV1S $PINS O=n3694 I=n3821
XU2715 MOAI1 $PINS O=n5891 A1=n5499 A2=FE_OFN1564_FE_DBTN36_n9707
+ B1=FE_OFN1683_n5496 B2=weight_0_r[21]
XU2716 XOR2HS $PINS O=n4253 I1=data_2_r[41] I2=FE_OFN1466_n4128
XU2717 INV1S $PINS O=n5995 I=n6007
XU2718 NR2 $PINS O=n3929 I1=FE_OFN1426_FE_DBTN44_weight_1_r_11 I2=n2052
XU2719 ND2 $PINS O=n3603 I1=n6689 I2=FE_OFN9129_weight_0_r_3
XU2721 XOR2HS $PINS O=n7039 I1=FE_OFN1269_weight_0_r_15 I2=data_0_r[25]
XU2722 MOAI1 $PINS O=n5673 A1=n7180 A2=n5641 B1=FE_OFN1523_n5640 B2=n5655
XU2723 ND2S $PINS O=n9812 I1=n5516 I2=n5515
XU2724 OAI22H $PINS O=n6507 A1=n6464 A2=FE_OFN1622_n6448 B1=FE_OFN1553_n9713
+ B2=n6502
XU2729 AO22 $PINS O=n5932 A1=n2295 A2=FE_OCPN9772_n6407 B1=n1874
+ B2=FE_OFN1403_weight_2_r_5
XU2731 INV1S $PINS O=n4622 I=n4495
XU2735 INV2 $PINS O=n3375 I=n4181
XU2741 INV1S $PINS O=n7115 I=FE_OFN1377_weight_2_r_16
XU2747 INV1S $PINS O=n3459 I=n5487
XU2748 XNR2HS $PINS O=n6502 I1=FE_OFN1248_weight_0_r_23 I2=data_0_r[37]
XU2755 INV1S $PINS O=n3800 I=n5615
XU2756 INV1S $PINS O=n5728 I=data_1_r[3]
XU2761 XOR2HS $PINS O=n5816 I1=data_1_r[7] I2=FE_OFN1340_weight_1_r_7
XU2762 OAI22S $PINS O=n5998 A1=n5981 A2=n5980 B1=n6414 B2=n5990
XU2764 ND3 $PINS O=n5653 I1=weight_0_r[3] I2=n9465 I3=n7179
XU2765 INV1S $PINS O=n5963 I=n5962
XU2766 ND3 $PINS O=n4155 I1=FE_OCPN9767_weight_2_r_19 I2=n4329
+ I3=FE_OFN1130_FE_DBTN30_data_2_r_33
XU2767 XNR2HS $PINS O=n4259 I1=data_2_r[42] I2=FE_OFN1466_n4128
XU2768 INV1S $PINS O=n6884 I=data_0_r[35]
XU2770 XOR2HS $PINS O=n5993 I1=data_2_r[6] I2=FE_OFN1532_n6412
XU2771 XOR2HS $PINS O=n6007 I1=FE_OFN1402_weight_2_r_5 I2=data_2_r[7]
XU2772 XNR2HS $PINS O=n6321 I1=FE_OFN1307_weight_1_r_23 I2=data_1_r[40]
XU2774 XOR2HS $PINS O=n6466 I1=data_0_r[38] I2=FE_OFN1551_n9711
XU2776 XNR2HS $PINS O=n6731 I1=weight_0_r[7] I2=data_0_r[3]
XU2778 XNR2HS $PINS O=n2848 I1=data_0_r[35] I2=FE_OFN1551_n9711
XU2779 XNR2HS $PINS O=n4274 I1=data_2_r[39] I2=FE_OFN1364_weight_2_r_23
XU2780 ND2 $PINS O=n2719 I1=FE_DBTN3_n6322 I2=n6236
XU2781 XOR2HS $PINS O=n5613 I1=FE_OFN1425_FE_DBTN49_data_1_r_1
+ I2=FE_OCPN9750_weight_1_r_5
XU2782 XNR2HS $PINS O=n4175 I1=data_2_r[36] I2=FE_OFN1465_n4128
XU2783 NR2 $PINS O=n2412 I1=FE_OFN1428_FE_DBTN34_weight_0_r_11
+ I2=FE_OFN1301_data_0_r_17
XU2784 XOR2HS $PINS O=n6041 I1=FE_OFN1398_weight_2_r_7 I2=data_2_r[7]
XU2785 ND2S $PINS O=n8880 I1=n5600 I2=n5599
XU2786 MOAI1S $PINS O=n5516 A1=FE_OFN1514_n5491 A2=n5513 B1=weight_0_r[16]
+ B2=n5512
XU2797 INV1S $PINS O=n5706 I=data_1_r[4]
XU2800 XOR2HS $PINS O=n3922 I1=FE_OFN1333_weight_1_r_9 I2=data_1_r[23]
XU2804 XNR2HS $PINS O=n6275 I1=data_1_r[39] I2=FE_OFN1530_n6178
XU2805 INV1S $PINS O=n9349 I=FE_OFN1337_weight_1_r_8
XU2809 XNR2HS $PINS O=n6272 I1=data_1_r[37] I2=FE_OFN1304_weight_1_r_23
XU2810 NR2P $PINS O=n3824 I1=FE_OFN1247_n9348 I2=FE_OFN1572_FE_DBTN21_n3428
XU2811 INV1S $PINS O=n2461 I=n5481
XU2812 XOR2HS $PINS O=n4501 I1=data_2_r[19] I2=FE_OFN1394_weight_2_r_9
XU2817 XOR2HS $PINS O=n5661 I1=data_0_r[3] I2=FE_OFN1297_weight_0_r_1
XU2818 NR2 $PINS O=n5955 I1=n8888 I2=n6414
XU2819 NR2P $PINS O=n5523 I1=FE_OFN1131_FE_DBTN29_data_0_r_33
+ I2=FE_OFN1564_FE_DBTN36_n9707
XU2820 XNR2HS $PINS O=n4249 I1=data_2_r[37] I2=weight_2_r[23]
XU2821 INV1S $PINS O=n9455 I=data_0_r[4]
XU2822 XNR2HS $PINS O=n5990 I1=data_2_r[4] I2=FE_OFN1400_weight_2_r_7
XU2824 INV1S $PINS O=n2295 I=n5577
XU2825 XNR2HS $PINS O=n5615 I1=FE_OFN1351_weight_1_r_1 I2=n3801
XU2826 NR2 $PINS O=n9344 I1=n3960 I2=FE_OFN1460_n3961
XU2827 ND3 $PINS O=n5505 I1=FE_DBTN25_n6937 I2=FE_OFN1256_weight_0_r_19
+ I3=FE_OFN1131_FE_DBTN29_data_0_r_33
XU2831 AOI22S $PINS O=n5525 A1=n5506 A2=weight_0_r[16] B1=FE_OFN1697_n5491
+ B2=n5512
XU2832 XNR2HS $PINS O=n7135 I1=weight_1_r[4] I2=FE_OFN9135_weight_1_r_3
XU2841 XNR2HS $PINS O=n4163 I1=data_2_r[34] I2=FE_OFN1465_n4128
XU2842 NR2 $PINS O=n5589 I1=FE_OFN1246_n8888 I2=FE_OFN1435_FE_DBTN18_n6407
XU2843 INV1S $PINS O=n3801 I=data_1_r[5]
XU2844 XOR2HS $PINS O=n6215 I1=weight_1_r[17] I2=data_1_r[38]
XU2845 NR2 $PINS O=n5611 I1=weight_1_r[4] I2=n5680
XU2846 NR2 $PINS O=n6530 I1=weight_0_r[14] I2=FE_OFN9748_weight_0_r_13
XU2849 XOR2HS $PINS O=n5506 I1=data_0_r[36] I2=weight_0_r[17]
XU2851 OAI12HS $PINS O=n1852 A1=n5477 B1=FE_OFN1679_n3135 B2=n5478
XU2852 ND2 $PINS O=n3438 I1=weight_2_r[15] I2=n3440
XU2854 NR2 $PINS O=n5687 I1=weight_1_r[6] I2=FE_OFN1343_weight_1_r_5
XU2855 INV1S $PINS O=n2771 I=FE_OFN1301_data_0_r_17
XU2856 ND2 $PINS O=n5577 I1=n8888 I2=FE_OFN1403_weight_2_r_5
XU2857 XNR2HS $PINS O=n3954 I1=FE_OFN1426_FE_DBTN44_weight_1_r_11
+ I2=data_1_r[17]
XU2859 XOR2HS $PINS O=n5621 I1=data_1_r[2] I2=n5725
XU2860 XNR2HS $PINS O=n5960 I1=data_2_r[5] I2=FE_OFN1406_weight_2_r_3
XU2861 XOR2HS $PINS O=n4470 I1=FE_OFN9142_n I2=data_2_r[20]
XU2862 MXL2HS $PINS OB=n5940 S=FE_OFN1404_weight_2_r_3 A=n5939 B=n2403
XU2864 AOI22S $PINS O=n5594 A1=n5583 A2=FE_OFN1413_weight_2_r_0
+ B1=FE_OFN1458_n3162 B2=n5597
XU2866 INV1S $PINS O=n3965 I=FE_OFN1460_n3961
XU2875 INV1S $PINS O=n4202 I=weight_2_r[20]
XU2876 XOR2HS $PINS O=n5583 I1=data_2_r[4] I2=FE_OFN1407_weight_2_r_1
XU2877 INV1S $PINS O=n3203 I=n4475
XU2883 INV1S $PINS O=n6893 I=data_0_r[36]
XU2887 ND2 $PINS O=n2466 I1=n3651 I2=FE_OFN1311_weight_1_r_19
XU2891 INV1S $PINS O=n2080 I=n3918
XU2894 INV1S $PINS O=n2479 I=weight_2_r[6]
XU2895 INV2 $PINS O=n5729 I=weight_1_r[4]
XU2896 INV1S $PINS O=n6224 I=weight_1_r[20]
XU2900 XNR2HS $PINS O=n5476 I1=data_1_r[34] I2=n2033
XU2902 INV1S $PINS O=n3429 I=weight_1_r[14]
XU2909 INV1S $PINS O=n5914 I=weight_0_r[20]
XU2910 INV1S $PINS O=n5957 I=weight_2_r[4]
XU2913 INV1S $PINS O=n6071 I=data_2_r[4]
XU2914 XNR2HS $PINS O=n1875 I1=weight_1_r[18] I2=FE_OFN1314_weight_1_r_17
XU2916 MOAI1S $PINS O=n4554 A1=FE_DBTN7_n4532 A2=n4474
+ B1=FE_OCPN9759_FE_DBTN19_n4371 B2=n4473
XU2917 MOAI1 $PINS O=n6020 A1=FE_OFN1665_n5980 A2=n6006 B1=FE_OFN1450_n2480
+ B2=n3136
XU2918 OAI12H $PINS O=n4016 A1=n2557 B1=FE_OFN1637_n9221 B2=n3996
XU2919 ND2 $PINS O=n3590 I1=n6002 I2=n6003
XU2920 ND2P $PINS O=n6031 I1=n3591 I2=n3590
XU2921 XNR2HS $PINS O=n4544 I1=FE_OFN9143_n I2=data_2_r[22]
XU2923 AOI12HS $PINS O=n5959 A1=n5573 B1=n3740 B2=data_2_r[3]
XU2924 INV1S $PINS O=n3823 I=n3824
XU2926 NR2 $PINS O=n4634 I1=n4627 I2=n4626
XU2927 MOAI1H $PINS O=n4636 A1=FE_OFN1444_FE_DBTN7_n4532 A2=n4620
+ B1=FE_OFN1434_FE_DBTN19_n4371 B2=n4618
XU2928 INV1S $PINS O=n4429 I=n4442
XU2929 NR2 $PINS O=n7289 I1=n4037 I2=n2425
XU2930 ND2P $PINS O=n9312 I1=n2425 I2=n4037
XU2931 ND2P $PINS O=n3830 I1=n9181 I2=n9179
XU2933 OAI12HS $PINS O=n3741 A1=n7260 B1=n7259 B2=n8834
XU2934 INV1S $PINS O=n3600 I=n3683
XU2937 INV1S $PINS O=n6912 I=n6950
XU2938 MOAI1 $PINS O=n6553 A1=FE_OFN1627_n6531 A2=n6539 B1=n6543
+ B2=FE_OFN1628_n6532
XU2939 NR2 $PINS O=n6112 I1=n6053 I2=n6054
XU2940 XNR2HS $PINS O=n6054 I1=n6109 I2=n3041
XU2941 ND3P $PINS O=n3150 I1=n6777 I2=FE_OCPN9771_n3747 I3=n9534
XU2942 ND3P $PINS O=n9499 I1=n6777 I2=n9487 I3=n9520
XU2943 ND3P $PINS O=n9515 I1=n6777 I2=n9520 I3=n9512
XU2944 ND3P $PINS O=n9525 I1=n6777 I2=n9521 I3=n9520
XU2945 NR2 $PINS O=n3245 I1=n6730 I2=n6658
XU2946 MOAI1S $PINS O=n6716 A1=n6658 A2=n6699 B1=FE_OFN9144_n9457 B2=n6709
XU2947 MOAI1 $PINS O=n6670 A1=FE_OFN1630_n6658 A2=n6668 B1=FE_OFN9144_n9457
+ B2=n6667
XU2948 ND3 $PINS O=n8931 I1=n2029 I2=n8926 I3=n8927
XU2949 ND3 $PINS O=n3205 I1=n2029 I2=n8926 I3=n7127
XU2950 ND2T $PINS O=n6649 I1=n3414 I2=n6644
XU2952 OAI22S $PINS O=n6119 A1=n6102 A2=n6103 B1=n6105
+ B2=FE_OFN1129_FE_DBTN39_n3378
XU2953 ND3P $PINS O=n3189 I1=n7107 I2=n7105 I3=n7106
XU2954 ND2 $PINS O=n6370 I1=n2228 I2=n2227
XU2955 OAI12HS $PINS O=n2228 A1=n6358 B1=n6359 B2=n6360
XU2956 OAI12HS $PINS O=n4208 A1=n3729 B1=FE_OFN1577_FE_DBTN17_n6819 B2=n4188
XU2957 XNR2HS $PINS O=pConv_0/product_2_w[14] I1=n2004 I2=n9773
XU2958 ND3P $PINS O=n2168 I1=n3409 I2=n2251 I3=n3410
XU2959 ND2 $PINS O=n9779 I1=n6989 I2=n6988
XU2960 NR2T $PINS O=n9778 I1=n6989 I2=n6988
XU2963 NR2T $PINS O=n3790 I1=n3793 I2=n8929
XU2967 ND2 $PINS O=n9355 I1=n9353 I2=n9364
XU2968 INV2 $PINS O=n3793 I=n1848
XU2969 NR2 $PINS O=n1848 I1=n8919 I2=n8924
XU2970 INV1S $PINS O=n1849 I=n4221
XU2971 ND2 $PINS O=n3746 I1=n1849 I2=n4220
XU2972 INV1S $PINS O=n4448 I=n4548
XU2973 FA1 $PINS S=n4646 CO=n4647 A=n4612 B=n4611 CI=n4610
XU2975 INV1S $PINS O=n3783 I=n4446
XU2976 INV1S $PINS O=n2027 I=n2028
XU2977 XNR2H $PINS O=n2300 I1=n5869 I2=n5870
XU2978 MAO222P $PINS O=n5869 A1=n2389 B1=n5849 C1=n5848
XU2979 XNR2HS $PINS O=n4206 I1=n1850 I2=n3248
XU2980 XOR2HS $PINS O=n1850 I1=n4198 I2=n4197
XU2983 OAI12HS $PINS O=n3685 A1=n3838 B1=n3687 B2=n6742
XU2984 INV1S $PINS O=n5817 I=n5816
XU2986 ND3HT $PINS O=n6308 I1=n6785 I2=n6301 I3=n2849
XU2987 INV2 $PINS O=n2057 I=n1852
XU2991 INV1S $PINS O=n6107 I=n6106
XU2992 ND2S $PINS O=n4123 I1=n9275 I2=n7123
XU2993 OAI12HP $PINS O=n9275 A1=n2548 B1=n9283 B2=n4122
XU2994 OR2 $PINS O=n2865 I1=n8831 I2=n8830
XU2995 INV1S $PINS O=n2745 I=n4260
XU2996 NR2P $PINS O=n6798 I1=n4269 I2=n4270
XU2997 XNR2HS $PINS O=n4270 I1=n4264 I2=n3369
XU2998 AOI13HS $PINS O=n5730 A1=FE_OCPN9762_FE_OFN9133_weight_1_r_3
+ B1=FE_OFN1343_weight_1_r_5 B2=n5728 B3=n5729
XU2999 ND3P $PINS O=n3771 I1=n3090 I2=n3463 I3=n9794
XU3000 XOR2HS $PINS O=n2005 I1=n6025 I2=n6024
XU3002 XNR2H $PINS O=n2483 I1=n2488 I2=n5474
XU3003 NR2P $PINS O=n2098 I1=n2643 I2=n9540
XU3004 INV1S $PINS O=n5987 I=n5986
XU3005 XOR2HS $PINS O=n7201 I1=n7206 I2=n2186
XU3006 INV1S $PINS O=n5999 I=n5998
XU3007 XNR2HS $PINS O=n6023 I1=n2133 I2=n1853
XU3008 XNR2HS $PINS O=n1853 I1=n6004 I2=n2688
XU3009 OR2 $PINS O=n3663 I1=n6812 I2=n9066
XU3010 NR2T $PINS O=n6812 I1=n4354 I2=n4355
XU3011 XOR2HS $PINS O=n2023 I1=n6740 I2=n6738
XU3012 XNR2HS $PINS O=n6738 I1=n3838 I2=n3684
XU3013 OR2P $PINS O=n7276 I1=n9152 I2=n9155
XU3014 NR2 $PINS O=n9155 I1=n5880 I2=n5879
XU3015 MOAI1 $PINS O=n4092 A1=FE_OFN1673_n4077 A2=n3896 B1=FE_OFN1452_n2589
+ B2=n3895
XU3016 XNR2HS $PINS O=n2589 I1=n1854 I2=FE_OFN1332_weight_1_r_9
XU3017 INV1S $PINS O=n1854 I=weight_1_r[10]
XU3018 XNR2HS $PINS O=n5782 I1=data_1_r[7] I2=FE_OFN1348_weight_1_r_3
XU3019 OA12 $PINS O=n9810 A1=n9812 B1=n9817 B2=n9811
XU3020 NR2 $PINS O=n3275 I1=n5785 I2=n5784
XU3021 AOI22S $PINS O=n5900 A1=FE_OFN1265_weight_0_r_16 A2=n5892
+ B1=FE_OFN1697_n5491 B2=n5500
XU3030 OAI12HS $PINS O=n2685 A1=n2133 B1=n6004 B2=n2688
XU3034 ND3 $PINS O=n9085 I1=n3478 I2=FE_OCPN9766_n6788 I3=n9083
XU3036 INV1S $PINS O=n2689 I=n6008
XU3037 INV1S $PINS O=n2741 I=n4060
XU3038 OAI22S $PINS O=n5845 A1=n5694 A2=FE_OFN1613_n5691 B1=n5693
+ B2=FE_DBTN10_n9120
XU3039 ND3P $PINS O=n6386 I1=n2234 I2=n6385 I3=n1855
XU3040 ND2P $PINS O=n1855 I1=n6373 I2=n9364
XU3041 NR2P $PINS O=n6869 I1=n6376 I2=n6377
XU3042 ND2 $PINS O=n6876 I1=n6872 I2=n9364
XU3045 AO22 $PINS O=n5905 A1=n2848 A2=n9707 B1=FE_OFN1683_n5496 B2=n5894
XU3046 NR2 $PINS O=n3382 I1=n2706 I2=n5794
XU3047 NR2 $PINS O=n3345 I1=n3532 I2=n9080
XU3048 ND2P $PINS O=n3532 I1=n4269 I2=n4270
XU3052 OAI12HS $PINS O=n9475 A1=n2392 B1=FE_OFN1579_FE_DBTN8_n9443 B2=n2393
XU3053 XNR2HS $PINS O=n3415 I1=n9475 I2=n3419
XU3054 MOAI1 $PINS O=n4238 A1=FE_OFN1588_n2932 A2=n4233 B1=n4243
+ B2=FE_OFN1471_n4329
XU3055 ND3 $PINS O=n6772 I1=n2024 I2=n2025 I3=n2026
XU3057 INV2 $PINS O=n6191 I=FE_OFN1313_weight_1_r_17
XU3058 XNR2HS $PINS O=n2566 I1=n4599 I2=n2567
XU3059 ND2 $PINS O=n1858 I1=FE_OFN1433_FE_DBTN19_n4371 I2=n4459
XU3062 MAO222 $PINS O=n6829 A1=n4142 B1=n4143 C1=n3400
XU3063 ND3HT $PINS O=n6785 I1=n2661 I2=n1861 I3=n6779
XU3065 OAI112HS $PINS O=n3177 A1=n2466 B1=n2465 C1=n1875 C2=n2675
XU3067 MOAI1 $PINS O=n6195 A1=n6172 A2=FE_OFN1680_n3135
+ B1=FE_OFN1312_weight_1_r_19 B2=FE_DBTN48_n1875
XU3068 ND2 $PINS O=n2465 I1=FE_OFN1448_n2033 I2=n6210
XU3069 INV2 $PINS O=n5857 I=n5856
XU3070 MAO222 $PINS O=n6635 A1=n2899 B1=n3412 C1=n3217
XU3071 INV1S $PINS O=n3440 I=weight_2_r[14]
XU3073 NR2P $PINS O=n6325 I1=n6332 I2=n6182
XU3074 OA12P $PINS O=n3811 A1=n7274 B1=n7273 B2=n9146
XU3075 INV3 $PINS O=n5886 I=n2118
XU3076 INV2 $PINS O=n3202 I=n9758
XU3077 ND3HT $PINS O=n9758 I1=n3625 I2=n3624 I3=n3623
XU3078 INV2 $PINS O=n9711 I=FE_OFN1254_weight_0_r_21
XU3079 MAO222 $PINS O=n6971 A1=n6967 B1=n6968 C1=n6969
XU3080 MOAI1S $PINS O=n6969 A1=n6953 A2=FE_OFN1566_FE_DBTN36_n9707
+ B1=FE_OFN1684_n5496 B2=n2055
XU3085 ND2 $PINS O=n3401 I1=FE_OFN1654_n3599 I2=n4134
XU3086 INV2 $PINS O=n6904 I=n9739
XU3087 XNR2HS $PINS O=n5602 I1=n5594 I2=n5593
XU3089 NR2P $PINS O=n9165 I1=n6389 I2=n6391
XU3091 XOR2HS $PINS O=n5907 I1=FE_OFN1261_weight_0_r_17 I2=data_0_r[39]
XU3093 NR2 $PINS O=n2189 I1=n4214 I2=n4195
XU3095 XNR2HS $PINS O=n2723 I1=n7062 I2=n2724
XU3097 XNR2HS $PINS O=n2384 I1=n3552 I2=n1862
XU3098 XNR2HS $PINS O=n1862 I1=n9725 I2=n9724
XU3099 AOI22S $PINS O=n6212 A1=n6215 A2=weight_1_r[16]
+ B1=FE_OFN1441_FE_DBTN9_n3607 B2=n5468
XU3100 ND3 $PINS O=n9622 I1=n9621 I2=n9619 I3=n9620
XU3102 NR2P $PINS O=n9733 I1=n9754 I2=n9741
XU3103 MAO222 $PINS O=n4611 A1=n2567 B1=n4599 C1=n4598
XU3105 XOR2HS $PINS O=n2090 I1=n5906 I2=n5905
XU3106 OAI12HS $PINS O=n2086 A1=n6983 B1=n2089 B2=n6984
XU3107 MAO222 $PINS O=n2089 A1=n3169 B1=n6503 C1=n6504
XU3108 NR2T $PINS O=n6987 I1=n9778 I2=n6985
XU3109 XOR2HS $PINS O=n3994 I1=n4026 I2=n1863
XU3110 XOR2HS $PINS O=n1863 I1=n2740 I2=n4027
XU3113 INV2 $PINS O=n4076 I=FE_OFN1451_n2589
XU3114 ND2 $PINS O=n4416 I1=FE_OFN9138_n I2=data_2_r[18]
XU3115 ND2 $PINS O=n6209 I1=n2581 I2=n6208
XU3116 XOR2HS $PINS O=n4594 I1=data_2_r[23] I2=FE_OFN9137_n
XU3117 MOAI1H $PINS O=n6452 A1=FE_OFN1623_n6448 A2=n5909 B1=n9697 B2=n6459
XU3118 INV2 $PINS O=n4463 I=n4462
XU3119 OA12P $PINS O=n3885 A1=n7250 B1=n8934 B2=n7249
XU3120 MOAI1H $PINS O=n2156 A1=n2157 A2=n2842 B1=n3302 B2=n6965
XU3121 INV1S $PINS O=n3111 I=n4300
XU3122 OAI12HP $PINS O=n3352 A1=n6514 B1=n6515 B2=n7270
XU3124 ND3HT $PINS O=n3625 I1=n6986 I2=n3572 I3=n6987
XU3125 NR2T $PINS O=n3572 I1=n6515 I2=n6513
XU3126 ND3HT $PINS O=n6986 I1=n6489 I2=n6488 I3=n9788
XU3128 OAI12HP $PINS O=n1873 A1=n3233 B1=n3234 B2=FE_OFN1516_n5494
XU3129 MOAI1H $PINS O=n6494 A1=n1864 A2=n3349 B1=n6481 B2=n6482
XU3130 NR2 $PINS O=n1864 I1=n6481 I2=n6482
XU3132 XNR2H $PINS O=n6511 I1=n6983 I2=n1866
XU3133 XNR2H $PINS O=n1866 I1=n2087 I2=n2088
XU3134 XNR2HS $PINS O=n5902 I1=n2090 I2=n2091
XU3135 XOR2HS $PINS O=n2091 I1=n5910 I2=n2533
XU3136 MOAI1S $PINS O=n5898 A1=n5897 A2=FE_OCPN9764_weight_0_r_19 B1=n5896
+ B2=FE_OCPN9764_weight_0_r_19
XU3141 NR2P $PINS O=n1874 I1=n3738 I2=n3739
XU3142 XNR2HS $PINS O=n6338 I1=weight_1_r[17] I2=weight_1_r[18]
XU3159 MOAI1S $PINS O=n2578 A1=n4468 A2=FE_DBTN7_n4532 B1=n4467
+ B2=FE_OCPN9759_FE_DBTN19_n4371
XU3160 NR2 $PINS O=n2650 I1=n4402 I2=n4401
XU3161 XNR2HS $PINS O=n6636 I1=n6617 I2=n6616
XU3162 AOI22H $PINS O=n6612 A1=n6603 A2=FE_OFN1282_weight_0_r_8 B1=n5564
+ B2=n6584
XU3163 ND2P $PINS O=n3762 I1=n9095 I2=n9093
XU3164 NR2P $PINS O=n3761 I1=n4178 I2=n4177
XU3165 ND2 $PINS O=n9669 I1=n5549 I2=n5550
XU3167 XOR2HS $PINS O=n4000 I1=FE_OFN1336_weight_1_r_9 I2=data_1_r[27]
XU3168 NR2P $PINS O=n7282 I1=n2549 I2=n4117
XU3169 NR2 $PINS O=n4087 I1=n4069 I2=n4067
XU3171 XOR2HS $PINS O=pConv_0/product_2_w[15] I1=n1900 I2=n9768
XU3172 XOR2HS $PINS O=n2563 I1=n5635 I2=n3853
XU3173 OAI22S $PINS O=n5635 A1=n5609 A2=FE_OFN1668_n5855
+ B1=FE_OFN1562_FE_DBTN37_n5853 B2=n5617
XU3174 XOR2HS $PINS O=n5975 I1=n5971 I2=n1901
XU3175 XOR2HS $PINS O=n1901 I1=n5973 I2=n5972
XU3176 XOR2H $PINS O=pConv_0/product_1_w[21] I1=n1902 I2=n2171
XU3177 XNR2HS $PINS O=n2855 I1=n7086 I2=n2329
XU3178 XNR2HS $PINS O=n3534 I1=n6591 I2=n3448
XU3180 OAI12HS $PINS O=n6767 A1=n2323 B1=n2325 B2=n2324
XU3181 FA1 $PINS S=n5568 CO=n5550 A=n5553 B=n5552 CI=n5551
XU3182 NR2 $PINS O=n3720 I1=n3721 I2=n9477
XU3183 OA12 $PINS O=n5524 A1=n5508 B1=n1873 B2=n5509
XU3184 OAI12HS $PINS O=n2734 A1=n6296 B1=n2737 B2=n6297
XU3186 OAI12HS $PINS O=n3141 A1=n6347 B1=n6348 B2=n6349
XU3187 NR2 $PINS O=n5488 I1=n5481 I2=n2057
XU3188 NR2 $PINS O=n9420 I1=n9417 I2=n9418
XU3189 AOI12HS $PINS O=n9574 A1=n9577 B1=n9575 B2=n9579
XU3190 OAI22S $PINS O=n6925 A1=n2012 A2=FE_OFN1685_n5496 B1=n6914
+ B2=FE_OFN1565_FE_DBTN36_n9707
XU3193 OAI12H $PINS O=n7095 A1=n2716 B1=n2717 B2=n3209
XU3194 INV1S $PINS O=n2717 I=n3210
XU3195 NR2 $PINS O=n9423 I1=n9422 I2=n2443
XU3196 MOAI1H $PINS O=n3274 A1=n3903 A2=FE_OFN1638_n9221 B1=n3902
+ B2=FE_OFN1557_FE_DBTN42_n3886
XU3197 XNR2HS $PINS O=n6735 I1=FE_OFN9128_weight_0_r_3 I2=data_0_r[7]
XU3198 MOAI1H $PINS O=n4227 A1=FE_RN_15_0 A2=n3185 B1=n3769 B2=n4216
XU3199 NR2P $PINS O=n2118 I1=n3057 I2=n7273
XU3201 OAI12HS $PINS O=n2549 A1=n2608 B1=n3309 B2=n3310
XU3202 INV1S $PINS O=n2618 I=n4613
XU3203 INV1S $PINS O=n4626 I=n4625
XU3205 OAI22S $PINS O=n5982 A1=n5968 A2=FE_OFN1128_FE_DBTN39_n3378 B1=n6103
+ B2=n5985
XU3208 XNR2HS $PINS O=n1909 I1=n9228 I2=n9227
XU3211 XOR2HS $PINS O=n1911 I1=n3750 I2=n4263
XU3212 ND3 $PINS O=n4573 I1=n2838 I2=n2839 I3=n2840
XU3213 ND2 $PINS O=n2839 I1=FE_OCPN9773_n4570 I2=n4569
XU3214 XNR2HS $PINS O=n2172 I1=n4574 I2=n4573
XU3215 XOR2HS $PINS O=n4540 I1=FE_OFN1387_weight_2_r_13 I2=data_2_r[21]
XU3216 INV1S $PINS O=n4542 I=n4540
XU3218 ND2P $PINS O=n3304 I1=n9565 I2=n9563
XU3219 OAI12HP $PINS O=n9565 A1=n9570 B1=n9574 B2=n9572
XU3220 XNR2HS $PINS O=n2195 I1=n4302 I2=n2196
XU3221 AOI22S $PINS O=n4283 A1=n4273 A2=FE_OFN1378_weight_2_r_16 B1=n4152
+ B2=n4254
XU3223 INV1S $PINS O=n3703 I=n5669
XU3224 XOR2HS $PINS O=n2186 I1=n7207 I2=n2187
XU3225 XOR3 $PINS O=n5676 I1=n5674 I2=n5673 I3=n5672
XU3226 NR2 $PINS O=n5910 I1=n2232 I2=n5900
XU3227 XOR2HS $PINS O=n4305 I1=data_2_r[47] I2=FE_OFN1695_weight_2_r_17
XU3228 XOR2HS $PINS O=n4248 I1=FE_OFN1695_weight_2_r_17 I2=data_2_r[43]
XU3229 XOR2HS $PINS O=n4229 I1=FE_OFN1376_weight_2_r_17 I2=data_2_r[41]
XU3230 XOR2HS $PINS O=n4189 I1=n3475 I2=data_2_r[38]
XU3231 XNR2HS $PINS O=n4262 I1=n4251 I2=n3131
XU3234 OAI22S $PINS O=n4398 A1=n3442 A2=FE_OFN1606_n4596 B1=n4388
+ B2=FE_OFN1644_FE_DBTN11_n3387
XU3235 ND3 $PINS O=n3372 I1=n4184 I2=FE_OFN1372_weight_2_r_19 I3=n4183
XU3236 NR2 $PINS O=n2619 I1=n4231 I2=n2620
XU3239 ND2P $PINS O=n2722 I1=n3987 I2=n3988
XU3240 XNR2HS $PINS O=n3987 I1=n3982 I2=n2302
XU3242 ND3 $PINS O=n9632 I1=n9631 I2=n9630 I3=n9629
XU3244 ND2 $PINS O=n8844 I1=n6054 I2=n6053
XU3245 MOAI1H $PINS O=n5711 A1=FE_OFN1668_n5855 A2=n5617 B1=n5853 B2=n5616
XU3246 XNR2HS $PINS O=n3991 I1=n3945 I2=n3688
XU3247 ND2 $PINS O=n3689 I1=n3945 I2=n3690
XU3248 XNR2HS $PINS O=n3945 I1=n3937 I2=n2327
XU3249 NR2 $PINS O=n3212 I1=n6712 I2=n3423
XU3250 XNR2HS $PINS O=n4661 I1=FE_DBTN46_n4426 I2=n1916
XU3251 XOR2HS $PINS O=n1916 I1=n4428 I2=n4427
XU3253 XOR2HS $PINS O=n2332 I1=n5793 I2=n5792
XU3254 XNR2HS $PINS O=n5793 I1=n5783 I2=n5785
XU3260 XOR2HS $PINS O=n1974 I1=n5521 I2=n5523
XU3261 MOAI1 $PINS O=n4419 A1=n4396 A2=FE_OFN1444_FE_DBTN7_n4532
+ B1=FE_OFN1434_FE_DBTN19_n4371 B2=n4403
XU3263 OR2 $PINS O=n2110 I1=FE_OFN1539_n6937 I2=n6451
XU3264 XNR2HS $PINS O=n2270 I1=n4168 I2=n2139
XU3265 OAI12HS $PINS O=n3273 A1=n9238 B1=n9239 B2=n3274
XU3267 OR2 $PINS O=n1919 I1=n2526 I2=n2524
XU3268 INV1S $PINS O=n3261 I=n4638
XU3269 OAI12H $PINS O=n6512 A1=n2146 B1=n2148 B2=n2147
XU3270 OAI22S $PINS O=n6503 A1=n6470 A2=FE_OFN1586_n1873 B1=FE_OFN1539_n6937
+ B2=n6506
XU3271 NR2P $PINS O=n6443 I1=n6080 I2=n3520
XU3272 MOAI1 $PINS O=n6080 A1=n2653 A2=n2652 B1=n6083 B2=n2654
XU3273 ND2T $PINS O=n8925 I1=n7127 I2=n6057
XU3275 XOR2HS $PINS O=n4254 I1=FE_OFN1695_weight_2_r_17 I2=data_2_r[44]
XU3276 XNR2HS $PINS O=n3719 I1=n9477 I2=n3721
XU3277 MOAI1 $PINS O=n4340 A1=n4322 A2=FE_OFN1576_FE_DBTN17_n6819
+ B1=FE_OFN1593_n3599 B2=n4321
XU3278 NR2 $PINS O=n1977 I1=n2714 I2=n2713
XU3279 MAO222 $PINS O=n5719 A1=n3562 B1=n5705 C1=n5704
XU3280 ND2 $PINS O=n3248 I1=n2222 I2=n3445
XU3283 NR2T $PINS O=n1923 I1=n7276 I2=n5886
XU3284 NR2T $PINS O=n9142 I1=n7276 I2=n5886
XU3285 MOAI1H $PINS O=n6207 A1=n5466 A2=FE_OFN1567_FE_DBTN31_n6225
+ B1=FE_DBTN40_n3656 B2=n5465
XU3286 MOAI1H $PINS O=n6206 A1=n5467 A2=FE_OFN1567_FE_DBTN31_n6225
+ B1=FE_DBTN40_n3656 B2=weight_1_r[21]
XU3287 INV2 $PINS O=n3271 I=n3274
XU3288 XNR2H $PINS O=n7100 I1=n3323 I2=n3322
XU3290 XOR2HS $PINS O=n2141 I1=FE_OFN1264_weight_0_r_17 I2=data_0_r[44]
XU3291 ND2 $PINS O=n9791 I1=n5919 I2=n2072
XU3292 NR2 $PINS O=n3821 I1=n3824 I2=n3925
XU3293 INV1S $PINS O=n3045 I=n5861
XU3294 INV1S $PINS O=n9292 I=n9295
XU3295 INV1S $PINS O=n4004 I=n4005
XU3297 XNR2HS $PINS O=n2181 I1=n4301 I2=n4300
XU3299 ND2 $PINS O=n5896 I1=n3234 I2=n6893
XU3300 NR2P $PINS O=n9320 I1=n3933 I2=n3932
XU3301 AOI13HS $PINS O=n4533 A1=FE_OFN9142_n B1=n4531 B2=n4530
+ B3=FE_OCPN9716_weight_2_r_13
XU3304 ND3 $PINS O=n9658 I1=n3222 I2=FE_OCPN9756_n6842 I3=n9656
XU3305 XNR2HS $PINS O=n3276 I1=n4343 I2=n3280
XU3306 MOAI1H $PINS O=n3909 A1=FE_OFN1639_n9221 A2=n3890
+ B1=FE_OFN1557_FE_DBTN42_n3886 B2=n3889
XU3307 INV1S $PINS O=n3225 I=n4256
XU3308 ND2 $PINS O=n8922 I1=n4655 I2=n4654
XU3309 OAI22S $PINS O=n5521 A1=n5493 A2=n1873 B1=n5502 B2=n6937
XU3311 AOI22S $PINS O=n3981 A1=n3921 A2=FE_OFN1337_weight_1_r_8
+ B1=FE_OFN1460_n3961 B2=n3947
XU3312 XNR2HS $PINS O=n2648 I1=n4402 I2=n4401
XU3313 MOAI1 $PINS O=n4068 A1=FE_OFN1597_n3897 A2=n4066 B1=n4065
+ B2=FE_OFN1459_n3428
XU3314 MOAI1H $PINS O=n4079 A1=FE_OFN1596_n3897 A2=n4002 B1=FE_OFN1459_n3428
+ B2=n4054
XU3315 OAI22H $PINS O=n4005 A1=n4003 A2=FE_OFN1596_n3897
+ B1=FE_OFN1572_FE_DBTN21_n3428 B2=n4002
XU3316 MAO222 $PINS O=n4348 A1=n4340 B1=n4341 C1=FE_OFN1694_weight_2_r_17
XU3317 XNR2HS $PINS O=n4339 I1=n3474 I2=n4340
XU3318 NR2 $PINS O=n4370 I1=weight_2_r[12] I2=FE_OFN1472_n4404
XU3319 XNR2HS $PINS O=n4038 I1=n4035 I2=n2610
XU3320 XNR2HS $PINS O=n2610 I1=n4036 I2=n2613
XU3321 XOR2HS $PINS O=n4036 I1=n2645 I2=n4017
XU3322 XOR2HS $PINS O=n2423 I1=n4025 I2=n2558
XU3324 NR2P $PINS O=n9108 I1=n3764 I2=n4160
XU3325 INV2 $PINS O=n3764 I=n4159
XU3326 XNR2HS $PINS O=n4160 I1=n3765 I2=n4161
XU3327 OAI22S $PINS O=n3938 A1=n3931 A2=FE_OFN1671_n4077 B1=n3942
+ B2=FE_OFN1598_n4076
XU3328 INV1S $PINS O=n3956 I=n3973
XU3329 XNR2HS $PINS O=n4458 I1=FE_OFN1387_weight_2_r_13 I2=data_2_r[24]
XU3331 MAO222 $PINS O=n4226 A1=n4222 B1=n2442 C1=n4223
XU3332 XOR2HS $PINS O=n2468 I1=n4048 I2=n4049
XU3333 NR2 $PINS O=n2473 I1=n4048 I2=n4049
XU3334 AOI22H $PINS O=n4069 A1=n4064 A2=FE_OFN1338_weight_1_r_8
+ B1=FE_OFN1461_n3961 B2=n4061
XU3335 AOI12HS $PINS O=n4317 A1=n3364 B1=n2750 B2=n3365
XU3336 AN2 $PINS O=n7287 I1=n2748 I2=n9282
XU3337 FA1 $PINS S=n1927 A=n4095 B=n4094 CI=n4093
XU3338 XNR2HS $PINS O=n4095 I1=n4079 I2=n4081
XU3339 XNR2HS $PINS O=n4347 I1=n3276 I2=n4342
XU3340 INV1S $PINS O=n3338 I=n4551
XU3341 XOR2HS $PINS O=n4061 I1=FE_OFN1336_weight_1_r_9 I2=data_1_r[30]
XU3343 ND2 $PINS O=n9253 I1=n4114 I2=n2815
XU3346 INV1S $PINS O=n3063 I=FE_OFN1353_weight_1_r_1
XU3347 OAI12HS $PINS O=n2299 A1=n5868 B1=n5869 B2=n5870
XU3348 OAI12HP $PINS O=n3752 A1=n3753 B1=n3755 B2=n3754
XU3349 MOAI1H $PINS O=n4042 A1=n2422 A2=n2555 B1=n2558 B2=n4025
XU3350 NR2 $PINS O=n2422 I1=n4025 I2=n2558
XU3351 ND2P $PINS O=n4045 I1=n3702 I2=n4039
XU3352 FA1 $PINS S=n4043 CO=n4118 A=n4095 B=n4094 CI=n4093
XU3353 INV1S $PINS O=n3971 I=n3968
XU3354 NR2 $PINS O=n4185 I1=n4183 I2=n4182
XU3355 FA1 $PINS S=n4427 CO=n4400 A=n4394 B=n4393 CI=n4392
XU3356 XNR2H $PINS O=n3270 I1=n3271 I2=n9239
XU3358 ND3 $PINS O=n4124 I1=FE_OFN1157_n4047 I2=n9274 I3=n7123
XU3359 ND3 $PINS O=n9277 I1=FE_OFN1157_n4047 I2=n9274 I3=n2467
XU3360 ND3P $PINS O=n9268 I1=FE_OFN1157_n4047 I2=n9266 I3=n9274
XU3361 ND3P $PINS O=n9260 I1=FE_OFN1157_n4047 I2=n9257 I3=n9274
XU3362 XOR2HS $PINS O=n3322 I1=n7090 I2=n7089
XU3363 NR2 $PINS O=n7083 I1=n2418 I2=n7060
XU3364 ND2 $PINS O=n4211 I1=n4206 I2=n4208
XU3365 ND2 $PINS O=n3916 I1=FE_OFN1332_weight_1_r_9 I2=weight_1_r[10]
XU3366 MOAI1 $PINS O=n4098 A1=n3999 A2=FE_OFN1672_n4077 B1=n4074
+ B2=FE_OFN1452_n2589
XU3367 MOAI1 $PINS O=n3721 A1=FE_OFN1648_n9466 A2=n7173 B1=FE_OFN1545_n7188
+ B2=FE_OFN1295_weight_0_r_3
XU3368 XNR2HS $PINS O=pConv_2/product_2_w[19] I1=n1928 I2=n4363
XU3369 OR2 $PINS O=n1928 I1=n9058 I2=n6836
XU3370 INV1S $PINS O=n4602 I=n4601
XU3372 XNR2HS $PINS O=n4179 I1=n4186 I2=n3445
XU3375 ND2 $PINS O=n3827 I1=FE_OFN1434_FE_DBTN19_n4371 I2=n4405
XU3376 MOAI1 $PINS O=n4638 A1=FE_OFN1444_FE_DBTN7_n4532 A2=n4407
+ B1=FE_OFN1434_FE_DBTN19_n4371 B2=n4617
XU3390 INV2 $PINS O=n5680 I=FE_OFN1344_weight_1_r_5
XU3410 INV2 $PINS O=n4404 I=weight_2_r[13]
XU3411 XNR2HS $PINS O=n4386 I1=data_2_r[31] I2=FE_OFN1473_n4404
XU3412 XNR2HS $PINS O=n4434 I1=data_2_r[23] I2=FE_OCPN9761_n4404
XU3413 XNR2HS $PINS O=n4473 I1=data_2_r[18] I2=FE_OFN1472_n4404
XU3414 XOR2HS $PINS O=n4442 I1=data_2_r[22] I2=FE_OCPN9761_n4404
XU3415 OR2 $PINS O=n1961 I1=n2195 I2=n3581
XU3418 AOI22S $PINS O=n5970 A1=n3586 A2=FE_OFN1412_weight_2_r_0 B1=n5951
+ B2=n3285
XU3419 NR2 $PINS O=n3587 I1=n5970 I2=n3385
XU3420 ND2 $PINS O=n1965 I1=FE_DBTN38_n6714 I2=n9443
XU3421 ND2S $PINS O=n6734 I1=n1965 I2=n2209
XU3424 ND2 $PINS O=n2209 I1=FE_OFN1575_FE_DBTN20_n2908 I2=n6713
XU3426 XOR2HS $PINS O=n2811 I1=n4514 I2=n4512
XU3427 AOI12HS $PINS O=n6796 A1=n6794 B1=FE_OCPN9766_n6788 B2=n6795
XU3428 ND3 $PINS O=n6816 I1=n2975 I2=n9069 I3=n9067
XU3429 AOI12HS $PINS O=n9074 A1=n2068 B1=n2975 B2=FE_DBTN4_n9073
XU3430 AN2 $PINS O=n1967 I1=n9765 I2=n9764
XU3431 OAI12H $PINS O=n9163 A1=n6387 B1=n6389 B2=n7279
XU3432 ND2 $PINS O=n6168 I1=n6162 I2=FE_OFN1312_weight_1_r_19
XU3433 ND2 $PINS O=n6162 I1=FE_OFN1680_n3135 I2=FE_OFN1447_n1875
XU3434 MAO222 $PINS O=n7091 A1=n2536 B1=n7056 C1=n7055
XU3435 ND2P $PINS O=n4585 I1=n8953 I2=n4584
XU3436 ND2 $PINS O=n3795 I1=n8928 I2=n3796
XU3437 XNR2HS $PINS O=n6572 I1=n2305 I2=n2307
XU3438 AN2 $PINS O=n1969 I1=FE_OFN1360_data_1_r_1 I2=FE_OFN1344_weight_1_r_5
XU3439 INV1S $PINS O=n9164 I=n6395
XU3440 ND2 $PINS O=n3650 I1=FE_DBTN27_n6338 I2=n6266
XU3441 ND2 $PINS O=n2749 I1=n2639 I2=n2033
XU3442 XOR2HS $PINS O=n1970 I1=n3985 I2=n3986
XU3443 ND2 $PINS O=n1971 I1=n3985 I2=n3984
XU3444 ND2 $PINS O=n1972 I1=n3984 I2=n3986
XU3445 ND2 $PINS O=n1973 I1=n3985 I2=n3986
XU3446 ND3 $PINS O=n3992 I1=n1971 I2=n1972 I3=n1973
XU3447 MOAI1S $PINS O=n3986 A1=n9349 A2=n3913 B1=FE_OCPN9723_n3961 B2=n3921
XU3448 XOR2H $PINS O=n3984 I1=n3924 I2=n1994
XU3449 INV2 $PINS O=n8927 I=n8925
XU3450 NR2P $PINS O=n3796 I1=n8924 I2=n8925
XU3452 NR2 $PINS O=n2354 I1=n2355 I2=n6756
XU3453 AOI13HS $PINS O=n6226 A1=FE_OFN1311_weight_1_r_19 B1=n2343 B2=n6224
+ B3=FE_OFN1309_weight_1_r_21
XU3454 XNR2HS $PINS O=n5764 I1=data_1_r[5] I2=weight_1_r[7]
XU3455 XOR2HS $PINS O=n2622 I1=data_1_r[5] I2=FE_OFN9135_weight_1_r_3
XU3456 XOR2HS $PINS O=n5779 I1=FE_OFN1344_weight_1_r_5 I2=data_1_r[5]
XU3458 XOR2HS $PINS O=n5528 I1=n5522 I2=n1974
XU3459 XNR2HS $PINS O=pConv_0/product_1_w[16] I1=n9638 I2=n9637
XU3460 OAI12H $PINS O=n3849 A1=FE_DBTN34_weight_0_r_11
+ B1=FE_DBTN33_weight_0_r_13 B2=weight_0_r[12]
XU3461 NR2 $PINS O=n5599 I1=FE_OFN1246_n8888 I2=n6103
XU3462 OAI12HS $PINS O=n3181 A1=n4588 B1=n4589 B2=n2582
XU3463 XNR2HS $PINS O=n4466 I1=n4588 I2=n3179
XU3464 INV1S $PINS O=n3461 I=n4452
XU3465 XNR2HS $PINS O=n4575 I1=n4449 I2=n2312
XU3466 XOR2HS $PINS O=n4562 I1=FE_OCPN9773_n4570 I2=n2837
XU3467 ND3 $PINS O=n9301 I1=n7290 I2=n9306 I3=n9305
XU3468 XOR2HS $PINS O=n5803 I1=n5757 I2=n5778
XU3470 XOR2HS $PINS O=n5919 I1=n6483 I2=n3516
XU3471 XNR2HS $PINS O=n2309 I1=n6239 I2=n6238
XU3472 NR2P $PINS O=n2857 I1=n4116 I2=n2550
XU3473 XNR2HS $PINS O=n6105 I1=FE_OFN1405_weight_2_r_3 I2=data_2_r[12]
XU3474 XOR2HS $PINS O=n3543 I1=n6245 I2=n1976
XU3475 XOR2HS $PINS O=n1976 I1=n6246 I2=n2434
XU3476 INV1S $PINS O=n7170 I=n7171
XU3477 NR2P $PINS O=n8955 I1=n6522 I2=n6520
XU3478 NR2P $PINS O=n3782 I1=n4549 I2=n4448
XU3480 XNR2HS $PINS O=n4026 I1=n3760 I2=n3759
XU3481 ND2 $PINS O=n3158 I1=n2230 I2=n5941
XU3482 INV1S $PINS O=n6182 I=n6331
XU3483 MAO222 $PINS O=n6126 A1=n2711 B1=n6121 C1=n6120
XU3484 FA1 $PINS S=n3973 CO=n3988 A=n3976 B=n3975 CI=n3974
XU3485 INV1S $PINS O=n3950 I=n3952
XU3486 ND3P $PINS O=n2345 I1=n2031 I2=n9642 I3=n3032
XU3487 XNR2HS $PINS O=pConv_1/product_2_w[21] I1=n2592 I2=n6386
XU3488 OAI12HS $PINS O=n2434 A1=n2430 B1=n2435 B2=n2432
XU3489 XOR2HS $PINS O=n6672 I1=FE_OFN1295_weight_0_r_3 I2=data_0_r[10]
XU3490 ND2 $PINS O=n9251 I1=n3911 I2=n3910
XU3492 XOR2HS $PINS O=n6247 I1=n2205 I2=n6248
XU3493 ND2 $PINS O=n2164 I1=n6117 I2=n2166
XU3494 INV1S $PINS O=n3548 I=n3408
XU3495 OAI22S $PINS O=n6733 A1=n6715 A2=n9466 B1=FE_OFN1641_n9465 B2=n6735
XU3496 XNR2HS $PINS O=n6715 I1=FE_OFN9128_weight_0_r_3 I2=data_0_r[6]
XU3498 NR2 $PINS O=n6732 I1=n6717 I2=n6718
XU3499 AN3 $PINS O=n1981 I1=n3602 I2=n3603 I3=n3604
XU3501 NR2 $PINS O=n5574 I1=weight_2_r[4] I2=n6412
XU3502 INV1S $PINS O=n3570 I=n3722
XU3503 MOAI1 $PINS O=n6963 A1=FE_OFN1685_n5496 A2=n6953 B1=n6934 B2=n9707
XU3504 XNR2HS $PINS O=n2820 I1=n4556 I2=n2636
XU3505 XOR2HS $PINS O=n5892 I1=FE_OFN1261_weight_0_r_17 I2=data_0_r[38]
XU3506 AOI12H $PINS O=n9191 A1=n9194 B1=n9196 B2=n9192
XU3507 OAI22S $PINS O=n5796 A1=n5746 A2=FE_OFN1668_n5855
+ B1=FE_OFN1562_FE_DBTN37_n5853 B2=n5782
XU3508 NR2 $PINS O=n2258 I1=n6363 I2=n6362
XU3509 XOR2HS $PINS O=n1983 I1=data_2_r[31] I2=FE_OFN1473_n4404
XU3510 ND2 $PINS O=n2280 I1=FE_OCPN9760_n6309 I2=n9386
XU3511 ND2 $PINS O=n2757 I1=n2280 I2=n9385
XU3512 ND3P $PINS O=n2311 I1=n9367 I2=n9366 I3=n9365
XU3513 ND2 $PINS O=n3522 I1=n6467 I2=FE_OFN1684_n5496
XU3514 XNR2H $PINS O=n6367 I1=n6328 I2=n2235
XU3515 NR2 $PINS O=n8876 I1=n5604 I2=n5603
XU3516 XNR2HS $PINS O=n4579 I1=n4451 I2=n2658
XU3518 OA12 $PINS O=n5487 A1=n5480 B1=n2033 B2=FE_OFN1679_n3135
XU3519 ND2 $PINS O=n4210 I1=n4206 I2=n4207
XU3520 OAI12HS $PINS O=n2113 A1=n6433 B1=n6434 B2=n6435
XU3521 OAI12HS $PINS O=n6298 A1=n2206 B1=n2208 B2=n2207
XU3522 XNR2HS $PINS O=n6250 I1=n6260 I2=n6258
XU3523 XOR3 $PINS O=n1986 I1=n7224 I2=n3044 I3=n7223
XU3524 XNR2HS $PINS O=pConv_0/product_0_w[18] I1=n1987 I2=n2169
XU3525 INV1S $PINS O=n5603 I=n5602
XU3527 INV1S $PINS O=n2373 I=n6727
XU3529 OR2 $PINS O=n1989 I1=n9140 I2=n9139
XU3531 XOR2HS $PINS O=n6723 I1=n6719 I2=n1990
XU3532 XOR2HS $PINS O=n1990 I1=n6721 I2=n6720
XU3533 AO22 $PINS O=n4290 A1=n6819 A2=n4291 B1=FE_OFN1593_n3599 B2=n4278
XU3535 INV1S $PINS O=n3115 I=n6980
XU3536 NR2P $PINS O=n3792 I1=n3793 I2=n8925
XU3538 XNR2HS $PINS O=n9459 I1=FE_OFN1285_weight_0_r_7 I2=data_0_r[12]
XU3540 XNR2H $PINS O=n2733 I1=n3317 I2=n3645
XU3541 XNR2HS $PINS O=n6548 I1=FE_OFN1273_weight_0_r_13 I2=data_0_r[25]
XU3542 XOR2HS $PINS O=n6618 I1=FE_OFN1271_weight_0_r_13 I2=data_0_r[23]
XU3543 FA1 $PINS S=n9248 CO=n9250 A=n9245 B=n9243 CI=n9244
XU3545 XOR2HS $PINS O=n6018 I1=FE_OFN1405_weight_2_r_3 I2=data_2_r[10]
XU3546 XOR2HS $PINS O=pConv_2/product_2_w[20] I1=n1992 I2=n6840
XU3547 AN2 $PINS O=n1992 I1=n6833 I2=n9060
XU3548 XNR2HS $PINS O=n2162 I1=n6969 I2=n6968
XU3549 MOAI1S $PINS O=n6968 A1=FE_OFN1586_n1873 A2=n6957 B1=n6955
+ B2=FE_OFN1569_FE_DBTN25_n6937
XU3551 AN2 $PINS O=n1993 I1=n3912 I2=n9251
XU3552 OR2 $PINS O=n2730 I1=FE_OFN1572_FE_DBTN21_n3428 I2=n3519
XU3553 ND2 $PINS O=n2557 I1=FE_OFN1558_FE_DBTN42_n3886 I2=n4007
XU3555 XOR2HS $PINS O=n4454 I1=data_2_r[28] I2=FE_OFN1660_weight_2_r_9
XU3556 INV1S $PINS O=n4492 I=n4510
XU3557 ND2S $PINS O=n9734 I1=n3526 I2=n3527
XU3558 MOAI1 $PINS O=n4613 A1=FE_OFN1606_n4596 A2=n4595 B1=n4413
+ B2=FE_OFN9140_n3387
XU3559 OAI22S $PINS O=n4625 A1=n4597 A2=FE_OFN1606_n4596 B1=n4595
+ B2=FE_DBTN11_n3387
XU3560 ND2 $PINS O=n8855 I1=n6034 I2=n6033
XU3561 XNR2HS $PINS O=n2163 I1=n6117 I2=n2166
XU3562 OAI12HS $PINS O=n2165 A1=n6116 B1=n6117 B2=n2166
XU3563 INV1S $PINS O=n5571 I=n5584
XU3564 XOR2HS $PINS O=n5584 I1=data_2_r[2] I2=FE_OFN1406_weight_2_r_3
XU3565 ND2 $PINS O=n5585 I1=n6086 I2=n5584
XU3566 MOAI1 $PINS O=n6486 A1=n3517 A2=n3518 B1=n6484 B2=n6485
XU3569 NR2P $PINS O=n9359 I1=n6380 I2=n6381
XU3570 OAI12HS $PINS O=n3646 A1=n3317 B1=n3649 B2=n6264
XU3571 XOR2HS $PINS O=n4412 I1=data_2_r[31] I2=FE_OFN1660_weight_2_r_9
XU3572 XOR2HS $PINS O=n4593 I1=data_2_r[30] I2=FE_OFN1660_weight_2_r_9
XU3573 ND3 $PINS O=n7254 I1=n3093 I2=n3204 I3=n8934
XU3574 INV1S $PINS O=n3391 I=n6028
XU3575 XOR2HS $PINS O=n1994 I1=n3824 I2=n3925
XU3576 XOR2HS $PINS O=n4511 I1=n4513 I2=n2811
XU3577 ND2P $PINS O=n9513 I1=n9522 I2=n9512
XU3578 OAI12H $PINS O=n3253 A1=n6790 B1=n6792 B2=n6793
XU3580 FA1 $PINS S=n4120 CO=n4116 A=n4107 B=n4106 CI=n4105
XU3581 XOR2HS $PINS O=n2396 I1=n3158 I2=n3155
XU3582 XOR2HS $PINS O=n5933 I1=data_2_r[6] I2=FE_OFN1407_weight_2_r_1
XU3583 ND3P $PINS O=n6651 I1=n6650 I2=n6648 I3=n6649
XU3584 INV1S $PINS O=n3784 I=n4376
XU3585 XNR2HS $PINS O=n9482 I1=n9476 I2=n3719
XU3589 FA1 $PINS S=n1999 A=n4555 B=FE_OCPN9752_n4554 CI=n4553
XU3590 NR2 $PINS O=n8964 I1=n3592 I2=n4559
XU3593 XNR2HS $PINS O=n4553 I1=n4526 I2=n3776
XU3594 OAI22S $PINS O=n4615 A1=n4606 A2=FE_OFN1480_n4623 B1=FE_OFN1608_n4622
+ B2=n4624
XU3595 NR2 $PINS O=n4504 I1=FE_OFN1546_n8995 I2=n4622
XU3596 OAI22S $PINS O=n4569 A1=n4544 A2=FE_OFN1479_n4623 B1=FE_OFN1608_n4622
+ B2=n4543
XU3599 XOR2HS $PINS O=n4483 I1=FE_OFN1394_weight_2_r_9 I2=data_2_r[21]
XU3601 OAI22H $PINS O=n6471 A1=n6460 A2=FE_OFN1623_n6448 B1=FE_OFN1553_n9713
+ B2=n6464
XU3602 XOR2H $PINS O=n2830 I1=n4350 I2=n4349
XU3603 OAI12HS $PINS O=n4349 A1=n3277 B1=n3281 B2=n3279
XU3604 OAI22S $PINS O=n5698 A1=FE_OFN1613_n5691 A2=n2495 B1=n5695
+ B2=FE_OFN1578_FE_DBTN10_n9120
XU3605 OAI22H $PINS O=n5783 A1=n5741 A2=n5691 B1=n5775 B2=FE_DBTN10_n9120
XU3606 NR2P $PINS O=n9288 I1=n4121 I2=n4120
XU3607 OR2T $PINS O=n5495 I1=weight_0_r[20] I2=FE_OFN1551_n9711
XU3608 XNR2HS $PINS O=n6766 I1=n2325 I2=n2322
XU3609 XNR2HS $PINS O=n2322 I1=n2324 I2=n6763
XU3610 XNR2H $PINS O=n5883 I1=n5868 I2=n2300
XU3611 ND2P $PINS O=n3541 I1=n3771 I2=n3770
XU3612 XNR2HS $PINS O=n4455 I1=FE_OFN1384_weight_2_r_15 I2=data_2_r[22]
XU3613 XOR2HS $PINS O=n4524 I1=FE_OFN1380_weight_2_r_15 I2=data_2_r[18]
XU3614 AN2 $PINS O=n2004 I1=n9770 I2=n9771
XU3615 OAI22H $PINS O=n6477 A1=n6461 A2=FE_OFN1623_n6448 B1=n6460
+ B2=FE_OFN1553_n9713
XU3616 XOR2HS $PINS O=n3969 I1=n3959 I2=n3610
XU3617 OAI12HS $PINS O=n3610 A1=n3953 B1=n4077 B2=n3954
XU3618 ND2 $PINS O=n3953 I1=n2589 I2=n3952
XU3619 MOAI1 $PINS O=n6560 A1=n5544 A2=FE_OFN1542_n7067 B1=FE_DBTN22_n3850
+ B2=n5543
XU3620 ND2 $PINS O=n9421 I1=n2460 I2=n3459
XU3621 XOR2HS $PINS O=n6032 I1=n6023 I2=n2005
XU3622 ND2 $PINS O=n2006 I1=n6023 I2=n6024
XU3623 ND2 $PINS O=n2007 I1=n6023 I2=n6025
XU3624 ND2 $PINS O=n2008 I1=n6024 I2=n6025
XU3625 ND3 $PINS O=n6033 I1=n2006 I2=n2007 I3=n2008
XU3626 OAI22S $PINS O=n5986 A1=n5963 A2=n5980 B1=n6414 B2=n5981
XU3627 NR2P $PINS O=n8831 I1=n6438 I2=n6437
XU3628 MOAI1 $PINS O=n5701 A1=n5684 A2=FE_OFN1583_FE_DBTN6_n7135
+ B1=FE_DBTN16_n5612 B2=n5683
XU3630 AN2 $PINS O=n2010 I1=n6057 I2=n6056
XU3631 AN2 $PINS O=n2011 I1=n8921 I2=n8920
XU3632 NR2 $PINS O=n5664 I1=FE_OFN1241_n7179 I2=FE_OFN1699_n7188
XU3633 ND2P $PINS O=n9619 I1=n9628 I2=n9618
XU3634 OAI22S $PINS O=n6616 A1=n6605 A2=n6531 B1=FE_OFN1454_n2727 B2=n6540
XU3635 INV1S $PINS O=n4073 I=n4070
XU3636 XNR2HS $PINS O=n2256 I1=n6363 I2=n6361
XU3637 XNR2H $PINS O=n6225 I1=n2033 I2=weight_1_r[20]
XU3638 MOAI1 $PINS O=n6344 A1=n6314 A2=FE_OFN1568_FE_DBTN31_n6225 B1=n6333
+ B2=FE_OFN1560_FE_DBTN40_n3656
XU3639 INV1S $PINS O=n6333 I=n2428
XU3640 XNR2HS $PINS O=n3653 I1=n3564 I2=n6231
XU3641 NR2P $PINS O=n3343 I1=n3344 I2=n3345
XU3642 XNR2HS $PINS O=n4176 I1=FE_OFN1372_weight_2_r_19 I2=data_2_r[35]
XU3645 INV1S $PINS O=n3442 I=n4411
XU3646 XOR2HS $PINS O=n2012 I1=data_0_r[43] I2=FE_OFN1551_n9711
XU3647 NR2T $PINS O=n9058 I1=n4147 I2=n4148
XU3648 XNR2HS $PINS O=n4148 I1=n6828 I2=n3748
XU3650 MOAI1S $PINS O=n7183 A1=FE_OFN1579_FE_DBTN8_n9443 A2=n7170 B1=n7169
+ B2=FE_OFN9122_n2908
XU3652 ND2P $PINS O=n9524 I1=n9522 I2=n9521
XU3653 MOAI1H $PINS O=n3280 A1=n4135 A2=FE_OFN1576_FE_DBTN17_n6819
+ B1=FE_OFN1654_n3599 B2=n4319
XU3654 XOR2HS $PINS O=n6538 I1=FE_OFN1279_weight_0_r_9 I2=data_0_r[28]
XU3655 AOI22S $PINS O=n6627 A1=n6538 A2=FE_OFN1283_weight_0_r_8 B1=n6537
+ B2=n5564
XU3656 OAI22S $PINS O=n6156 A1=n6154 A2=FE_OFN1617_n6138 B1=n2918 B2=n6148
XU3658 XNR2HS $PINS O=n6154 I1=FE_OFN1306_weight_1_r_23 I2=data_1_r[45]
XU3659 INV1S $PINS O=n8937 I=n2003
XU3660 XOR2HS $PINS O=pConv_2/product_0_w[19] I1=n2016 I2=n2198
XU3662 ND2P $PINS O=n7262 I1=n6030 I2=n6029
XU3663 NR2 $PINS O=n3390 I1=n6027 I2=n6026
XU3664 INV1S $PINS O=n2686 I=n6004
XU3665 FA1 $PINS S=n4650 CO=n4651 A=n4644 B=n4643 CI=n4642
XU3666 XOR2H $PINS O=pConv_2/product_0_w[20] I1=n2018 I2=n8829
XU3667 AN2 $PINS O=n2018 I1=n8827 I2=n8826
XU3668 XNR2HS $PINS O=pConv_2/product_1_w[16] I1=n7255 I2=n7254
XU3669 XOR2HS $PINS O=n6743 I1=FE_OFN1290_weight_0_r_5 I2=data_0_r[7]
XU3670 NR2P $PINS O=n6703 I1=FE_OCPN9755_FE_OFN1289_weight_0_r_5 I2=n2399
XU3671 NR2P $PINS O=n6654 I1=weight_0_r[6] I2=FE_OFN1290_weight_0_r_5
XU3672 XNR2H $PINS O=n9457 I1=weight_0_r[6] I2=FE_OFN1290_weight_0_r_5
XU3673 OAI12HS $PINS O=n3360 A1=n3361 B1=n4257 B2=FE_DBTN17_n6819
XU3674 ND2P $PINS O=n9158 I1=n5880 I2=n5879
XU3675 XNR2HS $PINS O=n5880 I1=n5829 I2=n2179
XU3676 XNR2HS $PINS O=n5750 I1=n5743 I2=n2474
XU3677 XOR2HS $PINS O=n6692 I1=n2019 I2=n6695
XU3678 ND2 $PINS O=n2020 I1=n6695 I2=n6697
XU3679 ND2 $PINS O=n2021 I1=n6695 I2=n6696
XU3680 ND2 $PINS O=n3264 I1=n4408 I2=FE_OFN1474_n4495
XU3681 INV1S $PINS O=n2664 I=n2665
XU3682 XOR2HS $PINS O=n6770 I1=n6739 I2=n2023
XU3683 ND2 $PINS O=n2024 I1=n6739 I2=n6738
XU3684 ND2 $PINS O=n2025 I1=n6739 I2=n6740
XU3685 ND2 $PINS O=n2026 I1=n6738 I2=n6740
XU3687 OAI12H $PINS O=n9796 A1=n9801 B1=n9805 B2=n9803
XU3689 XNR2HS $PINS O=n6680 I1=n6690 I2=n3683
XU3690 XNR2HS $PINS O=n2028 I1=n4378 I2=n4377
XU3691 XOR2HS $PINS O=n2633 I1=n3084 I2=n3082
XU3692 INV1S $PINS O=n3785 I=n4382
XU3695 OA12P $PINS O=n4587 A1=n8951 B1=n8950 B2=n8958
XU3696 NR2P $PINS O=n8950 I1=n4465 I2=n4466
XU3697 ND2 $PINS O=n8951 I1=n4466 I2=n4465
XU3699 NR2 $PINS O=n6221 I1=n9433 I2=n2918
XU3700 OAI22S $PINS O=n6145 A1=n6148 A2=FE_OFN1617_n6138 B1=n2918 B2=n6142
XU3701 MOAI1S $PINS O=n6169 A1=n6161 A2=FE_DBTN31_n6225 B1=FE_OFN9125_n3656
+ B2=n6170
XU3703 OAI22S $PINS O=n5848 A1=n5841 A2=FE_OFN1669_n5855 B1=FE_OFN9139_n5853
+ B2=n5854
XU3704 XNR2HS $PINS O=n5502 I1=data_0_r[35] I2=FE_OFN1256_weight_0_r_19
XU3705 NR2 $PINS O=n2470 I1=n3900 I2=FE_OFN1597_n3897
XU3708 ND2 $PINS O=n2221 I1=FE_OFN1561_FE_DBTN40_n3656 I2=n6256
XU3709 MOAI1 $PINS O=n6357 A1=n2428 A2=FE_OFN1568_FE_DBTN31_n6225
+ B1=FE_OFN9124_n3656 B2=n6335
XU3710 XOR2HS $PINS O=n5768 I1=FE_OFN1345_weight_1_r_5 I2=data_1_r[7]
XU3711 XOR2HS $PINS O=n5744 I1=FE_OFN1343_weight_1_r_5 I2=data_1_r[4]
XU3715 AOI13HS $PINS O=n5915 A1=FE_OCPN9764_weight_0_r_19
+ B1=FE_OFN1253_weight_0_r_21 B2=n6884 B3=n5914
XU3716 XOR2HS $PINS O=n6469 I1=data_0_r[40] I2=FE_OFN1257_weight_0_r_19
XU3717 XOR2HS $PINS O=n6915 I1=data_0_r[46] I2=FE_OFN1260_weight_0_r_19
XU3720 MOAI1 $PINS O=n9236 A1=FE_DBTN24_weight_1_r_13 A2=FE_OFN1639_n9221
+ B1=FE_OFN1557_FE_DBTN42_n3886 B2=n9220
XU3721 OAI12HS $PINS O=n4032 A1=n3298 B1=FE_OFN1637_n9221 B2=n4019
XU3726 MOAI1 $PINS O=n5941 A1=FE_DBTN39_n3378 A2=n5580 B1=n5579 B2=n6086
XU3729 OAI12HS $PINS O=n9132 A1=FE_OFN1344_weight_1_r_5 B1=FE_DBTN16_n5612
+ B2=n7135
XU3730 NR2 $PINS O=n4200 I1=FE_OFN1368_weight_2_r_21 I2=n4202
XU3731 OAI22S $PINS O=n6273 A1=FE_OFN1590_n3135 A2=n6267 B1=n1875 B2=n6276
XU3732 OAI22S $PINS O=n6356 A1=n6339 A2=FE_OFN1681_n3135 B1=FE_OFN1447_n1875
+ B2=n6337
XU3734 NR2 $PINS O=n3919 I1=n3917 I2=n3916
XU3735 INV1S $PINS O=n4606 I=n4604
XU3736 INV1S $PINS O=n3803 I=n5699
XU3737 XNR2HS $PINS O=n7008 I1=data_0_r[27] I2=FE_OFN1268_weight_0_r_15
XU3738 XNR2HS $PINS O=n4279 I1=data_2_r[43] I2=FE_OFN1466_n4128
XU3739 XOR2HS $PINS O=n6045 I1=data_2_r[9] I2=FE_OFN1532_n6412
XU3741 ND2 $PINS O=n2575 I1=FE_OFN1451_n2589 I2=n2615
XU3742 INV1S $PINS O=n2103 I=n6196
XU3743 XNR2HS $PINS O=n5695 I1=data_1_r[12] I2=FE_OFN1342_weight_1_r_7
XU3744 XOR2HS $PINS O=n6886 I1=data_0_r[47] I2=FE_OFN1260_weight_0_r_19
XU3745 INV1S $PINS O=n9723 I=n6922
XU3746 INV1S $PINS O=n3667 I=n3906
XU3747 XNR2HS $PINS O=n5854 I1=FE_OFN1350_weight_1_r_3 I2=data_1_r[13]
XU3748 XNR2HS $PINS O=n4403 I1=data_2_r[29] I2=FE_OFN1473_n4404
XU3749 AOI22S $PINS O=n4247 A1=n4236 A2=FE_OFN1378_weight_2_r_16
+ B1=FE_OFN1467_n4306 B2=n4229
XU3750 INV1S $PINS O=n2590 I=n3980
XU3752 OAI22S $PINS O=n6624 A1=n6606 A2=n6531 B1=n2727 B2=n6605
XU3753 XNR2HS $PINS O=n2710 I1=n6121 I2=n6120
XU3755 XNR2HS $PINS O=n2514 I1=data_1_r[15] I2=FE_OFN1344_weight_1_r_5
XU3757 INV2 $PINS O=n3670 I=n9234
XU3758 NR2 $PINS O=n4637 I1=n4614 I2=n2618
XU3759 XOR2HS $PINS O=n4298 I1=n4294 I2=n4295
XU3760 INV2 $PINS O=n3697 I=n3698
XU3761 NR2 $PINS O=n3083 I1=n4228 I2=n4227
XU3762 MOAI1 $PINS O=n3380 A1=n6531 A2=FE_DBTN28_weight_0_r_15 B1=n6532
+ B2=n6579
XU3763 INV1S $PINS O=n3239 I=n6971
XU3764 XNR2HS $PINS O=n4641 I1=n3825 I2=n3826
XU3766 OAI12HS $PINS O=n4381 A1=weight_2_r[13] B1=FE_OCPN9759_FE_DBTN19_n4371
+ B2=n4532
XU3767 INV2 $PINS O=n2627 I=n9097
XU3768 OR2 $PINS O=n2564 I1=n5637 I2=n5638
XU3769 OR2 $PINS O=n3676 I1=n2482 I2=n8836
XU3770 NR2P $PINS O=n9510 I1=n9488 I2=n9489
XU3771 OR2 $PINS O=n3149 I1=n9530 I2=n9535
XU3773 NR2P $PINS O=n6875 I1=n9350 I2=n6874
XU3774 ND2 $PINS O=n7266 I1=n6946 I2=n6947
XU3775 INV1S $PINS O=n9271 I=n9265
XU3777 INV1S $PINS O=n2279 I=n9426
XU3778 INV1S $PINS O=n9566 I=n3427
XU3779 AOI22S $PINS O=n9585 A1=n5660 A2=weight_0_r[0] B1=FE_OFN1523_n5640
+ B2=n7179
XU3783 NR2 $PINS O=n4861 I1=n4671 I2=n4672
XU3820 INV1S $PINS O=n7550 I=Buffer/data_buffer[383]
XU3829 INV1S $PINS O=n8282 I=Buffer/data_buffer[157]
XU3835 INV1S $PINS O=n7292 I=Buffer/counter_temp[3]
XU3836 MUX2 $PINS O=n389 S=Buffer/counter_temp[0] A=FE_OFN125_FE_DBTN1_n7298
+ B=Buffer/counter_temp[3]
XU3837 OR2 $PINS O=n2049 I1=n6492 I2=n6491
XU3838 OR2 $PINS O=n2050 I1=n3340 I2=n4551
XU3839 AN3 $PINS O=n2051 I1=n5725 I2=FE_DBTN37_n5853 I3=FE_DBTN49_data_1_r_1
XU3840 NR3 $PINS O=n2052 I1=n3927 I2=weight_1_r[12] I3=FE_DBTN24_weight_1_r_13
XU3841 XNR2HS $PINS O=n2053 I1=FE_OFN1255_weight_0_r_21 I2=data_0_r[46]
XU3842 XNR2HS $PINS O=n2054 I1=FE_OFN1255_weight_0_r_21 I2=data_0_r[47]
XU3843 XNR2HS $PINS O=n2055 I1=data_0_r[40] I2=FE_OFN1551_n9711
XU3844 INV1S $PINS O=n8923 I=n8922
XU3845 XNR2HS $PINS O=n2056 I1=n9604 I2=n9603
XU3846 XOR2HS $PINS O=n2058 I1=data_1_r[20]
+ I2=FE_OFN1426_FE_DBTN44_weight_1_r_11
XU3849 INV1S $PINS O=n2135 I=n9429
XU3850 INV1S $PINS O=n3396 I=n6426
XU3851 INV1S $PINS O=n2399 I=weight_0_r[4]
XU3853 XNR2HS $PINS O=n2060 I1=FE_OFN1346_weight_1_r_5 I2=data_1_r[10]
XU3855 OA12 $PINS O=n2061 A1=n9135 B1=n9137 B2=n9136
XU3856 OR2 $PINS O=n2062 I1=n5814 I2=n5813
XU3857 ND2 $PINS O=n9563 I1=n5651 I2=n5652
XU3861 OA12 $PINS O=n2063 A1=n8826 B1=n8825 B2=n8828
XU3862 OR2T $PINS O=n2064 I1=n5976 I2=n5977
XU3863 NR2 $PINS O=n8866 I1=n5948 I2=n5947
XU3864 OR2 $PINS O=n2065 I1=n6039 I2=n6038
XU3866 OAI12HS $PINS O=n3778 A1=n4526 B1=n2587 B2=n3779
XU3869 MOAI1S $PINS O=n6592 A1=FE_OFN1542_n7067 A2=n6563 B1=FE_DBTN22_n3850
+ B2=n2358
XU3870 INV1S $PINS O=n4559 I=n4558
XU3871 NR2 $PINS O=n2282 I1=n6594 I2=n3536
XU3872 OAI22S $PINS O=n5849 A1=n5839 A2=FE_OFN1583_FE_DBTN6_n7135 B1=n2060
+ B2=n5612
XU3873 INV1S $PINS O=n4620 I=n4617
XU3875 ND3 $PINS O=n3815 I1=n2835 I2=n9149 I3=n9147
XU3876 XNR2HS $PINS O=n6148 I1=FE_OFN1306_weight_1_r_23 I2=data_1_r[46]
XU3877 NR2P $PINS O=n9259 I1=n9256 I2=n9255
XU3878 NR2 $PINS O=n9255 I1=n9254 I2=n9278
XU3879 ND2T $PINS O=n3188 I1=n2571 I2=n2569
XU3880 MOAI1 $PINS O=n6902 A1=n3116 A2=n3115 B1=n6981 B2=n6982
XU3881 NR2 $PINS O=n3116 I1=n6982 I2=n6981
XU3882 ND2 $PINS O=n9369 I1=n6367 I2=n6366
XU3883 OAI12H $PINS O=n6366 A1=n2490 B1=n2492 B2=n2491
XU3884 XNR2HS $PINS O=n3673 I1=n9234 I2=FE_OCPN9769_FE_OFN1335_weight_1_r_9
XU3885 OAI12H $PINS O=n2439 A1=n3646 B1=n3648 B2=n3647
XU3886 XOR2HS $PINS O=n5655 I1=FE_OFN1297_weight_0_r_1 I2=data_0_r[4]
XU3887 XNR2HS $PINS O=n6456 I1=FE_OFN1257_weight_0_r_19 I2=data_0_r[39]
XU3888 XNR2H $PINS O=n9443 I1=weight_0_r[4] I2=FE_OFN9130_weight_0_r_3
XU3889 MOAI1 $PINS O=n6696 A1=FE_OFN1580_FE_DBTN8_n9443 A2=n6685
+ B1=FE_DBTN20_n2908 B2=n6684
XU3890 NR2P $PINS O=n2682 I1=n4016 I2=n2683
XU3892 NR2 $PINS O=n2112 I1=weight_1_r[12] I2=FE_DBTN24_weight_1_r_13
XU3893 AOI22H $PINS O=n4017 A1=n4000 A2=FE_OFN1338_weight_1_r_8
+ B1=FE_OFN1461_n3961 B2=n4013
XU3894 MOAI1S $PINS O=n4598 A1=FE_OFN1479_n4623 A2=n4461 B1=FE_OFN1474_n4495
+ B2=n4604
XU3896 ND3P $PINS O=n2085 I1=n3833 I2=n3834 I3=n9145
XU3897 ND2 $PINS O=n9396 I1=n9390 I2=n9391
XU3898 INV1S $PINS O=n9405 I=n3658
XU3899 ND2 $PINS O=n2911 I1=n3427 I2=n3166
XU3900 OAI12HS $PINS O=n3805 A1=n7162 B1=n7163 B2=n7164
XU3901 ND2 $PINS O=n9294 I1=n9289 I2=n9290
XU3904 OA12 $PINS O=n9330 A1=n2722 B1=n9325 B2=n2573
XU3905 ND2 $PINS O=n9748 I1=n9737 I2=n9736
XU3906 INV1S $PINS O=n9567 I=n3303
XU3907 INV1S $PINS O=n9328 I=n2764
XU3908 NR2P $PINS O=n9607 I1=n7009 I2=n7010
XU3909 INV1S $PINS O=n9331 I=n2626
XU3910 ND2S $PINS O=n2754 I1=n9054 I2=n9055
XU3911 INV1S $PINS O=n9670 I=n2360
XU3912 INV1S $PINS O=n2731 I=n6261
XU3913 ND2 $PINS O=n5735 I1=n5734 I2=n5733
XU3914 INV1S $PINS O=n2194 I=n4302
XU3916 XNR2HS $PINS O=n6124 I1=n6116 I2=n2163
XU3917 XNR2HS $PINS O=n3291 I1=n9461 I2=n3294
XU3918 INV1S $PINS O=n6472 I=n6471
XU3919 INV1S $PINS O=n3223 I=n3565
XU3956 XNR2HS $PINS O=n3809 I1=FE_OFN1355_weight_1_r_1 I2=n7146
XU3957 INV1S $PINS O=n2457 I=n6275
XU3958 ND2 $PINS O=n4469 I1=FE_OFN1546_n8995 I2=FE_OFN1388_weight_2_r_13
XU3959 INV1S $PINS O=n4405 I=n4407
XU3962 XNR2HS $PINS O=n6941 I1=n2160 I2=FE_OFN1264_weight_0_r_17
XU3963 ND2S $PINS O=n9594 I1=FE_OFN1268_weight_0_r_15 I2=data_0_r[23]
XU3964 INV1S $PINS O=n5513 I=n5511
XU3969 INV1S $PINS O=n2067 I=n9461
XU3970 INV1S $PINS O=n3078 I=data_0_r[26]
XU3971 INV1S $PINS O=n3102 I=FE_OFN1356_weight_1_r_0
XU3972 INV1S $PINS O=n3672 I=data_1_r[18]
XU3974 INV1S $PINS O=n3492 I=data_1_r[2]
XU3975 MUX2S $PINS O=o_data[7] S=FE_OFN1214_n5429 A=conv[7] B=o_data_temp[7]
XU3976 MUX2 $PINS O=o_data[0] S=FE_OFN1217_n5429 A=conv[0] B=o_data_temp[0]
XU3977 MUX2S $PINS O=o_data[4] S=FE_OFN1217_n5429 A=conv[4] B=o_data_temp[4]
XU3978 MUX2S $PINS O=o_data[1] S=FE_OFN1217_n5429 A=conv[1] B=o_data_temp[1]
XU3979 MUX2S $PINS O=o_data[3] S=FE_OFN1217_n5429 A=conv[3] B=o_data_temp[3]
XU3980 MUX2S $PINS O=o_data[6] S=FE_OFN1214_n5429 A=conv[6] B=o_data_temp[6]
XU3981 MUX2S $PINS O=o_data[5] S=FE_OFN1214_n5429 A=conv[5] B=o_data_temp[5]
XU3982 MUX2S $PINS O=o_data[2] S=FE_OFN1217_n5429 A=conv[2] B=o_data_temp[2]
XU3985 XNR2HS $PINS O=pConv_2/product_0_w[16] I1=n7261 I2=n3206
XU3987 XNR2HS $PINS O=pConv_0/product_2_w[16] I1=n7269 I2=n3098
XU3988 XNR2HS $PINS O=pConv_2/product_0_w[13] I1=n6055 I2=n3389
XU3989 ND3P $PINS O=n2346 I1=n5888 I2=n5887 I3=n7163
XU3990 XOR2HS $PINS O=pConv_2/product_0_w[21] I1=n6445 I2=n2168
XU3991 ND3P $PINS O=n9531 I1=n3150 I2=n9533 I3=n3149
XU3992 ND3P $PINS O=n9516 I1=n9515 I2=n9513 I3=n9514
XU3993 XNR2HS $PINS O=pConv_0/product_1_w[13] I1=n6652 I2=n6651
XU3994 ND3 $PINS O=n9087 I1=n3532 I2=n9085 I3=n9086
XU3995 ND2 $PINS O=n6786 I1=n3658 I2=n9406
XU3996 ND2 $PINS O=n6858 I1=n6862 I2=n6863
XU3997 ND2 $PINS O=n9381 I1=n9376 I2=n9375
XU3998 ND2 $PINS O=n9160 I1=n9159 I2=n9158
XU3999 ND2 $PINS O=n8959 I1=n8953 I2=n8954
XU4000 ND2 $PINS O=n7128 I1=n7127 I2=n7126
XU4001 ND2 $PINS O=n9662 I1=n9655 I2=n9654
XU4002 ND2 $PINS O=n7258 I1=n7256 I2=n7257
XU4004 ND2 $PINS O=n6853 I1=n9659 I2=n9656
XU4005 ND2 $PINS O=n6652 I1=n9648 I2=n9650
XU4006 ND2 $PINS O=n6055 I1=n8844 I2=n8846
XU4007 ND2 $PINS O=n6789 I1=n6795 I2=n6793
XU4008 ND2 $PINS O=n6843 I1=n6848 I2=n3402
XU4009 ND2 $PINS O=n9787 I1=n9779 I2=n9780
XU4010 ND2 $PINS O=n6517 I1=n9784 I2=n9781
XU4011 AN2 $PINS O=n7166 I1=n7154 I2=n9135
XU4012 AOI12HS $PINS O=n9667 A1=n9664 B1=n9665 B2=n9666
XU4013 ND2 $PINS O=n9168 I1=n9163 I2=n9164
XU4014 ND2 $PINS O=n9170 I1=n9161 I2=n9162
XU4015 ND2 $PINS O=n9537 I1=n9534 I2=n9533
XU4017 ND2 $PINS O=n6811 I1=n8852 I2=n8855
XU4018 ND2 $PINS O=n9088 I1=n9081 I2=n9082
XU4019 ND2 $PINS O=n9308 I1=n9305 I2=n9304
XU4020 INV1S $PINS O=n7251 I=n7249
XU4021 INV1S $PINS O=n9299 I=n9298
XU4022 ND2 $PINS O=n8858 I1=n8850 I2=n8851
XU4023 ND2 $PINS O=n9555 I1=n9545 I2=n9546
XU4024 ND2 $PINS O=n7288 I1=n7284 I2=n7283
XU4025 INV1S $PINS O=n9162 I=n2553
XU4026 ND2 $PINS O=n9287 I1=n9282 I2=n9281
XU4027 ND2 $PINS O=n6397 I1=n9164 I2=n3497
XU4028 ND2 $PINS O=n7125 I1=n7123 I2=n9253
XU4029 INV2 $PINS O=n2548 I=n2547
XU4030 ND2 $PINS O=n6818 I1=n6814 I2=n6813
XU4031 ND2 $PINS O=n9135 I1=n7153 I2=n7152
XU4032 INV1S $PINS O=n2068 I=n9076
XU4033 ND2T $PINS O=n9666 I1=n3618 I2=n3617
XU4034 INV3 $PINS O=n2069 I=n9633
XU4035 NR2P $PINS O=n9558 I1=n3425 I2=n3682
XU4036 ND2 $PINS O=n9532 I1=n9528 I2=n9527
XU4038 OAI12HS $PINS O=n2640 A1=n2641 B1=n2732 B2=n2731
XU4039 ND2 $PINS O=n6778 I1=n9540 I2=n9542
XU4040 INV1S $PINS O=n7117 I=n6436
XU4041 ND2 $PINS O=n9263 I1=n9250 I2=n9249
XU4042 INV1S $PINS O=n9798 I=n3463
XU4043 NR2P $PINS O=n9272 I1=n9247 I2=n9248
XU4044 ND2 $PINS O=n4645 I1=n3181 I2=n3180
XU4045 ND2 $PINS O=n3576 I1=n3578 I2=n3577
XU4046 ND2 $PINS O=n9060 I1=n6832 I2=n6831
XU4047 ND2 $PINS O=n9606 I1=n7010 I2=n7009
XU4049 NR2T $PINS O=n6985 I1=n6512 I2=n6511
XU4050 ND2 $PINS O=n2287 I1=n6037 I2=n2065
XU4052 OAI12HS $PINS O=n5810 A1=n2504 B1=n2505 B2=n2507
XU4053 INV2 $PINS O=n2070 I=n7259
XU4054 XNR2HS $PINS O=n2329 I1=n7088 I2=n7087
XU4055 ND2 $PINS O=n3577 I1=n4297 I2=n4298
XU4056 ND2S $PINS O=n8989 I1=n8987 I2=n8988
XU4057 ND2 $PINS O=n9583 I1=n9582 I2=n9581
XU4058 NR2 $PINS O=n9194 I1=n5634 I2=n5633
XU4059 ND2S $PINS O=n2753 I1=n9054 I2=n9053
XU4060 FA1 $PINS S=n9736 CO=n9716 A=n9720 B=n9719 CI=n9718
XU4061 NR2 $PINS O=n6355 I1=n6342 I2=n6341
XU4062 ND3 $PINS O=n5753 I1=n5736 I2=n5737 I3=n5735
XU4063 ND2 $PINS O=n8882 I1=n8881 I2=n8880
XU4064 FA1 $PINS S=n6439 CO=n6417 A=n6421 B=n6420 CI=n6419
XU4065 AOI12HS $PINS O=n9805 A1=n9808 B1=n9806 B2=n9810
XU4066 OAI12H $PINS O=n9095 A1=n9101 B1=n9104 B2=n9102
XU4067 INV1S $PINS O=n5904 I=n5901
XU4068 INV2 $PINS O=n9092 I=n3761
XU4069 OAI12HS $PINS O=n5037 A1=n5035 B1=FE_OFN1133_FE_DBTN14_n4987 B2=n5036
XU4070 OAI12HS $PINS O=n5029 A1=n5027 B1=FE_OFN1133_FE_DBTN14_n4987 B2=n5028
XU4071 INV1S $PINS O=n3542 I=n3989
XU4072 OAI12HS $PINS O=n5251 A1=n5249 B1=FE_OFN1134_FE_DBTN13_n5209 B2=n5250
XU4073 INV1S $PINS O=n3488 I=n4263
XU4074 OAI12HS $PINS O=n5259 A1=n5257 B1=FE_DBTN13_n5209 B2=n5258
XU4075 OR2 $PINS O=n3052 I1=n6975 I2=n6974
XU4076 OAI12HS $PINS O=n4815 A1=n4813 B1=FE_OFN1132_FE_DBTN15_n4765 B2=n4814
XU4077 OA12 $PINS O=pconv_1_w[24] A1=n5105 B1=n2968 B2=n5106
XU4078 OAI12HS $PINS O=n4807 A1=n4805 B1=FE_OFN1132_FE_DBTN15_n4765 B2=n4806
XU4079 FA1 $PINS S=n7152 CO=n9133 A=n9132 B=n9131 CI=n9130
XU4080 FA1 $PINS S=n7009 CO=n9603 A=n9602 B=n9601 CI=n9600
XU4081 OAI12HS $PINS O=n9451 A1=n3292 B1=n3294 B2=n2067
XU4082 OA12 $PINS O=pconv_0_w[24] A1=n4883 B1=n2967 B2=n4884
XU4083 ND2S $PINS O=n2755 I1=n9053 I2=n9055
XU4084 XNR2HS $PINS O=n3174 I1=n7080 I2=n3879
XU4085 XNR2HS $PINS O=n5873 I1=n3809 I2=n5862
XU4086 INV1S $PINS O=n5519 I=n5518
XU4087 OAI12HS $PINS O=n6427 A1=n3731 B1=n6424 B2=n3732
XU4088 ND2 $PINS O=n3292 I1=n9460 I2=n3293
XU4089 INV1S $PINS O=n4493 I=n4511
XU4092 ND2 $PINS O=n3500 I1=n4515 I2=n2578
XU4093 XOR2HS $PINS O=n3332 I1=n6608 I2=n3333
XU4094 NR2 $PINS O=n3183 I1=n4441 I2=n2743
XU4095 MAO222 $PINS O=n6123 A1=n6118 B1=n6119 C1=n2248
XU4096 NR2 $PINS O=n3333 I1=n6588 I2=n6587
XU4097 ND2 $PINS O=n9198 I1=n5630 I2=n5629
XU4098 FA1 $PINS S=n9719 CO=n9704 A=n9710 B=n9709 CI=n9708
XU4099 FA1S $PINS S=n9131 CO=n9128 A=n9127 B=n9126 CI=n9125
XU4100 NR2 $PINS O=n6043 I1=n6022 I2=n6021
XU4101 OAI12HS $PINS O=n4765 A1=n4687 B1=n4830 B2=n4688
XU4102 ND2S $PINS O=n9114 I1=n9113 I2=n9112
XU4103 FA1S $PINS S=n9230 CO=n9214 A=n9219 B=n9218 CI=n9217
XU4104 OAI12HS $PINS O=n4987 A1=n4909 B1=n5052 B2=n4910
XU4108 INV1S $PINS O=n6669 I=n6670
XU4109 INV1S $PINS O=n2111 I=n6480
XU4110 AN2 $PINS O=n2150 I1=n2151 I2=n2152
XU4112 AOI22S $PINS O=n6737 A1=n6728 A2=FE_OFN1299_weight_0_r_0
+ B1=FE_OFN1522_n5640 B2=n6708
XU4113 INV1S $PINS O=n3837 I=n6742
XU4114 ND2S $PINS O=n5106 I1=n5100 I2=n5103
XU4116 ND2S $PINS O=n4993 I1=n4991 I2=n5009
XU4117 ND2S $PINS O=n5002 I1=n5009 I2=n5000
XU4118 ND2S $PINS O=n5013 I1=n5009 I2=n5017
XU4119 ND2S $PINS O=n5328 I1=n5322 I2=n5325
XU4120 ND2S $PINS O=n5215 I1=n5213 I2=n5231
XU4122 ND2S $PINS O=n4884 I1=n4878 I2=n4881
XU4124 ND2S $PINS O=n8258 I1=i_data[5] I2=FE_OFN1245_n7298
XU4125 ND2S $PINS O=n8439 I1=i_data[4] I2=FE_OFN1245_n7298
XU4126 ND2S $PINS O=n7880 I1=i_data[3] I2=FE_OFN1244_n7298
XU4127 ND2S $PINS O=n8061 I1=i_data[1] I2=FE_OFN1243_n7298
XU4129 ND2S $PINS O=n4771 I1=n4769 I2=n4787
XU4130 ND2S $PINS O=n4780 I1=n4787 I2=n4778
XU4131 ND2S $PINS O=n4791 I1=n4787 I2=n4795
XU4132 ND2S $PINS O=n5224 I1=n5231 I2=n5222
XU4136 ND2S $PINS O=n5235 I1=n5231 I2=n5239
XU4137 INV1S $PINS O=n2269 I=n4168
XU4138 INV1S $PINS O=n6880 I=n6914
XU4140 ND2 $PINS O=n9112 I1=n4154 I2=n4153
XU4144 OAI12HS $PINS O=n4711 A1=n4709 B1=n4796 B2=n4710
XU4145 NR2 $PINS O=n5156 I1=n5154 I2=n5241
XU4146 ND2 $PINS O=n4393 I1=n4387 I2=FE_OFN1392_weight_2_r_11
XU4148 MOAI1H $PINS O=n6742 A1=n6744 A2=FE_OFN1704_n9443 B1=FE_DBTN38_n6714
+ B2=FE_OFN1574_FE_DBTN20_n2908
XU4154 OAI12HS $PINS O=n4933 A1=n4931 B1=n5018 B2=n4932
XU4157 ND2S $PINS O=n4744 I1=n4738 I2=n4737
XU4159 ND2S $PINS O=n4761 I1=n4760 I2=n4759
XU4160 ND2S $PINS O=n1710 I1=n7296 I2=n7292
XU4161 ND2S $PINS O=n4757 I1=n4755 I2=n4754
XU4162 ND2S $PINS O=n4773 I1=n4764 I2=n4763
XU4163 INV1S $PINS O=n6957 I=n6954
XU4164 ND2S $PINS O=n4742 I1=n4747 I2=n4746
XU4165 XOR2HS $PINS O=n3434 I1=n6193 I2=n6166
XU4166 ND3 $PINS O=n5480 I1=FE_DBTN48_n1875 I2=n9433 I3=weight_1_r[19]
XU4168 XNR2HS $PINS O=n3742 I1=n3716 I2=n6424
XU4169 ND2S $PINS O=n5186 I1=n5191 I2=n5190
XU4170 ND2S $PINS O=n5188 I1=n5182 I2=n5181
XU4171 ND2S $PINS O=n5201 I1=n5199 I2=n5198
XU4172 ND2S $PINS O=n5205 I1=n5204 I2=n5203
XU4173 ND2S $PINS O=n5217 I1=n5208 I2=n5207
XU4174 ND2 $PINS O=n5021 I1=n5017 I2=n5016
XU4175 ND2S $PINS O=n5028 I1=n5033 I2=n5032
XU4176 ND2S $PINS O=n5030 I1=n5024 I2=n5023
XU4177 ND2 $PINS O=n5038 I1=n5032 I2=n5031
XU4178 ND2S $PINS O=n5058 I1=n5051 I2=n5050
XU4179 ND2S $PINS O=n5065 I1=n5061 I2=n5060
XU4180 ND2S $PINS O=n5076 I1=n5074 I2=n5073
XU4181 ND2S $PINS O=n5082 I1=n5079 I2=n5078
XU4182 ND2S $PINS O=n5087 I1=n5085 I2=n5084
XU4183 ND2S $PINS O=n5091 I1=n5090 I2=n5089
XU4184 XNR2HS $PINS O=n6730 I1=FE_OFN1284_weight_0_r_7 I2=data_0_r[4]
XU4185 ND2 $PINS O=n5243 I1=n5239 I2=n5238
XU4186 ND2S $PINS O=n5250 I1=n5255 I2=n5254
XU4187 ND2S $PINS O=n5252 I1=n5246 I2=n5245
XU4188 ND2 $PINS O=n5260 I1=n5254 I2=n5253
XU4189 ND2S $PINS O=n5270 I1=n5268 I2=n5267
XU4190 ND2S $PINS O=n5280 I1=n5273 I2=n5272
XU4191 ND2S $PINS O=n5287 I1=n5283 I2=n5282
XU4192 ND2S $PINS O=n5298 I1=n5296 I2=n5295
XU4193 ND2S $PINS O=n5304 I1=n5301 I2=n5300
XU4194 ND2S $PINS O=n5309 I1=n5307 I2=n5306
XU4195 ND2S $PINS O=n5313 I1=n5312 I2=n5311
XU4196 ND2S $PINS O=n4808 I1=n4802 I2=n4801
XU4197 ND2S $PINS O=n4806 I1=n4811 I2=n4810
XU4198 ND2 $PINS O=n5499 I1=FE_OFN1131_FE_DBTN29_data_0_r_33 I2=weight_0_r[21]
XU4199 ND2S $PINS O=n4843 I1=n4839 I2=n4838
XU4200 ND2S $PINS O=n4836 I1=n4829 I2=n4828
XU4201 ND2S $PINS O=n4854 I1=n4852 I2=n4851
XU4202 ND2S $PINS O=n4860 I1=n4857 I2=n4856
XU4203 ND2S $PINS O=n4865 I1=n4863 I2=n4862
XU4204 ND2S $PINS O=n4869 I1=n4868 I2=n4867
XU4205 XNR2HS $PINS O=n3456 I1=n6193 I2=n6173
XU4206 ND2S $PINS O=n4826 I1=n4824 I2=n4823
XU4207 ND2 $PINS O=n4816 I1=n4810 I2=n4809
XU4208 ND2S $PINS O=n4983 I1=n4982 I2=n4981
XU4209 ND2S $PINS O=n4995 I1=n4986 I2=n4985
XU4210 ND2S $PINS O=n4964 I1=n4969 I2=n4968
XU4211 ND2S $PINS O=n4966 I1=n4960 I2=n4959
XU4212 ND2S $PINS O=n4979 I1=n4977 I2=n4976
XU4213 ND2 $PINS O=n4799 I1=n4795 I2=n4794
XU4216 ND2 $PINS O=n6922 I1=FE_OFN1249_weight_0_r_23 I2=data_0_r[34]
XU4217 NR2 $PINS O=n5285 I1=n5288 I2=n5291
XU4218 ND2S $PINS O=n9047 I1=FE_OFN1366_weight_2_r_23 I2=data_2_r[39]
XU4221 XOR2HS $PINS O=n6334 I1=data_1_r[41] I2=FE_OFN1530_n6178
XU4222 NR2 $PINS O=n5130 I1=n5271 I2=n5281
XU4223 NR2 $PINS O=n5063 I1=n5066 I2=n5069
XU4224 NR2 $PINS O=n4908 I1=n5049 I2=n5059
XU4225 ND2S $PINS O=n6400 I1=FE_OFN1398_weight_2_r_7 I2=data_2_r[7]
XU4226 NR2 $PINS O=n4686 I1=n4827 I2=n4837
XU4227 NR2 $PINS O=n4841 I1=n4844 I2=n4847
XU4228 INV1S $PINS O=n5662 I=n5660
XU4232 NR2 $PINS O=n5227 I1=n5145 I2=n5146
XU4234 OR2 $PINS O=n5109 I1=pConv_2/product_2_r[1] I2=n5111
XU4236 NR2 $PINS O=n5288 I1=n5123 I2=n5124
XU4237 NR2 $PINS O=n5271 I1=n5127 I2=n5128
XU4238 OR2 $PINS O=n4887 I1=pConv_1/product_2_r[1] I2=n4889
XU4239 NR2 $PINS O=n5066 I1=n4901 I2=n4902
XU4241 NR2 $PINS O=n5261 I1=n5135 I2=n5136
XU4242 NR2 $PINS O=n5049 I1=n4905 I2=n4906
XU4243 NR2 $PINS O=n5005 I1=n4923 I2=n4924
XU4244 NR2 $PINS O=n5039 I1=n4913 I2=n4914
XU4245 NR2P $PINS O=n7298 I1=n7293 I2=n7292
XU4247 NR2 $PINS O=n4783 I1=n4701 I2=n4702
XU4248 NR2 $PINS O=n4844 I1=n4679 I2=n4680
XU4249 OR2 $PINS O=n4665 I1=pConv_0/product_2_r[1] I2=n4667
XU4251 ND2 $PINS O=n9461 I1=FE_OFN1285_weight_0_r_7 I2=data_0_r[5]
XU4252 NR2 $PINS O=n4817 I1=n4691 I2=n4692
XU4254 ND2S $PINS O=n7297 I1=Buffer/counter_temp[0] I2=Buffer/counter_temp[1]
XU4258 INV1S $PINS O=n3917 I=data_1_r[20]
XU4259 INV1S $PINS O=n8995 I=FE_OFN1414_data_2_r_17
XU4262 INV1S $PINS O=n6576 I=weight_0_r[12]
XU4266 ND2P $PINS O=n8864 I1=n5581 I2=n5582
XU4268 NR2 $PINS O=n3464 I1=data_1_r[20] I2=n2080
XU4269 ND3 $PINS O=n9367 I1=FE_OFN1240_n6309 I2=n9363 I3=n9362
XU4270 XOR2HS $PINS O=n3428 I1=n3429 I2=FE_DBTN24_weight_1_r_13
XU4272 AOI12HS $PINS O=n3930 A1=FE_OFN1327_weight_1_r_11 B1=n3926 B2=n3927
XU4273 NR2F $PINS O=n3643 I1=n3551 I2=n9063
XU4274 INV1S $PINS O=n2178 I=n5829
XU4275 INV2 $PINS O=n8838 I=n2321
XU4277 XOR2HS $PINS O=n5989 I1=data_2_r[10] I2=FE_OFN1408_weight_2_r_1
XU4278 XOR2HS $PINS O=n6005 I1=data_2_r[11] I2=FE_OFN1408_weight_2_r_1
XU4279 ND2T $PINS O=n9175 I1=n2084 I2=n3038
XU4280 ND2 $PINS O=n3038 I1=n5720 I2=n5719
XU4282 XOR2HS $PINS O=n5875 I1=n5700 I2=n3178
XU4283 INV1S $PINS O=n5685 I=n5689
XU4285 MAO222 $PINS O=n5976 A1=n5971 B1=n5972 C1=n5973
XU4287 AOI22S $PINS O=n4482 A1=n4471 A2=FE_OFN1396_weight_2_r_8 B1=n4483
+ B2=FE_OFN1666_n4591
XU4288 OAI12HS $PINS O=n6504 A1=n3522 B1=n6468 B2=FE_OFN1564_FE_DBTN36_n9707
XU4289 INV2 $PINS O=n9141 I=n2211
XU4290 OAI12HS $PINS O=n6988 A1=n2086 B1=n2088 B2=n2087
XU4291 INV2 $PINS O=n2088 I=n2089
XU4292 MOAI1S $PINS O=n5920 A1=n2092 A2=n2091 B1=n5905 B2=n5906
XU4293 NR2 $PINS O=n2092 I1=n5906 I2=n5905
XU4296 ND2 $PINS O=n7162 I1=n5702 I2=n2509
XU4297 INV1S $PINS O=n2232 I=n5899
XU4298 MOAI1 $PINS O=n4512 A1=n4623 A2=n4487 B1=n4495 B2=n2095
XU4299 INV1S $PINS O=n2095 I=n4486
XU4300 XNR2HS $PINS O=n2286 I1=n6039 I2=n6038
XU4301 MAO222 $PINS O=n6038 A1=n2421 B1=n6015 C1=n6014
XU4302 XNR2HS $PINS O=n6299 I1=n2642 I2=n2096
XU4303 XNR2HS $PINS O=n2096 I1=n6261 I2=n2733
XU4305 ND2 $PINS O=n2097 I1=weight_0_r[22] I2=FE_OFN1254_weight_0_r_21
XU4306 NR2P $PINS O=n9535 I1=n2398 I2=n2098
XU4307 XNR2HS $PINS O=n6347 I1=n2099 I2=n6353
XU4308 XNR2HS $PINS O=n2099 I1=n6354 I2=n6352
XU4309 XNR2HS $PINS O=n2226 I1=n6360 I2=n6359
XU4310 MAO222 $PINS O=n6359 A1=n6353 B1=n6354 C1=n6352
XU4311 NR2P $PINS O=n9266 I1=n9272 I2=n9273
XU4312 XNR2HS $PINS O=n5968 I1=data_2_r[6] I2=FE_OFN1404_weight_2_r_3
XU4313 AOI22S $PINS O=n6626 A1=n6604 A2=FE_OFN1283_weight_0_r_8 B1=n6603
+ B2=n2791
XU4314 MOAI1 $PINS O=n4325 A1=FE_OFN1659_n4331 A2=n4312 B1=FE_OFN1471_n4329
+ B2=n4327
XU4315 XNR2HS $PINS O=n3073 I1=n2568 I2=n4082
XU4316 NR2T $PINS O=n6835 I1=n3404 I2=n9058
XU4317 NR2 $PINS O=n4399 I1=n4530 I2=n4538
XU4318 INV1S $PINS O=n3686 I=n3687
XU4319 MAO222 $PINS O=n7202 A1=n2448 B1=n6677 C1=n6676
XU4320 ND2P $PINS O=n3874 I1=n9671 I2=n9669
XU4322 OAI12H $PINS O=n3448 A1=n3312 B1=FE_OFN1633_n7070 B2=n6578
XU4323 INV1S $PINS O=n9363 I=n7239
XU4325 OAI12HS $PINS O=n3242 A1=n6569 B1=n6578 B2=FE_OFN1677_n7036
XU4326 OAI12HS $PINS O=n6203 A1=n2102 B1=n2104 B2=n2103
XU4327 OAI12HS $PINS O=n2102 A1=n6194 B1=n6195 B2=n6196
XU4328 XNR2HS $PINS O=n2529 I1=n6202 I2=n6201
XU4329 XNR2HS $PINS O=n6201 I1=n6194 I2=n2105
XU4330 XNR2HS $PINS O=n6510 I1=n6507 I2=n6508
XU4331 MOAI1S $PINS O=n5522 A1=n6890 A2=n5492 B1=n5506 B2=FE_OFN1697_n5491
XU4332 XOR2HS $PINS O=n5500 I1=FE_OFN1261_weight_0_r_17 I2=data_0_r[37]
XU4333 MOAI1 $PINS O=n4550 A1=FE_OFN1693_n4596 A2=n4538 B1=FE_OFN9141_n3387
+ B2=n4536
XU4334 XOR2HS $PINS O=n4552 I1=n4564 I2=n4563
XU4335 INV3 $PINS O=n7046 I=FE_OFN1278_weight_0_r_9
XU4336 XNR2HS $PINS O=n6483 I1=n6479 I2=n2106
XU4337 XNR2HS $PINS O=n2106 I1=n2109 I2=n6480
XU4338 OAI12HS $PINS O=n6491 A1=n2107 B1=n2111 B2=n2108
XU4339 OAI12HS $PINS O=n2107 A1=n6479 B1=n6480 B2=n2109
XU4340 INV1S $PINS O=n2108 I=n2109
XU4341 OAI12HS $PINS O=n2109 A1=n2110 B1=n5917 B2=n1873
XU4342 MXL2HS $PINS OB=n3886 S=FE_OFN1327_weight_1_r_11 A=n3926 B=n2112
XU4343 ND3P $PINS O=n3639 I1=n3643 I2=n2975 I3=n9059
XU4344 OAI12HS $PINS O=n6440 A1=n2113 B1=n2115 B2=n2114
XU4345 XNR2HS $PINS O=n6438 I1=n2116 I2=n6433
XU4346 XNR2HS $PINS O=n2116 I1=n6435 I2=n6434
XU4347 XOR2HS $PINS O=n3921 I1=FE_OFN1331_weight_1_r_9 I2=data_1_r[22]
XU4348 INV2 $PINS O=n2158 I=n6507
XU4349 NR2P $PINS O=n3302 I1=n6508 I2=n2158
XU4350 XOR2HS $PINS O=n2583 I1=n6206 I2=n6207
XU4353 INV1S $PINS O=n3822 I=n3925
XU4354 MOAI1 $PINS O=n6479 A1=FE_OFN1622_n6448 A2=FE_DBTN23_weight_0_r_23
+ B1=n9697 B2=n5918
XU4356 MOAI1 $PINS O=n6546 A1=n6536 A2=FE_OFN1634_n7070 B1=FE_OFN1676_n7036
+ B2=n6551
XU4357 ND3P $PINS O=n7107 I1=n9626 I2=n2031 I3=n7104
XU4358 NR2F $PINS O=n9626 I1=n9635 I2=n7103
XU4359 OAI22S $PINS O=n7081 A1=n7071 A2=FE_OFN1634_n7070 B1=FE_OFN1678_n7036
+ B2=n7068
XU4360 XNR2HS $PINS O=n6634 I1=n6628 I2=n2200
XU4361 OAI22H $PINS O=n6629 A1=n6623 A2=FE_OFN1634_n7070 B1=n6622
+ B2=FE_OFN1678_n7036
XU4362 NR2P $PINS O=n7273 I1=n5884 I2=n5885
XU4363 MOAI1H $PINS O=n2452 A1=FE_OFN1634_n7070 A2=n6622 B1=n6535
+ B2=FE_OFN1676_n7036
XU4364 MOAI1 $PINS O=n7222 A1=FE_OFN9123_n2908 A2=n6662 B1=n7208 B2=n9443
XU4365 ND3HT $PINS O=n4586 I1=n6521 I2=n8955 I3=n4584
XU4366 ND3HT $PINS O=n6521 I1=n3335 I2=n3334 I3=n8962
XU4367 NR2 $PINS O=n8919 I1=n4657 I2=n4656
XU4368 NR2 $PINS O=n3489 I1=n9530 I2=n9526
XU4369 NR2 $PINS O=n9530 I1=n7232 I2=n7231
XU4370 XOR2H $PINS O=pConv_1/product_0_w[20] I1=n7166 I2=n2120
XU4371 ND3P $PINS O=n2120 I1=n3806 I2=n3842 I3=n3807
XU4372 XNR2HS $PINS O=n6937 I1=weight_0_r[18] I2=weight_0_r[17]
XU4373 XNR2HS $PINS O=n5791 I1=n5795 I2=n2121
XU4374 XNR2HS $PINS O=n2121 I1=n5796 I2=n2499
XU4377 ND2 $PINS O=n3892 I1=weight_1_r[14] I2=FE_OCPN9768_weight_1_r_13
XU4378 XOR2HS $PINS O=n5811 I1=n2701 I2=n2700
XU4379 MOAI1 $PINS O=n6218 A1=n2585 A2=n2584 B1=n6206 B2=n6207
XU4380 ND2 $PINS O=n5619 I1=n3855 I2=n3854
XU4381 XNR2HS $PINS O=n6931 I1=n6905 I2=n2240
XU4382 XNR2HS $PINS O=n3259 I1=n4638 I2=n3263
XU4385 NR2 $PINS O=n6901 I1=n6884 I2=FE_OFN1432_FE_DBTN23_weight_0_r_23
XU4387 NR2T $PINS O=n2488 I1=FE_OFN1548_n9433 I2=FE_OFN1567_FE_DBTN31_n6225
XU4388 ND2 $PINS O=n6686 I1=weight_0_r[2] I2=weight_0_r[1]
XU4389 NR2P $PINS O=n2211 I1=n7164 I2=n7165
XU4390 ND2 $PINS O=n9076 I1=n3476 I2=n2720
XU4391 MAO222 $PINS O=n9488 A1=n9484 B1=n9485 C1=n3172
XU4392 MAO222 $PINS O=n6991 A1=n6979 B1=n6978 C1=n2715
XU4393 FA1S $PINS S=n4380 CO=n4368 A=n4375 B=n4374 CI=n4373
XU4394 INV1S $PINS O=n5784 I=n5783
XU4395 XOR2HS $PINS O=pConv_0/product_0_w[19] I1=n2252 I2=n9516
XU4396 NR2P $PINS O=n4584 I1=n8950 I2=n6526
XU4397 NR2 $PINS O=n3760 I1=n3944 I2=n2124
XU4398 INV1S $PINS O=n2124 I=n3943
XU4399 MOAI1 $PINS O=n3943 A1=n3897 A2=n3923 B1=FE_OFN1459_n3428 B2=n3935
XU4400 ND2 $PINS O=n3581 I1=n3575 I2=n3577
XU4401 NR2 $PINS O=n9486 I1=n7199 I2=n7200
XU4403 XNR2HS $PINS O=n6771 I1=n6760 I2=n2126
XU4404 XNR2HS $PINS O=n2126 I1=n2129 I2=n2130
XU4405 OR2 $PINS O=n3427 I1=n6694 I2=n6693
XU4406 MOAI1S $PINS O=n6711 A1=n6658 A2=FE_OFN1446_FE_DBTN0_weight_0_r_7
+ B1=FE_OFN9144_n9457 B2=n6707
XU4407 OAI22S $PINS O=n6754 A1=n6749 A2=FE_OFN1647_n9466 B1=FE_OFN1641_n9465
+ B2=n6748
XU4408 OR2 $PINS O=n9586 I1=n9584 I2=n9585
XU4409 NR2 $PINS O=n2376 I1=n3211 I2=n3212
XU4410 ND3P $PINS O=n2127 I1=n9506 I2=n9508 I3=n9507
XU4411 XOR3 $PINS O=n2834 I1=n6762 I2=n6761 I3=n6760
XU4412 NR2 $PINS O=n2624 I1=n6741 I2=n6675
XU4413 XNR2HS $PINS O=n3684 I1=n3686 I2=n3837
XU4414 XOR2HS $PINS O=n6708 I1=FE_OFN1296_weight_0_r_1 I2=data_0_r[8]
XU4415 ND3HT $PINS O=n6776 I1=n6857 I2=n6773 I3=n9549
XU4416 NR2P $PINS O=n9549 I1=n6861 I2=n6856
XU4417 OAI12HS $PINS O=n6765 A1=n2128 B1=n2130 B2=n2129
XU4418 OAI12HS $PINS O=n2128 A1=n6760 B1=n6762 B2=n6761
XU4419 INV1S $PINS O=n2129 I=n6762
XU4420 OAI12HS $PINS O=n6761 A1=n3685 B1=n3837 B2=n3686
XU4421 ND3HT $PINS O=n4046 I1=n7290 I2=n9306 I3=n4039
XU4422 ND3HT $PINS O=n7290 I1=n3495 I2=n3494 I3=n9318
XU4423 XOR2HS $PINS O=n6030 I1=n6001 I2=n2131
XU4424 XOR2HS $PINS O=n2131 I1=n6003 I2=n6002
XU4425 AOI22S $PINS O=n6718 A1=n6708 A2=FE_OFN1299_weight_0_r_0
+ B1=FE_OFN1522_n5640 B2=n6698
XU4426 ND2 $PINS O=n3268 I1=n3545 I2=n3269
XU4427 OAI22S $PINS O=n9728 A1=FE_OFN1565_FE_DBTN36_n9707 A2=n2054
+ B1=FE_OFN1685_n5496 B2=n2053
XU4428 XNR2HS $PINS O=n9729 I1=n9726 I2=n2134
XU4429 XNR2HS $PINS O=n2134 I1=n9728 I2=n9727
XU4430 ND2 $PINS O=n9727 I1=n6899 I2=FE_OFN1260_weight_0_r_19
XU4431 ND2 $PINS O=n9430 I1=n2136 I2=n2135
XU4432 OAI12HS $PINS O=n2136 A1=n2137 B1=n3607 B2=data_1_r[33]
XU4433 NR2 $PINS O=n9432 I1=n2136 I2=n2135
XU4434 ND2 $PINS O=n2137 I1=n5483 I2=weight_1_r[16]
XU4435 INV1S $PINS O=n4167 I=n2270
XU4436 XOR2HS $PINS O=n2139 I1=n4170 I2=n4169
XU4437 OAI22S $PINS O=n4169 A1=n2932 A2=n4164 B1=n4176
+ B2=FE_OFN1559_FE_DBTN41_n4329
XU4438 MOAI1S $PINS O=n3244 A1=FE_OFN1565_FE_DBTN36_n9707 A2=n6881
+ B1=FE_OFN1684_n5496 B2=n6880
XU4439 MAO222 $PINS O=n6982 A1=n3244 B1=n6922 C1=FE_DBTN35_weight_0_r_17
XU4440 XNR2HS $PINS O=n2271 I1=n6982 I2=n6980
XU4441 AOI22S $PINS O=n6960 A1=n2141 A2=FE_OFN1266_weight_0_r_16
+ B1=FE_OFN1696_n5491 B2=n6501
XU4442 AOI22S $PINS O=n6964 A1=FE_OFN1266_weight_0_r_16 A2=n6941
+ B1=FE_OFN1696_n5491 B2=n2141
XU4443 OAI12HS $PINS O=n6930 A1=n2142 B1=n2144 B2=n2145
XU4444 ND2 $PINS O=n2142 I1=n2143 I2=n6944
XU4445 ND2 $PINS O=n2143 I1=n2145 I2=n2144
XU4446 OR2 $PINS O=n2145 I1=n6951 I2=n6912
XU4447 INV1S $PINS O=n2144 I=n6945
XU4448 OAI12H $PINS O=n2146 A1=n6509 B1=n6510 B2=n3524
XU4449 XNR2H $PINS O=n6989 I1=n2161 I2=n2149
XU4450 XNR2H $PINS O=n2149 I1=n2159 I2=n2156
XU4451 XNR2HS $PINS O=n2245 I1=n6963 I2=n6961
XU4452 AOI12H $PINS O=n6961 A1=n6964 B1=n2152 B2=n2151
XU4453 OR2P $PINS O=n2152 I1=n6943 I2=FE_OFN1622_n6448
XU4454 XNR2HS $PINS O=n6943 I1=data_0_r[38] I2=FE_OFN1248_weight_0_r_23
XU4456 XOR2HS $PINS O=n6934 I1=data_0_r[42] I2=FE_OFN1255_weight_0_r_21
XU4457 NR2 $PINS O=n5491 I1=FE_OFN1266_weight_0_r_16 I2=FE_DBTN35_weight_0_r_17
XU4459 XNR2HS $PINS O=n2161 I1=n6967 I2=n2162
XU4460 INV1S $PINS O=n6966 I=n2842
XU4461 MAO222 $PINS O=n6990 A1=n2161 B1=n2159 C1=n2156
XU4462 NR2 $PINS O=n2157 I1=n6965 I2=n3302
XU4463 AOI22S $PINS O=n6508 A1=n6501 A2=FE_OFN1265_weight_0_r_16 B1=n6463
+ B2=FE_OFN1698_n5491
XU4464 MOAI1 $PINS O=n6965 A1=n6506 A2=FE_OFN1586_n1873
+ B1=FE_OFN1569_FE_DBTN25_n6937 B2=n6954
XU4465 NR2 $PINS O=n6967 I1=n6960 I2=n6959
XU4466 ND2 $PINS O=n6093 I1=n2165 I2=n2164
XU4467 OAI12HS $PINS O=n2166 A1=n2167 B1=FE_OFN1409_weight_2_r_1 B2=n8889
XU4468 ND2 $PINS O=n2167 I1=n6089 I2=FE_OFN1457_n3162
XU4469 ND2P $PINS O=n2663 I1=n3567 I2=n2071
XU4470 NR2T $PINS O=n3567 I1=n9411 I2=n3654
XU4471 ND3P $PINS O=n2169 I1=n9525 I2=n9524 I3=n9523
XU4472 XNR2H $PINS O=n7093 I1=n7053 I2=n2170
XU4473 XNR2H $PINS O=n2170 I1=n7054 I2=n3210
XU4474 INV2 $PINS O=n3229 I=n6350
XU4475 MOAI1 $PINS O=n6350 A1=FE_OFN1618_n6138 A2=n6324 B1=n3482
+ B2=FE_OFN1656_n6322
XU4476 ND3HT $PINS O=n2171 I1=n9613 I2=n9614 I3=n9612
XU4477 XNR2HS $PINS O=n4581 I1=n4572 I2=n2172
XU4478 ND2 $PINS O=n6518 I1=n4583 I2=n4582
XU4479 OAI12HS $PINS O=n4582 A1=n2173 B1=n2175 B2=n2174
XU4480 OAI12HS $PINS O=n2173 A1=n4572 B1=n4573 B2=n4574
XU4481 XNR2HS $PINS O=n3049 I1=n6975 I2=n6974
XU4482 ND3HT $PINS O=n6842 I1=n3615 I2=n3619 I3=n9663
XU4483 NR2P $PINS O=n9246 I1=n4114 I2=n4115
XU4485 XNR2HP $PINS O=n6302 I1=n6296 I2=n2199
XU4486 XNR2H $PINS O=n4041 I1=n2555 I2=n2423
XU4487 XNR2HS $PINS O=n5471 I1=n2584 I2=n2583
XU4488 OAI22H $PINS O=n6291 A1=n6272 A2=FE_OFN1617_n6138 B1=FE_OFN1657_n6322
+ B2=n6284
XU4490 XNR2HS $PINS O=n6242 I1=weight_1_r[19] I2=data_1_r[38]
XU4491 XNR2HS $PINS O=n2302 I1=n2303 I2=n3983
XU4492 OAI12HS $PINS O=n3228 A1=n3481 B1=n6343 B2=n6344
XU4494 NR2P $PINS O=n6805 I1=n6029 I2=n6030
XU4495 INV1S $PINS O=n4314 I=n4313
XU4497 ND2P $PINS O=n3090 I1=n9796 I2=n9795
XU4498 ND2P $PINS O=n9775 I1=n6990 I2=n2638
XU4499 INV1S $PINS O=n3979 I=n3977
XU4500 INV1S $PINS O=n4008 I=n4019
XU4502 MOAI1 $PINS O=n2558 A1=n2760 A2=n2559 B1=n4024 B2=n2614
XU4503 MOAI1 $PINS O=n5881 A1=n2178 A2=n2177 B1=n5830 B2=n5831
XU4504 NR2 $PINS O=n2177 I1=n5831 I2=n5830
XU4505 XNR2HS $PINS O=n2179 I1=n5830 I2=n5831
XU4506 XNR2HS $PINS O=n5931 I1=n5941 I2=n5942
XU4510 XNR2HS $PINS O=n5650 I1=FE_OFN1533_n6702 I2=data_0_r[3]
XU4511 XNR2HS $PINS O=n4271 I1=n4299 I2=n2181
XU4513 XNR2HS $PINS O=n4265 I1=n4261 I2=n4260
XU4515 OAI22S $PINS O=n4334 A1=n4308 A2=FE_OFN1601_n4195 B1=FE_OFN1702_n6822
+ B2=n4333
XU4518 ND2P $PINS O=n2184 I1=n3166 I2=n3427
XU4519 NR2 $PINS O=n6391 I1=n5808 I2=n5809
XU4520 XNR2HS $PINS O=n5809 I1=n5799 I2=n3751
XU4521 NR2P $PINS O=n2351 I1=n6767 I2=n6768
XU4522 XNR2HS $PINS O=n6361 I1=n3481 I2=n3480
XU4523 MOAI1 $PINS O=n3710 A1=n5646 A2=FE_OFN1580_FE_DBTN8_n9443 B1=n5645
+ B2=FE_DBTN20_n2908
XU4524 MOAI1 $PINS O=n5552 A1=n9696 A2=n5541 B1=n2791 B2=n5554
XU4525 INV1S $PINS O=n2508 I=n5794
XU4526 MAO222 $PINS O=n7216 A1=n7206 B1=n7207 C1=n2187
XU4527 NR2 $PINS O=n2187 I1=n6671 I2=n6669
XU4528 MOAI1H $PINS O=n7087 A1=n2188 A2=n2416 B1=n7081 B2=n7082
XU4529 NR2 $PINS O=n2188 I1=n7082 I2=n7081
XU4530 NR2 $PINS O=n4234 I1=n3161 I2=n2189
XU4532 XNR2HS $PINS O=n7236 I1=n7215 I2=n2316
XU4533 XNR2HS $PINS O=n6744 I1=FE_OFN1290_weight_0_r_5 I2=data_0_r[6]
XU4535 ND2 $PINS O=n7131 I1=n7129 I2=n9740
XU4536 MOAI1S $PINS O=n4331 A1=n4184 A2=FE_OFN1463_n4128 B1=n4182
+ B2=FE_OFN1463_n4128
XU4537 ND2 $PINS O=n4182 I1=n3475 I2=weight_2_r[18]
XU4538 MOAI1 $PINS O=n6712 A1=n6704 A2=n6705 B1=n6713 B2=n9443
XU4539 ND3HT $PINS O=n6650 I1=n6842 I2=n3222 I3=n6644
XU4540 ND2P $PINS O=n3799 I1=n2190 I2=n3798
XU4541 ND3P $PINS O=n2190 I1=n3067 I2=n2867 I3=n8968
XU4542 OAI22S $PINS O=n3423 A1=n6715 A2=FE_OFN1641_n9465 B1=n9466 B2=n6706
XU4543 XNR2HS $PINS O=n7232 I1=n1986 I2=n2191
XU4544 XNR2HS $PINS O=n2191 I1=n7227 I2=n7226
XU4545 NR2 $PINS O=n9526 I1=n7234 I2=n7233
XU4546 MAO222 $PINS O=n7233 A1=n1986 B1=n7227 C1=n7226
XU4550 AOI22S $PINS O=n6753 A1=n6665 A2=FE_OFN1300_weight_0_r_0 B1=n5663
+ B2=n6673
XU4551 OAI22S $PINS O=n5551 A1=n5542 A2=n7070 B1=FE_OFN1677_n7036 B2=n5548
XU4552 MOAI1 $PINS O=n4555 A1=n8996 A2=n4472 B1=n4503 B2=n4471
XU4553 INV1S $PINS O=n4502 I=n4500
XU4555 INV1S $PINS O=n7174 I=data_0_r[3]
XU4556 INV1S $PINS O=n6552 I=n6551
XU4557 FA1S $PINS S=n9731 CO=n9732 A=n9723 B=n9722 CI=n9721
XU4559 MOAI1 $PINS O=n4352 A1=n2194 A2=n2193 B1=n4303 B2=n4304
XU4560 XNR2HS $PINS O=n2196 I1=n4304 I2=n4303
XU4562 XNR2HS $PINS O=n4255 I1=data_2_r[38] I2=weight_2_r[23]
XU4563 INV2 $PINS O=n3754 I=n3758
XU4564 INV1S $PINS O=n7243 I=n5926
XU4566 ND3HT $PINS O=n2198 I1=n3549 I2=n3550 I3=n8833
XU4567 OAI12HS $PINS O=n3263 A1=n3264 B1=FE_OFN1480_n4623 B2=n4621
XU4568 NR2T $PINS O=n4039 I1=n9300 I2=n9298
XU4569 ND3HT $PINS O=n3347 I1=n3348 I2=n6788 I3=n3478
XU4570 NR2P $PINS O=n3348 I1=n9080 I2=n6798
XU4571 XNR2HS $PINS O=n2420 I1=n6015 I2=n2421
XU4572 MOAI1 $PINS O=n6015 A1=FE_OFN1436_FE_DBTN18_n6407 A2=n6016 B1=n2863
+ B2=n6007
XU4573 XNR2H $PINS O=n2199 I1=n6297 I2=n2737
XU4574 OAI12HS $PINS O=n3327 A1=n3328 B1=FE_OFN1479_n4623 B2=n4543
XU4577 OAI22H $PINS O=n6268 A1=n6253 A2=FE_OCPN9729_n6138 B1=FE_OFN1657_n6322
+ B2=n6263
XU4578 XOR2HS $PINS O=n4007 I1=FE_OFN1326_weight_1_r_13 I2=data_1_r[23]
XU4579 MOAI1 $PINS O=n5964 A1=n5980 A2=FE_OFN1440_FE_DBTN12_weight_2_r_7
+ B1=n2480 B2=n5961
XU4580 XOR2HS $PINS O=n6601 I1=n6607 I2=n3332
XU4581 ND2 $PINS O=n2430 I1=n2431 I2=n2721
XU4584 XNR2HS $PINS O=n2200 I1=n2204 I2=n6629
XU4585 OAI12HS $PINS O=n6638 A1=n2201 B1=n2203 B2=n2202
XU4586 MOAI1 $PINS O=n2204 A1=n6620 A2=FE_OFN1543_n7067
+ B1=FE_OFN1570_FE_DBTN22_n3850 B2=n6619
XU4587 ND3P $PINS O=n3267 I1=n6804 I2=n2538 I3=n3269
XU4588 NR2P $PINS O=n2538 I1=n6805 I2=n6803
XU4589 XOR2HS $PINS O=n2205 I1=n6250 I2=n6249
XU4590 OAI12HS $PINS O=n2206 A1=n6248 B1=n6249 B2=n6250
XU4591 INV1S $PINS O=n2208 I=n6250
XU4594 MOAI1 $PINS O=n6681 A1=n5647 A2=FE_OFN1580_FE_DBTN8_n9443
+ B1=FE_DBTN20_n2908 B2=FE_OFN1291_weight_0_r_5
XU4595 ND2 $PINS O=n9544 I1=n9539 I2=n9538
XU4597 XNR2HS $PINS O=n5667 I1=n5671 I2=n5670
XU4598 AOI22S $PINS O=n5671 A1=weight_0_r[0] A2=n5655 B1=n5661
+ B2=FE_OFN1523_n5640
XU4599 OAI22S $PINS O=n5743 A1=FE_OFN1562_FE_DBTN37_n5853 A2=n5746 B1=n2537
+ B2=n2622
XU4600 XNR2HS $PINS O=n5746 I1=FE_OFN1348_weight_1_r_3 I2=data_1_r[6]
XU4602 NR2F $PINS O=n9368 I1=n6366 I2=n6367
XU4603 NR2P $PINS O=n3091 I1=n7095 I2=n7094
XU4604 INV1S $PINS O=n2230 I=n5942
XU4605 INV1S $PINS O=n6237 I=n6236
XU4607 OAI22S $PINS O=n5766 A1=n5764 A2=FE_OFN1611_n5691 B1=n5763
+ B2=FE_DBTN10_n9120
XU4608 XOR2HS $PINS O=n5483 I1=weight_1_r[17] I2=data_1_r[34]
XU4609 NR2P $PINS O=n2656 I1=n4609 I2=n4608
XU4610 XNR2HS $PINS O=n6037 I1=n6043 I2=n2212
XU4611 XNR2HS $PINS O=n2212 I1=n2215 I2=n6044
XU4612 ND2 $PINS O=n6110 I1=n2214 I2=n2213
XU4613 ND2 $PINS O=n2213 I1=n6044 I2=n2215
XU4614 OAI12HS $PINS O=n2214 A1=n6043 B1=n6044 B2=n2215
XU4615 OAI12HS $PINS O=n2215 A1=n2216 B1=FE_OFN1436_FE_DBTN18_n6407 B2=n6045
XU4616 ND2 $PINS O=n2216 I1=n6017 I2=n1874
XU4617 XNR2HS $PINS O=n6660 I1=data_0_r[9] I2=FE_OFN1288_weight_0_r_5
XU4619 XOR2HS $PINS O=n6219 I1=FE_OFN1313_weight_1_r_17 I2=data_1_r[39]
XU4620 MOAI1S $PINS O=n4513 A1=n8996 A2=n4485 B1=FE_OFN1666_n4591 B2=n4488
XU4621 OAI22S $PINS O=n4635 A1=n4624 A2=FE_OFN1480_n4623 B1=FE_OFN1608_n4622
+ B2=n4621
XU4622 XOR2HS $PINS O=n4471 I1=FE_OFN1394_weight_2_r_9 I2=data_2_r[22]
XU4623 NR2 $PINS O=n2711 I1=n6096 I2=n6092
XU4625 INV1S $PINS O=n6241 I=n6256
XU4626 OAI22S $PINS O=n4251 A1=FE_OFN1588_n2932 A2=n4244 B1=FE_DBTN41_n4329
+ B2=n4253
XU4627 XOR2HS $PINS O=n2896 I1=n6255 I2=n6254
XU4628 MOAI1 $PINS O=n6254 A1=FE_OFN1590_n3135 A2=n6242 B1=n2283
+ B2=FE_DBTN48_n1875
XU4629 OAI12HS $PINS O=n3845 A1=n5700 B1=n2703 B2=n5701
XU4630 XOR2HS $PINS O=n4523 I1=data_2_r[24] I2=FE_OFN1661_weight_2_r_9
XU4632 NR2 $PINS O=n3379 I1=weight_2_r[2] I2=weight_2_r[1]
XU4633 NR2 $PINS O=n8983 I1=n4509 I2=n4508
XU4634 OA12 $PINS O=n4506 A1=n4496 B1=n4623 B2=n4443
XU4635 INV1S $PINS O=n9284 I=n9283
XU4636 INV1S $PINS O=n5712 I=n5711
XU4637 INV1S $PINS O=n3708 I=n6680
XU4638 MAO222 $PINS O=n7196 A1=n2220 B1=n7219 C1=n7218
XU4639 OAI22S $PINS O=n2220 A1=FE_OFN1630_n6658 A2=n7182 B1=n9435 B2=n7181
XU4641 XOR2HS $PINS O=n6684 I1=FE_OFN1291_weight_0_r_5 I2=data_0_r[2]
XU4642 XNR2HS $PINS O=n3645 I1=n3649 I2=n6264
XU4643 OAI12HP $PINS O=n6264 A1=n2221 B1=FE_OFN1567_FE_DBTN31_n6225 B2=n6265
XU4644 XNR2HS $PINS O=n3056 I1=n6681 I2=n3710
XU4645 OR2T $PINS O=n3145 I1=n9769 I2=n9772
XU4646 MOAI1H $PINS O=n3445 A1=FE_OFN1603_n4331 A2=n4176 B1=n4329 B2=n4175
XU4647 INV1S $PINS O=n2222 I=n4186
XU4648 NR2 $PINS O=n3169 I1=n6473 I2=n6472
XU4649 ND2P $PINS O=n2629 I1=n3432 I2=n2446
XU4650 NR2P $PINS O=n2446 I1=n2632 I2=n2631
XU4651 ND2P $PINS O=n3593 I1=n8860 I2=n2064
XU4652 NR2 $PINS O=n8860 I1=n3595 I2=n3594
XU4654 XNR2HS $PINS O=n4192 I1=n3767 I2=n4206
XU4655 OAI12HP $PINS O=n9399 A1=n9402 B1=n3658 B2=n9404
XU4657 ND2 $PINS O=n4557 I1=n3778 I2=n3777
XU4658 NR2 $PINS O=n2567 I1=n4463 I2=n4464
XU4659 NR2P $PINS O=n5674 I1=FE_OFN1241_n7179 I2=FE_OFN1580_FE_DBTN8_n9443
XU4660 ND2P $PINS O=n2625 I1=n8865 I2=n8864
XU4661 INV2 $PINS O=n9529 I=n3747
XU4662 INV1S $PINS O=n6892 I=n6919
XU4663 FA1 $PINS S=n5549 CO=n6571 A=n6560 B=n6559 CI=n6558
XU4664 INV2 $PINS O=n2732 I=n2733
XU4665 XOR2HS $PINS O=n2740 I1=n4023 I2=n4022
XU4667 INV1S $PINS O=n5772 I=n5781
XU4668 ND2P $PINS O=n3555 I1=n3556 I2=n9163
XU4670 INV3 $PINS O=n4086 I=FE_OFN1333_weight_1_r_9
XU4671 INV2 $PINS O=n6259 I=n6258
XU4672 INV1S $PINS O=n6911 I=n6942
XU4673 INV1S $PINS O=n3609 I=n3610
XU4675 INV1S $PINS O=n6290 I=n6289
XU4678 MOAI1S $PINS O=n3939 A1=n3930 A2=n3929 B1=n9216 B2=n3940
XU4679 MOAI1 $PINS O=n2310 A1=n6138 A2=FE_OFN1302_weight_1_r_23
+ B1=FE_DBTN3_n6322 B2=n6228
XU4680 XNR2HS $PINS O=n3982 I1=n3981 I2=n3980
XU4681 MOAI1H $PINS O=n3980 A1=FE_OFN1671_n4077 A2=n3949 B1=FE_OFN1451_n2589
+ B2=n2058
XU4682 ND2 $PINS O=n9582 I1=n5665 I2=n5664
XU4684 INV1S $PINS O=n5520 I=n5517
XU4685 MOAI1S $PINS O=n6826 A1=n4145 A2=FE_OFN1576_FE_DBTN17_n6819
+ B1=FE_OFN1654_n3599 B2=n4144
XU4686 INV1S $PINS O=n9521 I=n9486
XU4687 ND3P $PINS O=n3638 I1=n3639 I2=n3640 I3=n3642
XU4688 OAI12H $PINS O=n8971 A1=n8976 B1=n8979 B2=n8978
XU4689 INV1S $PINS O=n4246 I=n4245
XU4690 OAI22S $PINS O=n4245 A1=n4230 A2=n4195 B1=FE_OFN1536_n6822 B2=n4237
XU4691 ND3HT $PINS O=n2630 I1=n3221 I2=n3432 I3=n3250
XU4692 ND2P $PINS O=n3221 I1=n2628 I2=n2627
XU4693 MOAI1H $PINS O=n3165 A1=n4172 A2=FE_OFN1577_FE_DBTN17_n6819 B1=n4171
+ B2=FE_OFN1592_n3599
XU4694 XNR2HS $PINS O=n2276 I1=n4180 I2=n3165
XU4695 MOAI1H $PINS O=n6602 A1=n3315 A2=n3314 B1=n3448 B2=n6591
XU4696 AOI22S $PINS O=n5638 A1=n5620 A2=weight_1_r[0] B1=FE_OFN1520_n5608
+ B2=n5626
XU4698 NR2P $PINS O=n6780 I1=n2664 I2=n2673
XU4699 ND2 $PINS O=n3729 I1=n4187 I2=FE_OFN1592_n3599
XU4700 NR2P $PINS O=n6872 I1=n9351 I2=n9352
XU4701 INV1S $PINS O=n5598 I=n5596
XU4702 INV1S $PINS O=n5604 I=n5601
XU4703 INV1S $PINS O=n3890 I=n3902
XU4704 INV1S $PINS O=n3152 I=n4235
XU4705 MOAI1H $PINS O=n4326 A1=n4320 A2=FE_OFN1576_FE_DBTN17_n6819
+ B1=FE_OFN1593_n3599 B2=n4311
XU4707 MOAI1 $PINS O=n5474 A1=FE_OFN1316_weight_1_r_16 A2=n5462
+ B1=FE_DBTN9_n3607 B2=n5475
XU4708 XOR2HS $PINS O=n5479 I1=n5473 I2=n2483
XU4709 NR2T $PINS O=n9362 I1=n6372 I2=n9371
XU4710 XNR2HS $PINS O=n6369 I1=n6358 I2=n2226
XU4711 ND2 $PINS O=n2227 I1=n6359 I2=n6360
XU4714 AOI22S $PINS O=n6293 A1=n6281 A2=FE_DBTN2_weight_1_r_16
+ B1=FE_OFN1442_FE_DBTN9_n3607 B2=n6271
XU4715 ND2 $PINS O=n6813 I1=n4355 I2=n4354
XU4716 NR2T $PINS O=n3222 I1=n6841 I2=n6846
XU4717 OR2 $PINS O=n3303 I1=n6691 I2=n6692
XU4719 INV1S $PINS O=n4433 I=n4566
XU4720 MOAI1 $PINS O=n5899 A1=n5502 A2=n1873 B1=FE_DBTN25_n6937 B2=n5501
XU4721 ND3HT $PINS O=n2843 I1=n2233 I2=n2663 I3=n2662
XU4722 ND2P $PINS O=n2233 I1=n3568 I2=n3567
XU4723 XOR2HS $PINS O=n5554 I1=weight_0_r[9] I2=data_0_r[20]
XU4724 ND2 $PINS O=n9624 I1=n7094 I2=n7095
XU4725 INV1S $PINS O=n3913 I=n3922
XU4726 INV1S $PINS O=n2435 I=n3177
XU4727 ND3 $PINS O=n2234 I1=FE_OCPN9760_n6309 I2=n6373 I3=n9362
XU4729 OAI12HS $PINS O=n6378 A1=n2236 B1=n2238 B2=n2237
XU4730 OAI12HS $PINS O=n2236 A1=n6328 B1=n6329 B2=n6330
XU4732 XOR2HS $PINS O=n5762 I1=data_1_r[12] I2=FE_OFN1355_weight_1_r_1
XU4733 OAI22H $PINS O=n9468 A1=n7175 A2=FE_OFN1631_n6658 B1=n9459 B2=n9435
XU4734 OA12P $PINS O=n3311 A1=n9369 B1=n9368 B2=n9375
XU4735 NR2 $PINS O=n4324 I1=n4315 I2=n4314
XU4737 NR2 $PINS O=n3371 I1=n4265 I2=n4264
XU4738 MAO222 $PINS O=n4264 A1=n4250 B1=n3132 C1=n4251
XU4739 XNR2HS $PINS O=n5890 I1=n5900 I2=n5899
XU4740 ND2S $PINS O=n9276 I1=n9275 I2=n2467
XU4741 OR2P $PINS O=n3032 I1=n2855 I2=n7097
XU4742 XNR2HS $PINS O=n2240 I1=n6907 I2=n6906
XU4743 ND2 $PINS O=n6926 I1=n2242 I2=n2241
XU4744 ND2 $PINS O=n2241 I1=n6906 I2=n6907
XU4745 OAI12HS $PINS O=n2242 A1=n6905 B1=n6907 B2=n6906
XU4746 OR2T $PINS O=n9371 I1=n9384 I2=n2477
XU4747 INV2 $PINS O=n5494 I=FE_OFN1256_weight_0_r_19
XU4748 ND2 $PINS O=n7283 I1=n4117 I2=n2549
XU4750 INV1S $PINS O=n7066 I=n7063
XU4751 INV1S $PINS O=n7173 I=n7176
XU4752 XNR2HS $PINS O=n7076 I1=n2416 I2=n2454
XU4753 MAO222 $PINS O=n6974 A1=n6962 B1=n6963 C1=n6961
XU4754 OAI12HS $PINS O=n3238 A1=n6970 B1=n6971 B2=n6972
XU4755 XNR2HS $PINS O=n6970 I1=n6962 I2=n2245
XU4756 AOI12H $PINS O=n2296 A1=n2297 B1=n3449 B2=n7117
XU4757 NR2P $PINS O=n3269 I1=n8849 I2=n6809
XU4758 OAI22S $PINS O=n6009 A1=n5990 A2=n5980 B1=n6414 B2=n6006
XU4759 XNR2HS $PINS O=n6036 I1=n2286 I2=n6037
XU4760 MOAI1 $PINS O=n4089 A1=FE_OFN1638_n9221 A2=n4058
+ B1=FE_OFN1558_FE_DBTN42_n3886 B2=n4057
XU4761 MOAI1 $PINS O=n6465 A1=FE_OFN1586_n1873 A2=n6456
+ B1=FE_OFN1569_FE_DBTN25_n6937 B2=n6469
XU4763 ND2T $PINS O=n3233 I1=n5895 I2=FE_OFN1516_n5494
XU4764 INV1S $PINS O=n3887 I=n4058
XU4765 XNR2HS $PINS O=n4110 I1=n3673 I2=n3674
XU4766 AOI22S $PINS O=n6933 A1=n6918 A2=FE_OFN1266_weight_0_r_16
+ B1=FE_OFN1696_n5491 B2=n6917
XU4767 XNR2HS $PINS O=n6113 I1=n6118 I2=n2247
XU4768 XNR2HS $PINS O=n2247 I1=n2248 I2=n6119
XU4769 OR2 $PINS O=n2321 I1=n8841 I2=n6112
XU4771 OAI12HS $PINS O=n9238 A1=n3666 B1=n9234 B2=n3667
XU4772 MOAI1S $PINS O=n3983 A1=n9221 A2=n3584 B1=FE_OFN1325_weight_1_r_13
+ B2=FE_OFN1556_FE_DBTN42_n3886
XU4774 INV1S $PINS O=n9801 I=n2543
XU4775 AO22 $PINS O=n3172 A1=n9476 A2=n2337 B1=n9477 B2=n3721
XU4776 ND2P $PINS O=n2251 I1=n3411 I2=n3449
XU4778 ND2 $PINS O=n7274 I1=n5885 I2=n5884
XU4779 FA1 $PINS S=n6083 CO=n6430 A=n6079 B=n6078 CI=n6077
XU4780 FA1 $PINS S=n4117 CO=n4114 A=n4110 B=n4109 CI=n4108
XU4781 INV1S $PINS O=n3997 I=n3996
XU4782 INV2 $PINS O=n7285 I=n2748
XU4783 NR2F $PINS O=n6301 I1=n9392 I2=n9389
XU4784 NR2F $PINS O=n9389 I1=n6305 I2=n6304
XU4786 MOAI1H $PINS O=n6286 A1=FE_OFN1681_n3135 A2=n6276 B1=FE_DBTN27_n6338
+ B2=n6289
XU4787 OAI22H $PINS O=n4096 A1=n4055 A2=FE_OFN1597_n3897
+ B1=FE_OFN1572_FE_DBTN21_n3428 B2=n4066
XU4788 MOAI1 $PINS O=n4632 A1=FE_OFN9749_n A2=n8996 B1=FE_OFN1476_n4591
+ B2=n4412
XU4789 AOI12HP $PINS O=n8929 A1=n2617 B1=n2616 B2=n6057
XU4790 OAI12HS $PINS O=n6348 A1=n2676 B1=n2680 B2=n2677
XU4791 XNR2HS $PINS O=n4034 I1=n4028 I2=n2726
XU4792 INV1S $PINS O=n4396 I=n4395
XU4794 NR2T $PINS O=n9298 I1=n4042 I2=n4043
XU4795 NR2 $PINS O=n2252 I1=n9510 I2=n9509
XU4796 OR2T $PINS O=n6057 I1=n4660 I2=n4661
XU4797 NR2P $PINS O=n4528 I1=n4531 I2=FE_OCPN9716_weight_2_r_13
XU4798 OAI22S $PINS O=n5965 A1=n5960 A2=FE_DBTN39_n3378 B1=n6103 B2=n5968
XU4799 XNR2HS $PINS O=n2320 I1=n5964 I2=n5965
XU4800 XNR2HS $PINS O=n6295 I1=n6277 I2=n6279
XU4801 XNR2HS $PINS O=n4014 I1=FE_OFN1321_weight_1_r_15 I2=n3927
XU4802 ND2P $PINS O=n9469 I1=FE_OFN1286_weight_0_r_7 I2=data_0_r[2]
XU4803 ND2 $PINS O=n9504 I1=n9489 I2=n9488
XU4804 INV1S $PINS O=n2337 I=n3720
XU4806 OAI12H $PINS O=n6138 A1=n2253 B1=n2255 B2=FE_OFN1303_weight_1_r_23
XU4807 ND2 $PINS O=n2253 I1=n2254 I2=FE_OFN1303_weight_1_r_23
XU4808 ND2 $PINS O=n2254 I1=FE_OFN1309_weight_1_r_21 I2=weight_1_r[22]
XU4809 NR2 $PINS O=n2255 I1=weight_1_r[22] I2=FE_OFN1309_weight_1_r_21
XU4810 XNR2H $PINS O=n6371 I1=n6362 I2=n2256
XU4811 MOAI1H $PINS O=n6364 A1=n2258 A2=n2257 B1=n6362 B2=n6363
XU4812 XNR2HS $PINS O=n6253 I1=weight_1_r[23] I2=data_1_r[35]
XU4813 INV2 $PINS O=n2478 I=n9382
XU4814 MAO222 $PINS O=n6249 A1=n2310 B1=n6239 C1=n6238
XU4816 XNR2HS $PINS O=n5841 I1=FE_OFN1350_weight_1_r_3 I2=data_1_r[12]
XU4817 ND3 $PINS O=n4362 I1=n9078 I2=n4356 I3=n9059
XU4818 ND3HT $PINS O=n9078 I1=n3347 I2=n3346 I3=n3343
XU4819 ND3 $PINS O=n5928 I1=n9078 I2=n7243 I3=n9059
XU4820 XOR2HS $PINS O=n4263 I1=n1977 I2=n3486
XU4821 XOR2HS $PINS O=pConv_0/product_0_w[17] I1=n2261 I2=n7238
XU4822 ND2 $PINS O=n2261 I1=n9523 I2=n9521
XU4823 XOR2HS $PINS O=n2752 I1=n9055 I2=n9053
XU4824 MOAI1H $PINS O=n6720 A1=n1981 A2=n3680 B1=n3679 B2=n6700
XU4825 ND3 $PINS O=n3681 I1=n3602 I2=n3603 I3=n3604
XU4829 MOAI1S $PINS O=n9460 A1=FE_OFN1287_weight_0_r_5
+ A2=FE_OFN1579_FE_DBTN8_n9443 B1=FE_OFN1573_FE_DBTN20_n2908 B2=n9462
XU4830 XOR2HS $PINS O=n9479 I1=n3291 I2=n9460
XU4831 OAI112HS $PINS O=n9373 A1=n9372 B1=n9375 C1=n3484 C2=n9377
XU4832 ND2 $PINS O=n9388 I1=n9385 I2=n9386
XU4833 XOR2HS $PINS O=n2727 I1=weight_0_r[14] I2=FE_DBTN33_weight_0_r_13
XU4835 OAI22S $PINS O=n5473 A1=n5463 A2=FE_OFN1679_n3135 B1=n5470 B2=n1875
XU4836 ND2 $PINS O=n2679 I1=FE_OFN9124_n3656 I2=n6275
XU4837 ND2P $PINS O=n9416 I1=n5479 I2=n2458
XU4840 XNR2HS $PINS O=n6977 I1=n6973 I2=n3049
XU4841 ND2 $PINS O=n3227 I1=n6343 I2=n6344
XU4842 ND2 $PINS O=n9161 I1=n5806 I2=n5807
XU4843 NR2 $PINS O=n5818 I1=n5767 I2=n5765
XU4844 INV1S $PINS O=n6314 I=n6313
XU4845 MOAI1 $PINS O=n6098 A1=FE_OFN1436_FE_DBTN18_n6407 A2=n6047 B1=n1874
+ B2=n6046
XU4846 OAI22S $PINS O=n6408 A1=n6413 A2=FE_OFN1662_n5980 B1=FE_OFN1619_n6414
+ B2=n6403
XU4847 XOR2HS $PINS O=n6281 I1=FE_OFN1313_weight_1_r_17 I2=data_1_r[44]
XU4848 ND2 $PINS O=n8826 I1=n6440 I2=n6439
XU4850 OAI12HS $PINS O=n2695 A1=n6097 B1=n2697 B2=n6098
XU4851 MOAI1 $PINS O=n2697 A1=FE_OFN1129_FE_DBTN39_n3378 A2=n6050
+ B1=FE_OFN1529_n6086 B2=n2698
XU4852 ND3P $PINS O=n3206 I1=n3258 I2=n3676 I3=n8834
XU4855 MAO222 $PINS O=n5945 A1=n5931 B1=n5932 C1=n2274
XU4856 INV2 $PINS O=n3422 I=n6712
XU4857 INV1S $PINS O=n5823 I=n5822
XU4858 FA1 $PINS S=n9452 CO=n9441 A=n2067 B=n9445 CI=n9444
XU4859 INV4 $PINS O=n3404 I=n3582
XU4861 XOR2HS $PINS O=n4228 I1=n4234 I2=n3472
XU4862 NR2P $PINS O=n6395 I1=n5804 I2=n5805
XU4863 MOAI1 $PINS O=n5804 A1=n2701 A2=n2702 B1=n5802 B2=n5803
XU4864 MOAI1 $PINS O=n3457 A1=FE_OFN1618_n6138 A2=n6164 B1=FE_OFN1656_n6322
+ B2=n3458
XU4865 XOR2HS $PINS O=n2604 I1=n6205 I2=n6203
XU4866 ND2 $PINS O=n9360 I1=n6381 I2=n6380
XU4867 NR2 $PINS O=n2706 I1=n3431 I2=n3430
XU4868 INV1S $PINS O=n4278 I=n4277
XU4869 MAO222 $PINS O=n4303 A1=n4290 B1=n4289 C1=n3468
XU4871 MOAI1 $PINS O=n4178 A1=n2269 A2=n2268 B1=n4169 B2=n4170
XU4872 NR2 $PINS O=n2268 I1=n4170 I2=n4169
XU4873 ND2 $PINS O=n3526 I1=n9730 I2=n9731
XU4874 INV1S $PINS O=n3325 I=n4571
XU4875 INV1S $PINS O=n4531 I=weight_2_r[12]
XU4876 INV1S $PINS O=n2562 I=n5841
XU4877 XNR2HS $PINS O=n5977 I1=n2356 I2=n2545
XU4879 XNR2HS $PINS O=n6992 I1=n6981 I2=n2271
XU4880 XNR2HS $PINS O=n2290 I1=n6095 I2=n6094
XU4881 OAI22S $PINS O=n7148 A1=n7140 A2=FE_OFN1612_n5691
+ B1=FE_OFN1578_FE_DBTN10_n9120 B2=n7137
XU4882 NR2 $PINS O=n3315 I1=n6591 I2=n3448
XU4883 INV1S $PINS O=n6179 I=n6181
XU4884 MAO222 $PINS O=n2326 A1=n6754 B1=n6755 C1=n3218
XU4885 INV2 $PINS O=n5590 I=n5606
XU4886 INV1S $PINS O=n6450 I=n6455
XU4887 INV1S $PINS O=n6468 I=n6505
XU4889 INV1S $PINS O=n3312 I=n3313
XU4890 FA1 $PINS S=n6133 CO=n6128 A=n6127 B=n6126 CI=n6125
XU4891 XNR2HS $PINS O=n5581 I1=n5931 I2=n2273
XU4892 XNR2HS $PINS O=n2273 I1=n2274 I2=n5932
XU4893 MOAI1 $PINS O=n2274 A1=n5576 A2=n5575 B1=FE_OCPN9772_n6407 B2=n5935
XU4894 NR2 $PINS O=n5939 I1=n6071 I2=n5937
XU4895 NR2P $PINS O=n9311 I1=n2609 I2=n4038
XU4896 AOI22S $PINS O=n7213 A1=n7189 A2=FE_OFN1300_weight_0_r_0 B1=n5663
+ B2=n6666
XU4897 MOAI1S $PINS O=n5974 A1=n2396 A2=n2395 B1=n5950 B2=n5949
XU4898 MOAI1S $PINS O=n6559 A1=FE_OFN1542_n7067 A2=n5545 B1=FE_DBTN22_n3850
+ B2=FE_OFN1272_weight_0_r_13
XU4899 OR2T $PINS O=n9609 I1=n9607 I2=n9616
XU4900 FA1 $PINS S=n9601 CO=n9598 A=n9597 B=n9596 CI=n9595
XU4901 ND2 $PINS O=n6529 I1=weight_0_r[14] I2=FE_OFN9748_weight_0_r_13
XU4903 XNR2H $PINS O=n3210 I1=n7049 I2=n3633
XU4904 OR2 $PINS O=n9117 I1=n9115 I2=n9116
XU4905 XNR2HS $PINS O=n4002 I1=FE_OFN1320_weight_1_r_15 I2=data_1_r[22]
XU4906 NR2P $PINS O=n6373 I1=n6382 I2=n9352
XU4907 NR2P $PINS O=n2724 I1=n6555 I2=n6554
XU4909 INV1S $PINS O=n2544 I=n5528
XU4910 INV2 $PINS O=n3884 I=n9647
XU4911 XNR2HS $PINS O=n4177 I1=n4179 I2=n2276
XU4912 ND3HT $PINS O=n3618 I1=n3874 I2=n9672 I3=n2360
XU4914 ND2S $PINS O=n7005 I1=FE_OFN1678_n7036 I2=FE_OFN1635_n7070
XU4916 OA12 $PINS O=n5601 A1=n5592 B1=n5573 B2=FE_DBTN39_n3378
XU4917 INV1S $PINS O=n4172 I=n4187
XU4918 INV1S $PINS O=n6657 I=n6672
XU4919 OAI22S $PINS O=n4631 A1=n4415 A2=FE_OFN1606_n4596 B1=n4414
+ B2=FE_OFN1644_FE_DBTN11_n3387
XU4920 NR2T $PINS O=n2683 I1=n4017 I2=n2645
XU4922 OAI12HS $PINS O=n6026 A1=n2685 B1=n2687 B2=n2686
XU4923 AOI22H $PINS O=n6478 A1=n6458 A2=FE_OFN1265_weight_0_r_16
+ B1=FE_OFN1698_n5491 B2=n6457
XU4924 XOR2HS $PINS O=n5996 I1=FE_OFN1405_weight_2_r_3 I2=data_2_r[8]
XU4925 XNR2HS $PINS O=n3308 I1=n4085 I2=n4084
XU4926 INV1S $PINS O=n6570 I=n2453
XU4928 NR2 $PINS O=n9424 I1=n2279 I2=n2278
XU4929 NR2 $PINS O=n2278 I1=n9430 I2=n9425
XU4930 XNR2H $PINS O=n6304 I1=n6347 I2=n3140
XU4931 MOAI1 $PINS O=n6932 A1=FE_OFN1620_n6448 A2=n6920 B1=n9697 B2=n6919
XU4932 XOR2HS $PINS O=n6235 I1=FE_OFN1313_weight_1_r_17 I2=data_1_r[40]
XU4934 MOAI1S $PINS O=n2475 A1=n5730 A2=n5731 B1=n5744 B2=n7135
XU4935 INV1S $PINS O=n4190 I=n4194
XU4936 MOAI1 $PINS O=n6599 A1=n2282 A2=n3863 B1=n3536 B2=n6594
XU4937 AOI22S $PINS O=n5785 A1=n5773 A2=FE_OFN1356_weight_1_r_0 B1=n5628
+ B2=n5739
XU4938 MOAI1S $PINS O=n5709 A1=n5708 A2=FE_OCPN9762_FE_OFN9133_weight_1_r_3
+ B1=n5707 B2=FE_OFN9133_weight_1_r_3
XU4939 XNR2HS $PINS O=n6265 I1=FE_OFN1308_weight_1_r_21 I2=data_1_r[38]
XU4940 NR2 $PINS O=n3906 I1=FE_OFN1359_data_1_r_19
+ I2=FE_OFN1431_FE_DBTN26_weight_1_r_15
XU4941 ND2 $PINS O=n6441 I1=n6080 I2=n3520
XU4942 NR2 $PINS O=n9337 I1=n3971 I2=n3970
XU4943 ND2P $PINS O=n9174 I1=n3831 I2=n3829
XU4944 ND2 $PINS O=n5952 I1=FE_OFN1401_weight_2_r_5 I2=weight_2_r[6]
XU4945 MOAI1 $PINS O=n5906 A1=n6890 A2=n5893 B1=FE_OFN1698_n5491 B2=n5892
XU4946 INV1S $PINS O=n6064 I=n6067
XU4947 INV1S $PINS O=n7175 I=n7178
XU4948 INV1S $PINS O=n3358 I=n4438
XU4950 XOR2HS $PINS O=pConv_1/product_0_w[14] I1=n9157 I2=n2707
XU4951 XNR2HS $PINS O=n6125 I1=n6093 I2=n2290
XU4952 OAI12HS $PINS O=n6082 A1=n2291 B1=n2293 B2=n2292
XU4953 OAI12HS $PINS O=n2291 A1=n6093 B1=n6095 B2=n6094
XU4954 INV1S $PINS O=n2293 I=n6095
XU4956 MOAI1S $PINS O=n4216 A1=n4204 A2=n4203 B1=n6819 B2=n4217
XU4957 ND2 $PINS O=n4126 I1=FE_OFN1367_weight_2_r_21 I2=weight_2_r[22]
XU4958 INV3 $PINS O=n5573 I=FE_OFN1404_weight_2_r_3
XU4959 ND2 $PINS O=n6442 I1=n6129 I2=n6128
XU4960 ND2 $PINS O=n3473 I1=n4152 I2=n4305
XU4962 NR2P $PINS O=n3057 I1=n5882 I2=n5883
XU4963 AOI22S $PINS O=n4315 A1=n4305 A2=FE_OFN1378_weight_2_r_16 B1=n4152
+ B2=n4285
XU4964 MOAI1 $PINS O=n4607 A1=FE_OFN1693_n4596 A2=n4455 B1=FE_OFN9140_n3387
+ B2=n4594
XU4965 XOR2HS $PINS O=n6089 I1=data_2_r[15] I2=n3716
XU4966 MAO222 $PINS O=n4629 A1=n4615 B1=n4616 C1=n2656
XU4968 NR2 $PINS O=n2451 I1=n6630 I2=n2452
XU4969 MOAI1 $PINS O=n6632 A1=n3871 A2=n2451 B1=n2452 B2=n6630
XU4971 ND2 $PINS O=n2484 I1=n2485 I2=n5473
XU4972 NR2P $PINS O=n2524 I1=n9158 I2=n9152
XU4973 ND2 $PINS O=n2639 I1=FE_OFN1314_weight_1_r_17 I2=weight_1_r[18]
XU4974 INV1S $PINS O=n5463 I=n5476
XU4975 OAI22S $PINS O=n6905 A1=n6892 A2=FE_OFN1620_n6448 B1=n6891
+ B2=FE_OFN1554_n9713
XU4977 XOR2HS $PINS O=n5951 I1=data_2_r[7] I2=FE_OFN1407_weight_2_r_1
XU4978 XOR2HS $PINS O=n2394 I1=n5950 I2=n5949
XU4979 ND3P $PINS O=n6839 I1=n9078 I2=n6834 I3=n9059
XU4981 INV2 $PINS O=n2616 I=n7126
XU4982 INV1S $PINS O=n5492 I=n5500
XU4983 XOR2HS $PINS O=n2305 I1=n6592 I2=n6593
XU4984 XOR2HS $PINS O=n2307 I1=n6589 I2=n3620
XU4985 NR2P $PINS O=n9080 I1=n4272 I2=n4271
XU4988 XNR2HS $PINS O=n6557 I1=n7057 I2=n2729
XU4989 NR2P $PINS O=n2657 I1=n4006 I2=n4004
XU4990 MAO222 $PINS O=n4103 A1=n4098 B1=n4099 C1=n2657
XU4991 NR2P $PINS O=n6545 I1=n6627 I2=n6541
XU4992 INV2 $PINS O=n3122 I=n3469
XU4993 XNR2HS $PINS O=n6245 I1=n2310 I2=n2309
XU4994 NR2P $PINS O=n3317 I1=n6260 I2=n6259
XU4995 OAI22HP $PINS O=n6258 A1=n6237 A2=FE_OCPN9729_n6138 B1=FE_OFN1657_n6322
+ B2=n6253
XU4996 INV1S $PINS O=n2438 I=n2439
XU4997 ND2P $PINS O=n9745 I1=n9755 I2=n9733
XU4999 NR2F $PINS O=n9392 I1=n6302 I2=n6303
XU5000 NR2 $PINS O=n5913 I1=n5914 I2=FE_OFN1253_weight_0_r_21
XU5001 AOI12HS $PINS O=n7240 A1=n9364 B1=FE_OFN1240_n6309 B2=n9362
XU5003 NR2F $PINS O=n2330 I1=n9368 I2=n3484
XU5004 XNR2HS $PINS O=n2312 I1=n2313 I2=n4450
XU5005 MAO222 $PINS O=n4452 A1=n4449 B1=n4450 C1=n2313
XU5006 OAI12HS $PINS O=n2313 A1=n2314 B1=n4430 B2=FE_OFN1443_FE_DBTN7_n4532
XU5007 ND2 $PINS O=n2314 I1=n4429 I2=FE_OFN1433_FE_DBTN19_n4371
XU5008 OAI12H $PINS O=n9181 A1=n9187 B1=n9191 B2=n9189
XU5010 NR2 $PINS O=n9470 I1=n7174 I2=FE_DBTN0_weight_0_r_7
XU5011 ND2T $PINS O=n3623 I1=n6987 I2=n3352
XU5012 OA12 $PINS O=n5637 A1=n5622 B1=n5623 B2=n2537
XU5013 XOR2HS $PINS O=pConv_0/product_2_w[17] I1=n7131 I2=n7130
XU5014 XNR2HS $PINS O=n2316 I1=n7217 I2=n7216
XU5015 ND2 $PINS O=n9533 I1=n7232 I2=n7231
XU5016 OAI12HS $PINS O=n7231 A1=n2317 B1=n2319 B2=n2318
XU5017 OAI12HS $PINS O=n2317 A1=n7215 B1=n7216 B2=n7217
XU5018 MOAI1 $PINS O=n5949 A1=FE_OFN1435_FE_DBTN18_n6407 A2=n5936 B1=n2863
+ B2=n5935
XU5019 XNR2HS $PINS O=n5971 I1=n3321 I2=n2320
XU5020 NR2P $PINS O=n2890 I1=n3738 I2=n3739
XU5021 OAI12HS $PINS O=n3812 A1=n5791 B1=n5792 B2=n5793
XU5023 OAI12HS $PINS O=n2323 A1=n6763 B1=n2326 B2=n6764
XU5024 INV1S $PINS O=n2325 I=n2326
XU5025 XNR2HS $PINS O=n2327 I1=n3938 I2=n3939
XU5026 MAO222 $PINS O=n4027 A1=n3939 B1=n3938 C1=n3937
XU5027 XOR2HS $PINS O=n3420 I1=n2614 I2=n4024
XU5030 MOAI1H $PINS O=n6340 A1=FE_OFN1618_n6138 A2=n6284 B1=FE_OFN1656_n6322
+ B2=n6320
XU5031 OAI12HS $PINS O=n3743 A1=n3744 B1=FE_OFN1436_FE_DBTN18_n6407 B2=n6059
XU5032 XNR2HS $PINS O=n6287 I1=FE_OFN1310_weight_1_r_21 I2=data_1_r[40]
XU5033 OR2 $PINS O=n9178 I1=n5619 I2=n5618
XU5035 NR2P $PINS O=n9300 I1=n4040 I2=n4041
XU5036 ND2 $PINS O=n3133 I1=n5547 I2=n7069
XU5037 INV1S $PINS O=n4009 I=n4007
XU5038 MOAI1 $PINS O=n7085 A1=n7030 A2=FE_OFN1544_n7067
+ B1=FE_OFN1570_FE_DBTN22_n3850 B2=n7063
XU5039 ND2 $PINS O=n2536 I1=n3635 I2=n3634
XU5041 OAI12H $PINS O=n3545 A1=n6801 B1=n7262 B2=n6803
XU5042 NR2P $PINS O=n3353 I1=n5754 I2=n5755
XU5043 XOR2HS $PINS O=n5755 I1=n5791 I2=n2332
XU5044 XNR2HS $PINS O=n3601 I1=n6701 I2=n3681
XU5045 INV3 $PINS O=n6372 I=n2330
XU5047 XOR2HS $PINS O=n5718 I1=n5734 I2=n5733
XU5048 NR2P $PINS O=n3481 I1=n6351 I2=n3229
XU5049 ND2P $PINS O=n2493 I1=n3228 I2=n3227
XU5050 ND2 $PINS O=n2431 I1=n2435 I2=n2432
XU5052 MOAI1S $PINS O=n5863 A1=n5854 A2=n2537 B1=FE_OFN1526_n5853 B2=n5852
XU5053 INV1S $PINS O=n4538 I=FE_OFN1380_weight_2_r_15
XU5054 ND2 $PINS O=n7241 I1=n9365 I2=n9363
XU5055 INV1S $PINS O=n5748 I=n5747
XU5057 INV1S $PINS O=n6693 I=n6692
XU5059 ND3P $PINS O=n3167 I1=n9744 I2=n9745 I3=n2331
XU5060 ND3HT $PINS O=n8829 I1=n3450 I2=n3451 I3=n3453
XU5061 ND2 $PINS O=n9751 I1=n9735 I2=n9734
XU5062 MAO222 $PINS O=n5860 A1=n3301 B1=n5837 C1=n5838
XU5063 ND3HT $PINS O=n6489 I1=n3541 I2=n9789 I3=n9791
XU5064 MOAI1 $PINS O=n2688 A1=FE_OFN1129_FE_DBTN39_n3378 A2=n5997 B1=n2689
+ B2=FE_OFN1529_n6086
XU5065 XNR2HS $PINS O=n3831 I1=n5750 I2=n2333
XU5069 AOI12HS $PINS O=n3397 A1=n3398 B1=n2890 B2=n6410
XU5070 XNR2HS $PINS O=n3394 I1=n3396 I2=n3397
XU5071 ND3 $PINS O=n8960 I1=n8958 I2=n8957 I3=n8959
XU5072 NR2 $PINS O=n3976 I1=FE_OFN1247_n9348 I2=n9221
XU5073 MOAI1S $PINS O=n6014 A1=FE_OFN1129_FE_DBTN39_n3378 A2=n6008
+ B1=FE_OFN1529_n6086 B2=n6018
XU5074 XOR2HS $PINS O=n3155 I1=n5955 I2=n3157
XU5075 NR2 $PINS O=n5699 I1=FE_DBTN32_weight_1_r_7 I2=n5728
XU5078 FA1 $PINS S=n9485 CO=n9480 A=n9473 B=n9472 CI=n9471
XU5079 NR2P $PINS O=n6352 I1=n6293 I2=n6292
XU5080 XNR2HS $PINS O=n5973 I1=n5969 I2=n5970
XU5081 INV1S $PINS O=n2497 I=n5864
XU5082 ND2P $PINS O=n9523 I1=n7200 I2=n7199
XU5083 XNR2HS $PINS O=n6596 I1=n3863 I2=n2341
XU5084 XOR2HS $PINS O=n2341 I1=n6594 I2=n3536
XU5086 OR2T $PINS O=n9789 I1=n6486 I2=n6487
XU5087 ND2 $PINS O=n3635 I1=n3636 I2=n7049
XU5088 MOAI1 $PINS O=n6199 A1=FE_OFN1680_n3135 A2=n6185 B1=FE_DBTN48_n1875
+ B2=n6184
XU5089 INV1S $PINS O=n5948 I=n5945
XU5090 INV1S $PINS O=n7020 I=n7035
XU5091 INV1S $PINS O=n9353 I=n9352
XU5092 OAI12H $PINS O=n2453 A1=n3133 B1=n5548 B2=n7070
XU5093 MAO222 $PINS O=n5504 A1=n5521 B1=n5522 C1=n5523
XU5095 XOR2HS $PINS O=n7192 I1=FE_OFN1298_weight_0_r_1 I2=data_0_r[15]
XU5096 OAI12HS $PINS O=n3666 A1=n3905 B1=n3906 B2=n3670
XU5097 NR2T $PINS O=n9766 I1=n2406 I2=n2405
XU5098 INV2 $PINS O=n2736 I=n2737
XU5100 NR2F $PINS O=n6515 I1=n6475 I2=n6474
XU5101 XNR2H $PINS O=n3251 I1=n6510 I2=n3524
XU5102 MAO222P $PINS O=n3524 A1=n3723 B1=n6465 C1=n3570
XU5103 AOI12HP $PINS O=n3755 A1=n9144 B1=n2835 B2=n9142
XU5104 ND3HT $PINS O=n2835 I1=n3554 I2=n3553 I3=n3555
XU5105 OR2T $PINS O=n3349 I1=n6454 I2=n6453
XU5106 XNR2HS $PINS O=n5503 I1=n2542 I2=n2541
XU5108 XNR2HS $PINS O=n6431 I1=n6427 I2=n2342
XU5109 XOR2HS $PINS O=n2342 I1=n6428 I2=n3087
XU5111 ND2P $PINS O=n9365 I1=n6378 I2=n6379
XU5112 MOAI1S $PINS O=n2462 A1=n5485 A2=n3607 B1=n5484 B2=weight_1_r[16]
XU5113 XNR2HS $PINS O=n5484 I1=n2343 I2=FE_OFN1314_weight_1_r_17
XU5114 OR2T $PINS O=n9635 I1=n7075 I2=n9645
XU5116 AOI13HS $PINS O=n5958 A1=FE_OFN1404_weight_2_r_3 B1=n5957 B2=n6063
+ B3=FE_OFN1401_weight_2_r_5
XU5117 INV1S $PINS O=n4375 I=n4385
XU5118 INV1S $PINS O=n4508 I=n4507
XU5119 INV1S $PINS O=n5493 I=n5507
XU5120 XOR2HS $PINS O=pConv_2/product_1_w[14] I1=n8946 I2=n2574
XU5121 ND2P $PINS O=n3658 I1=n6299 I2=n6298
XU5122 XOR2HS $PINS O=n5547 I1=data_0_r[20] I2=FE_OFN1274_weight_0_r_11
XU5123 INV1S $PINS O=n3651 I=n6209
XU5124 OAI12HT $PINS O=n9364 A1=n3311 B1=n9377 B2=n6372
XU5126 OAI12H $PINS O=n3882 A1=n9634 B1=n9633 B2=n2415
XU5127 MOAI1 $PINS O=n6198 A1=FE_OFN1618_n6138 A2=n6189 B1=FE_OFN1656_n6322
+ B2=n6186
XU5128 ND3P $PINS O=n9637 I1=n2345 I2=n2415 I3=n2344
XU5129 NR2P $PINS O=n3411 I1=n8832 I2=n6444
XU5130 ND3HT $PINS O=n3549 I1=FE_OFN1156_n2894 I2=n2659 I3=n3408
XU5133 AOI12H $PINS O=n8872 A1=n8876 B1=n8878 B2=n8874
XU5134 XNR2HS $PINS O=n6578 I1=FE_OFN1274_weight_0_r_11 I2=data_0_r[21]
XU5135 ND3HT $PINS O=n3806 I1=n3757 I2=n1923 I3=n3843
XU5136 NR2 $PINS O=n6628 I1=n6626 I2=n6625
XU5137 NR2P $PINS O=n2552 I1=n3497 I2=n2553
XU5139 NR2 $PINS O=n4170 I1=FE_DBTN30_data_2_r_33 I2=FE_OFN1577_FE_DBTN17_n6819
XU5141 FA1 $PINS S=n6432 CO=n6435 A=n6424 B=n6423 CI=n6422
XU5142 ND3HT $PINS O=n3450 I1=FE_OFN1156_n2894 I2=n3454 I3=n3408
XU5143 NR2 $PINS O=n3893 I1=weight_1_r[14] I2=FE_OCPN9768_weight_1_r_13
XU5144 INV2 $PINS O=n6775 I=n2350
XU5145 OAI12HS $PINS O=n2350 A1=n9545 B1=n9552 B2=n2351
XU5146 INV1S $PINS O=n9546 I=n2351
XU5147 NR2P $PINS O=n6773 I1=n6866 I2=n2351
XU5148 XOR2HS $PINS O=n5648 I1=FE_OFN1297_weight_0_r_1 I2=data_0_r[5]
XU5149 XOR2HS $PINS O=n6673 I1=data_0_r[11] I2=FE_OFN1298_weight_0_r_1
XU5150 XOR2HS $PINS O=n6666 I1=data_0_r[13] I2=FE_OFN1298_weight_0_r_1
XU5151 XOR2HS $PINS O=n6729 I1=data_0_r[10] I2=FE_OFN1298_weight_0_r_1
XU5152 XNR2HS $PINS O=n6763 I1=n2355 I2=n2623
XU5153 MOAI1 $PINS O=n6758 A1=n2354 A2=n2353 B1=n6756 B2=n2355
XU5154 XNR2HS $PINS O=n2545 I1=n3587 I2=n2357
XU5155 XOR2HS $PINS O=n2356 I1=n5979 I2=n5978
XU5156 MAO222 $PINS O=n5978 A1=n5965 B1=n5964 C1=n3321
XU5157 XNR2HS $PINS O=n5544 I1=data_0_r[18] I2=FE_OFN1272_weight_0_r_13
XU5158 OR2 $PINS O=n2360 I1=n5550 I2=n5549
XU5159 ND2S $PINS O=n5569 I1=n2360 I2=n9669
XU5160 OAI22S $PINS O=n9721 A1=n6448 A2=n6894 B1=n9715 B2=n9713
XU5161 OAI22S $PINS O=n6900 A1=n6448 A2=n6885 B1=n6894 B2=n9713
XU5162 OAI12HS $PINS O=n9724 A1=n2386 B1=n9713 B2=n9712
XU5163 OAI12HS $PINS O=n6640 A1=n2365 B1=n2367 B2=n2366
XU5164 OAI12HS $PINS O=n2365 A1=n6601 B1=n2368 B2=n6602
XU5165 INV1S $PINS O=n2366 I=n6602
XU5166 INV1S $PINS O=n2367 I=n2368
XU5167 XNR2HS $PINS O=n2368 I1=n6611 I2=n6612
XU5168 OAI12HS $PINS O=n3683 A1=n3705 B1=n2891 B2=n5650
XU5169 MOAI1 $PINS O=n7198 A1=n7177 A2=FE_OFN1648_n9466 B1=FE_OFN1545_n7188
+ B2=n7176
XU5170 XNR2HS $PINS O=n6725 I1=n2370 I2=n6726
XU5171 XNR2HS $PINS O=n2370 I1=n2373 I2=n2374
XU5172 OAI12HS $PINS O=n6769 A1=n2371 B1=n2374 B2=n2373
XU5173 ND2 $PINS O=n2371 I1=n6726 I2=n2372
XU5174 ND2 $PINS O=n2372 I1=n2374 I2=n2373
XU5175 NR2P $PINS O=n2374 I1=n2375 I2=n2376
XU5176 NR2 $PINS O=n2375 I1=n3422 I2=n3678
XU5177 INV1S $PINS O=n2377 I=n5667
XU5178 OA12 $PINS O=n5670 A1=n5657 B1=n2891 B2=n5658
XU5179 XNR2HS $PINS O=n9735 I1=n2380 I2=n2378
XU5180 XNR2HS $PINS O=n2378 I1=n2384 I2=n9732
XU5181 OAI12HS $PINS O=n9737 A1=n2379 B1=n2387 B2=n2383
XU5183 OR2 $PINS O=n2386 I1=n9715 I2=n6448
XU5184 XNR2HS $PINS O=n5859 I1=n5848 I2=n2388
XU5185 XNR2HS $PINS O=n2388 I1=n5849 I2=n2389
XU5186 NR2P $PINS O=n2389 I1=n5844 I2=n5843
XU5187 OAI12HS $PINS O=n3151 A1=n2391 B1=n3154 B2=n4235
XU5188 XNR2HS $PINS O=n4267 I1=n2391 I2=n2390
XU5189 XNR2HS $PINS O=n2390 I1=n4235 I2=n3154
XU5190 XNR2HS $PINS O=n2391 I1=n4238 I2=n3117
XU5191 OAI12HS $PINS O=n3419 A1=FE_OFN1295_weight_0_r_3 B1=FE_OFN1545_n7188
+ B2=FE_OFN1642_n9466
XU5192 ND2 $PINS O=n2392 I1=n9463 I2=FE_OFN1573_FE_DBTN20_n2908
XU5193 XNR2HS $PINS O=n5946 I1=n2394 I2=n2396
XU5194 NR2 $PINS O=n2395 I1=n5949 I2=n5950
XU5195 AOI12H $PINS O=n9536 A1=n2397 B1=n2751 B2=FE_OCPN9771_n3747
XU5196 INV1S $PINS O=n2397 I=n9535
XU5197 ND2 $PINS O=n5643 I1=n2399 I2=FE_OCPN9755_FE_OFN1289_weight_0_r_5
XU5198 NR2 $PINS O=n2899 I1=n6612 I2=n2400
XU5199 INV1S $PINS O=n2400 I=n6611
XU5201 NR2 $PINS O=n5908 I1=weight_0_r[22] I2=FE_OFN1254_weight_0_r_21
XU5202 XNR2HS $PINS O=n6065 I1=n5573 I2=data_2_r[15]
XU5203 XOR2HS $PINS O=n5985 I1=n5573 I2=data_2_r[7]
XU5204 ND3 $PINS O=n5592 I1=n6086 I2=FE_OFN1246_n8888
+ I3=FE_OFN1406_weight_2_r_3
XU5205 INV1S $PINS O=n2403 I=n5938
XU5206 OAI12HS $PINS O=n6428 A1=weight_2_r[3] B1=FE_OFN1528_n6086 B2=n3378
XU5207 NR2 $PINS O=n9684 I1=n2411 I2=n2410
XU5208 OA12 $PINS O=n5558 A1=n5556 B1=n7070 B2=n5557
XU5209 AOI22S $PINS O=n5559 A1=n5554 A2=weight_0_r[8] B1=n5562
+ B2=FE_OFN1541_n7045
XU5210 MAOI1 $PINS O=n5566 A1=n7036 A2=n2412 B1=n7070
+ B2=FE_OFN1428_FE_DBTN34_weight_0_r_11
XU5211 OAI12HS $PINS O=n2716 A1=n7053 B1=n3210 B2=n7054
XU5212 MAO222 $PINS O=n7053 A1=n3866 B1=n7051 C1=n7052
XU5213 OAI12HS $PINS O=n3866 A1=n2414 B1=n3878 B2=n3877
XU5214 OAI12HS $PINS O=n2414 A1=n7079 B1=n3879 B2=n7080
XU5215 ND2S $PINS O=n9644 I1=n2415 I2=n3032
XU5216 ND2P $PINS O=n2415 I1=n7098 I2=n7097
XU5217 OR2 $PINS O=n2416 I1=n7074 I2=n7073
XU5218 OAI12H $PINS O=n2419 A1=n3350 B1=FE_OFN1627_n6531 B2=n2417
XU5219 OAI22S $PINS O=n7072 A1=n6544 A2=FE_OFN1627_n6531 B1=FE_OFN1454_n2727
+ B2=n2417
XU5220 XNR2HS $PINS O=n2417 I1=data_0_r[24] I2=FE_OFN1269_weight_0_r_15
XU5221 XNR2HS $PINS O=n7078 I1=n2419 I2=n7060
XU5222 XNR2HS $PINS O=n6028 I1=n2420 I2=n6014
XU5223 NR2 $PINS O=n2421 I1=n6011 I2=n6010
XU5224 OAI12HS $PINS O=n4040 A1=n2424 B1=n2612 B2=n2611
XU5225 OAI12HS $PINS O=n2424 A1=n4035 B1=n4036 B2=n2613
XU5226 XNR2HS $PINS O=n2425 I1=n4033 I2=n3121
XU5227 AOI22S $PINS O=n5988 A1=n2426 A2=FE_OFN1412_weight_2_r_0 B1=n3586
+ B2=n3285
XU5228 XNR2HS $PINS O=n2426 I1=n2427 I2=FE_OFN1408_weight_2_r_1
XU5229 INV1S $PINS O=n2427 I=data_2_r[9]
XU5230 XNR2HS $PINS O=n6240 I1=data_1_r[36] I2=n6178
XU5231 XNR2HS $PINS O=n6256 I1=data_1_r[37] I2=n6178
XU5232 XNR2HS $PINS O=n6177 I1=data_1_r[45] I2=FE_OFN1530_n6178
XU5233 INV1S $PINS O=n2432 I=n6221
XU5234 MOAI1 $PINS O=n2666 A1=n2433 A2=n2674 B1=n6246 B2=n2434
XU5235 NR2 $PINS O=n2433 I1=n2434 I2=n6246
XU5236 XOR2H $PINS O=n6300 I1=n6294 I2=n2436
XU5237 XOR2HS $PINS O=n2436 I1=n6295 I2=n2439
XU5238 OAI12H $PINS O=n6303 A1=n2437 B1=n2438 B2=n2440
XU5239 OAI12HS $PINS O=n2437 A1=n6294 B1=n2439 B2=n6295
XU5240 INV1S $PINS O=n2440 I=n6295
XU5241 XNR2HS $PINS O=n4225 I1=n4222 I2=n2441
XU5242 XNR2HS $PINS O=n2441 I1=n2442 I2=n4223
XU5243 AOI12H $PINS O=n9419 A1=n2443 B1=n9421 B2=n9424
XU5244 NR2 $PINS O=n2443 I1=n3459 I2=n2460
XU5245 OA12 $PINS O=n4294 A1=n2444 B1=FE_OFN1601_n4195 B2=n4274
XU5246 NR2 $PINS O=n5679 I1=n2446 I2=n5678
XU5247 AOI12HS $PINS O=n9090 A1=n2446 B1=n3221 B2=n3250
XU5248 XNR2HS $PINS O=n6757 I1=n2448 I2=n2447
XU5249 XNR2HS $PINS O=n2447 I1=n6677 I2=n6676
XU5251 OAI22S $PINS O=n6238 A1=n2675 A2=FE_OFN1590_n3135 B1=n6242 B2=n1875
XU5252 MAOI1HP $PINS O=n6211 A1=n5469 A2=FE_DBTN27_n6338 B1=n5470
+ B2=FE_OFN1679_n3135
XU5253 MOAI1 $PINS O=n6326 A1=FE_OFN1680_n3135 A2=n6315 B1=n6183
+ B2=FE_DBTN27_n6338
XU5254 OAI12HS $PINS O=n3135 A1=n2749 B1=n2581 B2=n2033
XU5255 ND2 $PINS O=n9659 I1=n6645 I2=n2450
XU5257 XOR2HS $PINS O=n3870 I1=n6630 I2=n2452
XU5258 XNR2HS $PINS O=n6558 I1=n2453 I2=n3864
XU5259 XOR2HS $PINS O=n2454 I1=n7082 I2=n7081
XU5260 MOAI1 $PINS O=n3879 A1=FE_OFN1627_n6531 A2=n7043 B1=FE_OFN1628_n6532
+ B2=n3880
XU5261 AOI22H $PINS O=n6555 A1=n6542 A2=FE_OFN1283_weight_0_r_8 B1=n5564
+ B2=n6538
XU5262 INV1S $PINS O=n4164 I=n4163
XU5263 FA1 $PINS S=n7102 CO=n7097 A=n7078 B=n7077 CI=n7076
XU5264 XOR2HS $PINS O=n6294 I1=n3535 I2=n2456
XU5265 XOR2HS $PINS O=n2456 I1=n6273 I2=n6274
XU5266 OAI22S $PINS O=n6274 A1=FE_DBTN31_n6225 A2=n2457 B1=n6265
+ B2=FE_OFN9126_n3656
XU5267 ND2P $PINS O=n9398 I1=n6302 I2=n6303
XU5268 INV1S $PINS O=n2458 I=n5488
XU5270 XOR2HS $PINS O=n5475 I1=FE_OFN1314_weight_1_r_17 I2=data_1_r[36]
XU5271 XNR2HS $PINS O=n2460 I1=n2461 I2=n2057
XU5272 ND2 $PINS O=n9426 I1=n2462 I2=n5486
XU5273 NR2 $PINS O=n9425 I1=n5486 I2=n2462
XU5274 NR2 $PINS O=n9429 I1=FE_DBTN9_n3607 I2=n5482
XU5275 AOI22S $PINS O=n5481 A1=n5475 A2=weight_1_r[16] B1=FE_DBTN9_n3607
+ B2=n5484
XU5276 XNR2H $PINS O=n6230 I1=n2721 I2=n2464
XU5277 XNR2HS $PINS O=n2464 I1=n6221 I2=n3177
XU5278 INV1S $PINS O=n2467 I=n9273
XU5279 XNR2HS $PINS O=n4085 I1=n2469 I2=n2468
XU5280 MOAI1 $PINS O=n4090 A1=n2469 A2=n2473 B1=n4049 B2=n4048
XU5281 NR2 $PINS O=n2469 I1=n2471 I2=n2470
XU5282 XNR2HS $PINS O=n2474 I1=n2475 I2=n5742
XU5283 MAO222 $PINS O=n5792 A1=n5743 B1=n5742 C1=n2475
XU5284 NR2T $PINS O=n2477 I1=n6370 I2=n6371
XU5285 NR2F $PINS O=n9377 I1=n2478 I2=n2476
XU5286 NR2T $PINS O=n2476 I1=n9385 I2=n2477
XU5287 XNR2HS $PINS O=n2480 I1=n2479 I2=weight_2_r[5]
XU5288 INV2 $PINS O=n6414 I=n2480
XU5289 ND2 $PINS O=n2693 I1=n6041 I2=FE_OFN1450_n2480
XU5290 MOAI1S $PINS O=n6399 A1=n6403 A2=FE_OFN1662_n5980 B1=FE_OFN1450_n2480
+ B2=weight_2_r[7]
XU5291 MOAI1 $PINS O=n5969 A1=n5980 A2=n5954 B1=n5962 B2=n2480
XU5292 MOAI1 $PINS O=n6094 A1=FE_OFN1663_n5980 A2=n6069 B1=FE_OFN1450_n2480
+ B2=n6067
XU5293 ND2T $PINS O=n6136 I1=n2070 I2=n8835
XU5294 INV1S $PINS O=n2482 I=n8835
XU5295 OR2P $PINS O=n8835 I1=n6130 I2=n6131
XU5296 OAI12HS $PINS O=n5472 A1=n2484 B1=n2487 B2=n2486
XU5297 OR2 $PINS O=n2485 I1=n2488 I2=n5474
XU5298 XNR2H $PINS O=n6365 I1=n6345 I2=n2489
XU5299 XNR2HS $PINS O=n2489 I1=n6346 I2=n2493
XU5300 OAI12HS $PINS O=n2490 A1=n6345 B1=n2493 B2=n6346
XU5301 OAI12HS $PINS O=n7150 A1=n2494 B1=n3803 B2=n7146
XU5302 NR2T $PINS O=n7165 I1=n5877 I2=n5878
XU5303 NR2P $PINS O=n7164 I1=n2509 I2=n5702
XU5304 XNR2HS $PINS O=n2509 I1=n2503 I2=n2510
XU5305 NR2P $PINS O=n3758 I1=n9138 I2=n9141
XU5306 OR2P $PINS O=n9138 I1=n9140 I2=n9137
XU5307 NR2P $PINS O=n9140 I1=n7161 I2=n7160
XU5308 OAI12HS $PINS O=n7161 A1=n2516 B1=n2518 B2=n2517
XU5309 XNR2HS $PINS O=n5836 I1=data_1_r[8] I2=FE_OFN1342_weight_1_r_7
XU5310 XNR3 $PINS O=n5868 I1=n5863 I2=n2497 I3=n2498
XU5311 MAO222 $PINS O=n5872 A1=n2498 B1=n5864 C1=n5863
XU5312 NR2 $PINS O=n2498 I1=n5858 I2=n5857
XU5313 MAO222 $PINS O=n5800 A1=n5795 B1=n5796 C1=n2499
XU5314 MOAI1H $PINS O=n2499 A1=FE_OFN1585_FE_DBTN6_n7135 A2=n5745 B1=n5744
+ B2=FE_OFN1438_FE_DBTN16_n5612
XU5315 OAI12HS $PINS O=n2502 A1=n2500 B1=n2514 B2=FE_OFN1583_FE_DBTN6_n7135
XU5316 ND2 $PINS O=n2500 I1=FE_DBTN16_n5612 I2=n5696
XU5317 XNR2HS $PINS O=n3846 I1=n7151 I2=n2502
XU5318 ND2S $PINS O=n3847 I1=n7151 I2=n2502
XU5319 OAI12HS $PINS O=n3848 A1=n7150 B1=n7151 B2=n2502
XU5320 ND2 $PINS O=n2504 I1=n5800 I2=n5801
XU5321 XNR2HS $PINS O=n5799 I1=n3275 I2=n2506
XU5322 XNR2HS $PINS O=n2506 I1=n5797 I2=n5798
XU5323 XNR2HS $PINS O=n5801 I1=n2508 I2=n2706
XU5324 XOR2HS $PINS O=n2510 I1=n7159 I2=n2519
XU5325 ND2P $PINS O=n7163 I1=n5878 I2=n5877
XU5326 OAI12H $PINS O=n5882 A1=n2511 B1=n2532 B2=n3045
XU5327 OAI12HS $PINS O=n2511 A1=n5859 B1=n5860 B2=n5861
XU5329 MOAI1 $PINS O=n5787 A1=n5770 A2=FE_OFN1585_FE_DBTN6_n7135
+ B1=FE_OFN1439_FE_DBTN16_n5612 B2=n5769
XU5330 OAI22S $PINS O=n7147 A1=FE_OFN1583_FE_DBTN6_n7135 A2=n5680 B1=n2514
+ B2=n5612
XU5331 MOAI1 $PINS O=n5838 A1=n2060 A2=FE_OFN1585_FE_DBTN6_n7135 B1=n5823
+ B2=FE_OFN1439_FE_DBTN16_n5612
XU5333 ND2 $PINS O=n2515 I1=n5714 I2=FE_OFN1438_FE_DBTN16_n5612
XU5334 XNR2HS $PINS O=n2519 I1=n3846 I2=n7150
XU5335 XOR2HS $PINS O=n5814 I1=n5828 I2=n5827
XU5336 OA12 $PINS O=n5827 A1=n2520 B1=FE_OFN1613_n5691 B2=n5763
XU5340 NR2 $PINS O=n7145 I1=FE_OFN1429_FE_DBTN32_weight_1_r_7 I2=n5706
XU5341 NR2 $PINS O=n5847 I1=FE_DBTN32_weight_1_r_7 I2=FE_OFN1360_data_1_r_1
XU5342 NR2 $PINS O=n9126 I1=FE_OFN1429_FE_DBTN32_weight_1_r_7 I2=n7136
XU5343 MOAI1S $PINS O=n5742 A1=n5691 A2=FE_DBTN32_weight_1_r_7 B1=n9120
+ B2=n2523
XU5344 NR2 $PINS O=n2523 I1=FE_OFN1425_FE_DBTN49_data_1_r_1
+ I2=FE_DBTN32_weight_1_r_7
XU5345 NR2P $PINS O=n9148 I1=n2526 I2=n2524
XU5346 ND2 $PINS O=n2525 I1=n5812 I2=n2062
XU5347 NR2P $PINS O=n9152 I1=n2527 I2=n5881
XU5348 ND2 $PINS O=n9153 I1=n5881 I2=n2527
XU5349 XNR2H $PINS O=n2527 I1=n5859 I2=n2528
XU5350 XNR2HS $PINS O=n2528 I1=n5861 I2=n5860
XU5351 XNR2HS $PINS O=n6379 I1=n6200 I2=n2529
XU5352 INV1S $PINS O=n2532 I=n5860
XU5353 XNR2HS $PINS O=n2533 I1=n2534 I2=n5911
XU5354 MAO222 $PINS O=n6484 A1=n5910 B1=n5911 C1=n2534
XU5355 OAI12HS $PINS O=n2534 A1=n5898 B1=n5917 B2=n6937
XU5356 XNR2HS $PINS O=n7094 I1=n7055 I2=n2535
XU5357 XNR2HS $PINS O=n2535 I1=n7056 I2=n2536
XU5358 NR2 $PINS O=n6173 I1=n2343 I2=FE_OFN1302_weight_1_r_23
XU5359 ND2 $PINS O=n5697 I1=n2537 I2=FE_OFN9139_n5853
XU5360 MOAI1S $PINS O=n5777 A1=n5771 A2=n2537 B1=n3839 B2=FE_OFN1526_n5853
XU5361 OAI22S $PINS O=n5786 A1=n2537 A2=n5772 B1=n5771 B2=FE_OFN9139_n5853
XU5362 OAI12H $PINS O=n2537 A1=n3828 B1=n3357 B2=FE_OFN9136_weight_1_r_3
XU5363 ND3 $PINS O=n8854 I1=FE_OCPN9763_n6804 I2=n2538 I3=n8852
XU5364 AOI12HS $PINS O=n6810 A1=n3545 B1=FE_OCPN9763_n6804 B2=n2538
XU5366 OR2T $PINS O=n7127 I1=n4658 I2=n4659
XU5368 ND2 $PINS O=n9795 I1=n5503 I2=n5504
XU5369 XOR2HS $PINS O=n2541 I1=n5890 I2=n3099
XU5370 INV1S $PINS O=n2542 I=n5891
XU5371 NR2 $PINS O=n2543 I1=n5527 I2=n5528
XU5372 NR2P $PINS O=n9803 I1=n5526 I2=n2544
XU5373 NR2 $PINS O=n9808 I1=n5520 I2=n5519
XU5374 OR2 $PINS O=n9806 I1=n5517 I2=n5518
XU5375 MOAI1 $PINS O=n6029 A1=n2546 A2=n2545 B1=n5979 B2=n5978
XU5376 NR2 $PINS O=n2546 I1=n5979 I2=n5978
XU5377 XNR2HS $PINS O=n2550 I1=n4083 I2=n3308
XU5378 OAI12HS $PINS O=n2547 A1=n7283 B1=n7282 B2=n9281
XU5379 ND2 $PINS O=n9281 I1=n2550 I2=n4116
XU5380 OR2T $PINS O=n4122 I1=n2857 I2=n7282
XU5381 OA12P $PINS O=n9283 A1=n9289 B1=n9295 B2=n9288
XU5382 ND2 $PINS O=n9289 I1=n4121 I2=n4120
XU5383 ND2P $PINS O=n9295 I1=n4119 I2=n4118
XU5384 NR2T $PINS O=n3553 I1=n2552 I2=n2551
XU5385 INV1S $PINS O=n2551 I=n9161
XU5386 NR2P $PINS O=n2553 I1=n5806 I2=n5807
XU5387 NR2P $PINS O=n3556 I1=n6395 I2=n2553
XU5388 ND2 $PINS O=n8934 I1=n4649 I2=n4650
XU5389 XNR2HS $PINS O=n6100 I1=data_2_r[10] I2=FE_OFN1532_n6412
XU5390 XOR2HS $PINS O=n6016 I1=data_2_r[8] I2=FE_OFN1532_n6412
XU5391 XOR2HS $PINS O=n6084 I1=data_2_r[12] I2=FE_OFN1532_n6412
XU5392 XNR2HS $PINS O=n2555 I1=n4015 I2=n2556
XU5393 NR2 $PINS O=n2559 I1=n4024 I2=n2614
XU5394 OAI12HS $PINS O=n2614 A1=n2575 B1=FE_OFN1672_n4077 B2=n4011
XU5396 OAI12HS $PINS O=n2726 A1=n2730 B1=FE_OFN1596_n3897 B2=n4014
XU5397 MOAI1S $PINS O=n5837 A1=n5826 A2=FE_OFN1669_n5855 B1=n2562
+ B2=FE_OFN1526_n5853
XU5398 NR2 $PINS O=n3301 I1=n5828 I2=n5827
XU5399 NR2 $PINS O=n9189 I1=n2564 I2=n2563
XU5400 OR2 $PINS O=n9192 I1=n5631 I2=n5632
XU5401 XNR2HS $PINS O=n5632 I1=n5637 I2=n5638
XU5402 NR2 $PINS O=n5631 I1=n2565 I2=n2051
XU5403 NR2 $PINS O=n2565 I1=FE_OFN1668_n5855 I2=FE_OFN9135_weight_1_r_3
XU5404 OA12 $PINS O=n9196 A1=n9198 B1=n9197 B2=n9203
XU5405 NR2P $PINS O=n3469 I1=n3363 I2=n6812
XU5406 NR2T $PINS O=n3363 I1=n4352 I2=n4353
XU5407 XNR2HS $PINS O=n4588 I1=n4598 I2=n2566
XU5408 MAO222 $PINS O=n4084 A1=n2568 B1=n4082 C1=n3074
XU5409 OAI12HS $PINS O=n2568 A1=n2576 B1=FE_OFN1673_n4077 B2=n4075
XU5410 INV2 $PINS O=n2569 I=n9327
XU5411 NR2P $PINS O=n9327 I1=n3542 I2=n2570
XU5412 INV2 $PINS O=n2570 I=n3990
XU5413 ND3HT $PINS O=n2571 I1=n2572 I2=n2764 I3=n9324
XU5414 OR2P $PINS O=n9324 I1=n3988 I2=n3987
XU5415 OR2T $PINS O=n2764 I1=n3989 I2=n3990
XU5417 AOI12HS $PINS O=n2574 A1=n8945 B1=n2029 B2=n8948
XU5419 OAI22S $PINS O=n4100 A1=n4078 A2=FE_OFN1673_n4077 B1=n4076 B2=n4075
XU5420 MOAI1S $PINS O=n3908 A1=FE_OFN1673_n4077 A2=n3891 B1=FE_OFN1452_n2589
+ B2=FE_OFN1329_weight_1_r_11
XU5421 ND2S $PINS O=n3499 I1=n4516 I2=n2578
XU5422 XOR2HS $PINS O=n4518 I1=n2578 I2=n4517
XU5425 NR2 $PINS O=n5608 I1=FE_OFN1356_weight_1_r_0 I2=n3063
XU5426 NR2 $PINS O=n2581 I1=weight_1_r[18] I2=FE_OFN1314_weight_1_r_17
XU5427 ND2 $PINS O=n3180 I1=n4589 I2=n2582
XU5428 XNR2HS $PINS O=n3179 I1=n2582 I2=n4589
XU5429 XNR2HS $PINS O=n2584 I1=n6212 I2=n6211
XU5430 NR2 $PINS O=n2585 I1=n6207 I2=n6206
XU5431 INV1S $PINS O=n3692 I=n2586
XU5432 OR2T $PINS O=n3690 I1=n3946 I2=n2586
XU5434 OAI12H $PINS O=n2586 A1=n3693 B1=n3822 B2=n3823
XU5435 ND2S $PINS O=n3777 I1=n2587 I2=n3779
XU5436 XNR2HS $PINS O=n3776 I1=n3779 I2=n2587
XU5437 OAI12H $PINS O=n2587 A1=n4480 B1=n4535 B2=FE_OFN1608_n4622
XU5438 XOR2HS $PINS O=n3216 I1=n3695 I2=n3217
XU5439 OAI12H $PINS O=n3217 A1=n2588 B1=FE_OFN1633_n7070 B2=n6610
XU5440 ND2 $PINS O=n2588 I1=n6621 I2=FE_OFN1676_n7036
XU5441 XNR2HS $PINS O=n6610 I1=data_0_r[23] I2=FE_OFN1275_weight_0_r_11
XU5442 NR2P $PINS O=n3924 I1=n3981 I2=n2590
XU5443 INV1S $PINS O=n8972 I=n3798
XU5444 ND2 $PINS O=n3798 I1=n1999 I2=n4520
XU5445 ND3 $PINS O=n4520 I1=n3500 I2=n3498 I3=n3499
XU5446 XNR2HS $PINS O=n2592 I1=n6150 I2=n6149
XU5447 NR2P $PINS O=n8849 I1=n6035 I2=n6036
XU5448 ND2 $PINS O=n8850 I1=n6036 I2=n6035
XU5450 NR2T $PINS O=n9351 I1=n6374 I2=n6375
XU5451 ND3 $PINS O=n6374 I1=n2605 I2=n2606 I3=n2607
XU5452 XOR2HS $PINS O=n9241 I1=n9238 I2=n3270
XU5453 OAI12H $PINS O=n8865 A1=n8870 B1=n8872 B2=n8869
XU5454 XNR2HS $PINS O=n5580 I1=FE_OFN1406_weight_2_r_3 I2=data_2_r[3]
XU5455 MOAI1 $PINS O=n6035 A1=n3391 A2=n3390 B1=n6026 B2=n6027
XU5456 FA1 $PINS S=n4358 CO=n4359 A=n4348 B=n4347 CI=n4346
XU5457 INV1S $PINS O=n3287 I=data_0_r[22]
XU5458 XNR2HS $PINS O=n6582 I1=FE_OFN1275_weight_0_r_11 I2=data_0_r[22]
XU5459 XOR2HS $PINS O=n6561 I1=FE_OFN1278_weight_0_r_9 I2=data_0_r[22]
XU5460 XNR2HS $PINS O=n6539 I1=FE_OFN1269_weight_0_r_15 I2=data_0_r[22]
XU5461 AOI12HS $PINS O=n7130 A1=n9755 B1=n9758 B2=n2601
XU5462 OAI12HS $PINS O=n2739 A1=n4026 B1=n4027 B2=n2740
XU5463 ND2 $PINS O=n3093 I1=n2596 I2=n2595
XU5464 ND3HT $PINS O=n2596 I1=n4586 I2=n4585 I3=n4587
XU5465 XNR2HS $PINS O=n6674 I1=FE_OFN1284_weight_0_r_7 I2=data_0_r[5]
XU5466 XOR2HS $PINS O=n6188 I1=FE_OFN1307_weight_1_r_23 I2=data_1_r[41]
XU5468 AOI22S $PINS O=n4627 A1=n4593 A2=FE_OFN1397_weight_2_r_8
+ B1=FE_OFN1475_n4591 B2=n4590
XU5469 XOR2HS $PINS O=n6087 I1=data_2_r[14] I2=FE_OFN1408_weight_2_r_1
XU5471 AN2 $PINS O=n2597 I1=n9264 I2=n9263
XU5472 OR2 $PINS O=n2598 I1=n5582 I2=n5581
XU5473 AOI12HS $PINS O=n6807 A1=n6806 B1=FE_OCPN9763_n6804 B2=n7263
XU5474 NR2 $PINS O=n3044 I1=n7205 I2=n7195
XU5475 XOR2HS $PINS O=n3586 I1=data_2_r[8] I2=FE_OFN1407_weight_2_r_1
XU5476 XNR2HS $PINS O=n7234 I1=n7228 I2=n3407
XU5477 XNR2HS $PINS O=n4337 I1=n3859 I2=n4344
XU5478 AOI12HP $PINS O=n8836 A1=n2602 B1=n8845 B2=n8843
XU5479 INV2 $PINS O=n8843 I=n8841
XU5480 INV2 $PINS O=n8845 I=n8844
XU5481 MOAI1H $PINS O=n4654 A1=n3787 A2=FE_DBTN46_n4426 B1=n4427 B2=n4428
XU5482 NR2 $PINS O=n3787 I1=n4428 I2=n4427
XU5483 XNR2HS $PINS O=n4655 I1=n4400 I2=n2648
XU5484 XOR3 $PINS O=n2761 I1=n4304 I2=n4302 I3=n4303
XU5485 ND2T $PINS O=n3589 I1=n3598 I2=n3597
XU5486 ND2 $PINS O=n2768 I1=n7057 I2=n7059
XU5487 FA1 $PINS S=n7024 CO=n9600 A=n7002 B=n7001 CI=n7000
XU5488 FA1 $PINS S=n7056 CO=n7025 A=n7014 B=n7013 CI=n7012
XU5489 NR2P $PINS O=n7265 I1=n6947 I2=n6946
XU5491 INV1S $PINS O=n3377 I=n3379
XU5492 XOR2HS $PINS O=n6381 I1=n6204 I2=n2604
XU5493 ND2 $PINS O=n2605 I1=n6204 I2=n6203
XU5494 ND2 $PINS O=n2606 I1=n6204 I2=n6205
XU5495 ND2 $PINS O=n2607 I1=n6203 I2=n6205
XU5496 XOR2HS $PINS O=n3940 I1=FE_OFN1323_weight_1_r_13 I2=data_1_r[20]
XU5497 XOR2HS $PINS O=pConv_2/product_0_w[18] I1=n6137 I2=n3546
XU5498 OAI12H $PINS O=n3702 A1=n9309 B1=n9311 B2=n9312
XU5499 ND2 $PINS O=n9309 I1=n4038 I2=n2609
XU5500 ND2P $PINS O=n9647 I1=n7102 I2=n7101
XU5501 ND3 $PINS O=n9169 I1=n9168 I2=n9167 I3=n3497
XU5504 XNR2HS $PINS O=n6819 I1=weight_2_r[20] I2=FE_OFN1371_weight_2_r_19
XU5505 INV2 $PINS O=n6103 I=n6086
XU5506 INV1S $PINS O=n8996 I=FE_OFN1396_weight_2_r_8
XU5507 OAI22S $PINS O=n6607 A1=FE_OFN1633_n7070 A2=n6582 B1=FE_OFN1677_n7036
+ B2=n6610
XU5508 XOR2HS $PINS O=n4217 I1=FE_OFN1368_weight_2_r_21 I2=data_2_r[36]
XU5509 AOI22S $PINS O=n3944 A1=n3934 A2=FE_OFN1337_weight_1_r_8 B1=n3922
+ B2=FE_OCPN9723_n3961
XU5510 XOR2HS $PINS O=n3934 I1=FE_OFN1333_weight_1_r_9 I2=data_1_r[24]
XU5511 ND2 $PINS O=n2838 I1=FE_OCPN9773_n4570 I2=n4568
XU5512 NR2P $PINS O=n4568 I1=n4547 I2=n4546
XU5513 XOR2HS $PINS O=n5468 I1=FE_OFN1314_weight_1_r_17 I2=data_1_r[37]
XU5514 MOAI1S $PINS O=n3321 A1=n5958 A2=n5959 B1=n5966 B2=FE_OCPN9772_n6407
XU5515 XNR2HS $PINS O=n6451 I1=FE_OFN1257_weight_0_r_19 I2=data_0_r[38]
XU5516 ND3 $PINS O=n3833 I1=n2835 I2=n1923 I3=n2211
XU5517 ND3 $PINS O=n5888 I1=n2835 I2=n9142 I3=n7120
XU5518 XOR2HS $PINS O=n4033 I1=n3538 I2=n3297
XU5519 OR2 $PINS O=n3538 I1=n4023 I2=n4022
XU5520 OA12 $PINS O=n4022 A1=n3700 B1=FE_OFN1596_n3897 B2=n3936
XU5521 AOI22S $PINS O=n4023 A1=n3934 A2=FE_OCPN9723_n3961
+ B1=FE_OFN1337_weight_1_r_8 B2=n4012
XU5523 INV1S $PINS O=n2615 I=n4010
XU5524 OAI12HS $PINS O=n3260 A1=n4637 B1=n3263 B2=n4638
XU5525 XNR2HS $PINS O=n3745 I1=n4231 I2=n2620
XU5526 MOAI1H $PINS O=n3154 A1=n3746 A2=n2619 B1=n4231 B2=n2620
XU5527 OAI12HS $PINS O=n2620 A1=n2621 B1=n4218 B2=FE_OFN1577_FE_DBTN17_n6819
XU5528 ND2 $PINS O=n2621 I1=FE_OFN1594_n3599 I2=n4217
XU5529 OR2 $PINS O=n5710 I1=n2622 I2=FE_OFN1562_FE_DBTN37_n5853
XU5530 XNR2HS $PINS O=n2623 I1=n6756 I2=n2624
XU5531 ND3P $PINS O=n3598 I1=n2625 I2=n2647 I3=n2598
XU5532 OR2 $PINS O=n2647 I1=n5945 I2=n5946
XU5533 OR2P $PINS O=n8870 I1=n5605 I2=n5606
XU5534 OR2 $PINS O=n2626 I1=n3972 I2=n3973
XU5536 ND3P $PINS O=n2628 I1=n3762 I2=n9096 I3=n9092
XU5537 ND3HT $PINS O=n6788 I1=n2630 I2=n2629 I3=n9089
XU5538 ND2 $PINS O=n9089 I1=n2633 I2=n4226
XU5539 OR2P $PINS O=n3250 I1=n4224 I2=n4225
XU5540 OR2T $PINS O=n3432 I1=n4226 I2=n2633
XU5541 INV2 $PINS O=n2631 I=n4225
XU5542 ND3HT $PINS O=n3495 I1=n3188 I2=n9319 I3=n9321
XU5543 ND2 $PINS O=n9545 I1=n6768 I2=n6767
XU5544 ND2 $PINS O=n9552 I1=n6766 I2=n6765
XU5545 XNR2HS $PINS O=n2636 I1=n2637 I2=n4557
XU5546 XNR2HS $PINS O=n2637 I1=n4547 I2=n4545
XU5547 INV1S $PINS O=n9183 I=n3038
XU5548 XOR2HS $PINS O=n5720 I1=n5718 I2=n5732
XU5549 NR2 $PINS O=n6210 I1=n6208 I2=n2639
XU5550 ND2 $PINS O=n9402 I1=n6300 I2=n2640
XU5551 NR2T $PINS O=n9404 I1=n2640 I2=n6300
XU5552 OAI12HS $PINS O=n2641 A1=n2642 B1=n6261 B2=n2733
XU5553 MAO222 $PINS O=n2642 A1=n3503 B1=n6255 C1=n6254
XU5554 INV1S $PINS O=n9538 I=n2643
XU5555 NR2P $PINS O=n3747 I1=n2643 I2=n7214
XU5556 NR2P $PINS O=n2643 I1=n7236 I2=n7235
XU5557 OAI12HS $PINS O=n6327 A1=n3544 B1=n6181 B2=FE_OFN1568_FE_DBTN31_n6225
XU5558 NR2P $PINS O=n2645 I1=n3574 I2=n3573
XU5560 INV1S $PINS O=n5943 I=n2647
XU5561 INV1S $PINS O=n5944 I=n2598
XU5562 MOAI1 $PINS O=n4657 A1=n2650 A2=n2649 B1=n4402 B2=n4401
XU5563 XNR2HS $PINS O=n6129 I1=n6083 I2=n2651
XU5564 XNR2HS $PINS O=n2651 I1=n2654 I2=n6082
XU5565 NR2 $PINS O=n2653 I1=n2654 I2=n6083
XU5566 MAO222 $PINS O=n2654 A1=FE_OFN1409_weight_2_r_1 B1=n3743 C1=n3733
XU5567 XNR2HS $PINS O=n4610 I1=n2655 I2=n4615
XU5568 XNR2HS $PINS O=n2655 I1=n4616 I2=n2656
XU5569 NR2P $PINS O=n8941 I1=n4647 I2=n4648
XU5570 ND2 $PINS O=n8958 I1=n4578 I2=n4579
XU5571 XNR2HS $PINS O=n2658 I1=n4453 I2=n4452
XU5572 ND2 $PINS O=n3550 I1=n2659 I2=n3449
XU5573 INV2 $PINS O=n2659 I=n8832
XU5574 ND2S $PINS O=n5607 I1=n2598 I2=n8864
XU5575 XNR2HS $PINS O=n6916 I1=data_0_r[45] I2=FE_OFN1260_weight_0_r_19
XU5576 XNR2HS $PINS O=n6506 I1=data_0_r[41] I2=FE_OFN1257_weight_0_r_19
XU5577 XNR2HS $PINS O=n6936 I1=data_0_r[44] I2=FE_OFN1259_weight_0_r_19
XU5578 XOR2HS $PINS O=n6955 I1=data_0_r[43] I2=FE_OFN1259_weight_0_r_19
XU5579 XNR2HS $PINS O=n5509 I1=data_0_r[33] I2=FE_OFN1256_weight_0_r_19
XU5580 ND2 $PINS O=n6779 I1=n2666 I2=n6247
XU5581 ND3HT $PINS O=n2661 I1=n2843 I2=n6781 I3=n3351
XU5582 OR2 $PINS O=n6781 I1=n2665 I2=n3543
XU5583 OR2P $PINS O=n3351 I1=n2666 I2=n6247
XU5584 OAI12HS $PINS O=n2667 A1=n6929 B1=n6930 B2=n6931
XU5585 XOR2HS $PINS O=n6947 I1=n6978 I2=n2669
XU5586 XOR2HS $PINS O=n2669 I1=n2715 I2=n6979
XU5587 NR2 $PINS O=n4306 I1=FE_OFN1377_weight_2_r_16
+ I2=FE_OFN1694_weight_2_r_17
XU5588 XNR2HS $PINS O=n6187 I1=data_1_r[47] I2=FE_OFN1531_n6191
XU5589 XNR2HS $PINS O=n6262 I1=data_1_r[42] I2=FE_OFN1531_n6191
XU5590 XNR2HS $PINS O=n6319 I1=data_1_r[46] I2=FE_OFN1531_n6191
XU5591 MOAI1H $PINS O=n6231 A1=n6214 A2=FE_OFN1567_FE_DBTN31_n6225
+ B1=FE_DBTN40_n3656 B2=n6213
XU5592 OAI12HS $PINS O=n2678 A1=n2679 B1=n6287 B2=FE_OFN1568_FE_DBTN31_n6225
XU5593 MOAI1H $PINS O=n6255 A1=n6241 A2=FE_OFN1567_FE_DBTN31_n6225
+ B1=FE_OFN1561_FE_DBTN40_n3656 B2=n6240
XU5594 XNR2H $PINS O=n6296 I1=n6285 I2=n2672
XU5595 NR2P $PINS O=n6285 I1=n6279 I2=n6278
XU5596 MAO222P $PINS O=n2737 A1=n3535 B1=n6274 C1=n6273
XU5597 XNR2HS $PINS O=n2675 I1=data_1_r[37] I2=FE_OFN1311_weight_1_r_19
XU5598 OAI12HS $PINS O=n2676 A1=n6285 B1=n6286 B2=n2678
XU5599 XNR2HS $PINS O=n6183 I1=data_1_r[46] I2=FE_OFN1449_n2033
XU5600 XOR2HS $PINS O=n5470 I1=data_1_r[35] I2=n2033
XU5601 XOR2HS $PINS O=n6257 I1=data_1_r[39] I2=FE_OFN1448_n2033
XU5602 XOR2HS $PINS O=n6315 I1=data_1_r[45] I2=FE_OFN1449_n2033
XU5603 NR2T $PINS O=n2849 I1=n6784 I2=n9404
XU5604 NR2P $PINS O=n6784 I1=n6298 I2=n6299
XU5605 XOR2HS $PINS O=n6039 I1=n6052 I2=n6051
XU5606 OAI12HS $PINS O=n2692 A1=n2693 B1=FE_OFN1664_n5980 B2=n6013
XU5607 XNR2HS $PINS O=n6109 I1=n2697 I2=n2694
XU5608 XNR2HS $PINS O=n2694 I1=n6098 I2=n6097
XU5609 OAI12HS $PINS O=n6114 A1=n2695 B1=n2699 B2=n2696
XU5610 INV1S $PINS O=n2696 I=n2697
XU5611 INV1S $PINS O=n2698 I=n6105
XU5612 XNR2HS $PINS O=n2700 I1=n5803 I2=n5802
XU5613 XNR2HS $PINS O=n2701 I1=n5786 I2=n3381
XU5614 INV1S $PINS O=n2703 I=n2704
XU5615 XNR2HS $PINS O=n3178 I1=n2704 I2=n5701
XU5616 OA12 $PINS O=n2704 A1=n2705 B1=FE_OFN1669_n5855 B2=n5685
XU5617 AOI12HS $PINS O=n2707 A1=n9156 B1=n3757 B2=n9159
XU5619 XOR2HS $PINS O=n5617 I1=FE_OFN9135_weight_1_r_3 I2=data_1_r[3]
XU5620 XOR2HS $PINS O=n5850 I1=FE_OFN1346_weight_1_r_5 I2=data_1_r[11]
XU5621 MOAI1 $PINS O=n7051 A1=FE_OFN1627_n6531 A2=n7040 B1=n2712
+ B2=FE_OFN1628_n6532
XU5622 MAO222 $PINS O=n4300 A1=n3662 B1=n3360 C1=n4256
XU5623 NR2 $PINS O=n3662 I1=n3486 I2=n1977
XU5625 NR2 $PINS O=n2713 I1=n4237 I2=n4195
XU5626 NR2 $PINS O=n2714 I1=n4249 I2=FE_OFN1536_n6822
XU5627 OA12S $PINS O=n9269 A1=n9265 B1=n9278 B2=n9272
XU5628 OA12P $PINS O=n9278 A1=n9251 B1=n9253 B2=n9252
XU5629 NR2P $PINS O=n9252 I1=n3910 I2=n3911
XU5630 INV1S $PINS O=n3515 I=n9624
XU5631 NR2P $PINS O=n7259 I1=n6132 I2=n6133
XU5632 ND2 $PINS O=n5927 I1=n2718 I2=n7243
XU5633 ND2 $PINS O=n4361 I1=n2718 I2=n4356
XU5634 ND2 $PINS O=n6838 I1=n2718 I2=n6834
XU5635 ND3HT $PINS O=n2718 I1=n3664 I2=n3663 I3=n6813
XU5636 XOR2HS $PINS O=n6246 I1=n6244 I2=n6243
XU5637 OA12 $PINS O=n6243 A1=n2719 B1=n6138 B2=n6220
XU5638 NR2 $PINS O=n9073 I1=n2720 I2=n3476
XU5639 OAI12HS $PINS O=n2720 A1=n3110 B1=n3112 B2=n3111
XU5640 NR2P $PINS O=n3654 I1=n6218 I2=n3655
XU5641 XNR2H $PINS O=n3655 I1=n3653 I2=n6230
XU5642 NR2P $PINS O=n2721 I1=n6211 I2=n6212
XU5643 XNR2HS $PINS O=n7057 I1=n7061 I2=n2723
XU5644 MAO222 $PINS O=n7077 A1=n7061 B1=n7062 C1=n2724
XU5645 NR2P $PINS O=n7246 I1=n7092 I2=n7093
XU5646 MOAI1H $PINS O=n7092 A1=n2725 A2=n3323 B1=n7089 B2=n7090
XU5647 NR2 $PINS O=n2725 I1=n7090 I2=n7089
XU5648 NR2 $PINS O=n6575 I1=n6576 I2=FE_OFN9748_weight_0_r_13
XU5649 XOR2HS $PINS O=n6534 I1=FE_DBTN33_weight_0_r_13 I2=n3342
XU5650 OAI12H $PINS O=n6305 A1=n2734 B1=n2736 B2=n2735
XU5651 ND2 $PINS O=n4037 I1=n2739 I2=n2738
XU5652 ND2 $PINS O=n2738 I1=n4027 I2=n2740
XU5653 OAI12HS $PINS O=n3460 A1=n4451 B1=n4452 B2=n4453
XU5654 XNR2HS $PINS O=n4451 I1=n3183 I2=n2742
XU5655 AOI22S $PINS O=n4441 A1=FE_OFN1477_n4591 A2=n4436
+ B1=FE_OFN1397_weight_2_r_8 B2=n4437
XU5656 XNR2HS $PINS O=n3580 I1=n4298 I2=n4297
XU5657 MAO222 $PINS O=n4297 A1=n3477 B1=n4276 C1=n4275
XU5658 MOAI1 $PINS O=n4275 A1=FE_OFN1659_n4331 A2=n2744 B1=FE_OFN1471_n4329
+ B2=n4279
XU5659 NR2 $PINS O=n3477 I1=n4261 I2=n2745
XU5661 INV1S $PINS O=n6996 I=n7067
XU5662 XNR2HS $PINS O=n7067 I1=weight_0_r[11] I2=weight_0_r[12]
XU5663 XOR2HS $PINS O=n6585 I1=FE_OFN1267_weight_0_r_15 I2=data_0_r[18]
XU5665 XOR2HS $PINS O=n5546 I1=data_0_r[21] I2=FE_OFN1277_weight_0_r_9
XU5666 NR2P $PINS O=n2748 I1=n9288 I2=n9291
XU5667 NR2P $PINS O=n9291 I1=n4118 I2=n4119
XU5668 XNR2HS $PINS O=n4302 I1=n2750 I2=n3797
XU5669 OR2 $PINS O=n2750 I1=n4294 I2=n4295
XU5670 ND3HT $PINS O=n2751 I1=n6776 I2=n6774 I3=n6775
XU5671 XNR2HS $PINS O=n3569 I1=n4099 I2=n4098
XU5673 XNR2HS $PINS O=n4350 I1=n4142 I2=n3399
XU5674 INV1S $PINS O=n9397 I=n9392
XU5675 INV1S $PINS O=n7123 I=n9246
XU5676 AOI12HS $PINS O=n9380 A1=n9378 B1=FE_OFN1240_n6309 B2=n9379
XU5677 XOR2HS $PINS O=n6831 I1=n9054 I2=n2752
XU5678 ND3 $PINS O=n9056 I1=n2753 I2=n2754 I3=n2755
XU5679 FA1 $PINS S=n6828 CO=n9053 A=n6827 B=n6826 CI=n6825
XU5680 NR2 $PINS O=n9061 I1=n6831 I2=n6832
XU5681 NR2 $PINS O=n3518 I1=n6485 I2=n6484
XU5682 AN2 $PINS O=n2756 I1=n9383 I2=n9382
XU5683 INV1S $PINS O=n2758 I=n6862
XU5686 INV1S $PINS O=n9305 I=n9300
XU5687 ND2 $PINS O=n9136 I1=n7160 I2=n7161
XU5688 FA1 $PINS S=n7159 CO=n7157 A=n7146 B=n7145 CI=n7144
XU5689 FA1 $PINS S=n4119 CO=n4121 A=n4104 B=n4103 CI=n4102
XU5690 XNR2HS $PINS O=n6903 I1=n9730 I2=n3525
XU5691 XNR2HS $PINS O=n3907 I1=n3905 I2=n3665
XU5692 OAI22S $PINS O=n3937 A1=FE_DBTN26_weight_1_r_15 A2=FE_OFN1596_n3897
+ B1=n2762 B2=FE_OFN1572_FE_DBTN21_n3428
XU5693 OR2 $PINS O=n2762 I1=data_1_r[17] I2=FE_DBTN26_weight_1_r_15
XU5694 MOAI1 $PINS O=n6928 A1=FE_OFN1587_n1873 A2=n6887
+ B1=FE_OFN1569_FE_DBTN25_n6937 B2=n6886
XU5696 OAI12H $PINS O=n8953 A1=n6518 B1=n6520 B2=n7256
XU5698 ND2 $PINS O=n3361 I1=FE_OFN1594_n3599 I2=n4252
XU5699 AN2 $PINS O=n2763 I1=n9749 I2=n9748
XU5700 MOAI1 $PINS O=n4272 A1=n3371 A2=n3370 B1=n4264 B2=n4265
XU5701 ND2P $PINS O=n9648 I1=n6556 I2=n6557
XU5702 INV1S $PINS O=n9641 I=n9640
XU5704 XOR2HS $PINS O=n4001 I1=FE_OCPN9769_FE_OFN1335_weight_1_r_9
+ I2=data_1_r[28]
XU5705 OA12 $PINS O=n3968 A1=n3957 B1=n4077 B2=FE_DBTN44_weight_1_r_11
XU5706 XOR2HS $PINS O=n3797 I1=n4309 I2=n3366
XU5707 MOAI1 $PINS O=n4309 A1=FE_OFN1576_FE_DBTN17_n6819 A2=n4292
+ B1=FE_OFN1593_n3599 B2=n4291
XU5708 ND3 $PINS O=n9270 I1=n9268 I2=n9267 I3=n9269
XU5709 XNR2HS $PINS O=n3946 I1=n3943 I2=n3944
XU5710 OAI22S $PINS O=n3974 A1=n3950 A2=FE_OFN1671_n4077 B1=FE_OFN1598_n4076
+ B2=n3949
XU5714 ND2 $PINS O=n2766 I1=n7058 I2=n7057
XU5715 ND2 $PINS O=n2767 I1=n7058 I2=n7059
XU5716 ND3 $PINS O=n7101 I1=n2766 I2=n2767 I3=n2768
XU5717 XNR2HS $PINS O=n7059 I1=n7072 I2=n7074
XU5718 NR2P $PINS O=n7075 I1=n6556 I2=n6557
XU5727 NR2P $PINS O=n2791 I1=FE_OFN1281_weight_0_r_8 I2=n7046
XU5731 XNR2HS $PINS O=n3103 I1=n6639 I2=n6637
XU5732 ND2 $PINS O=n3365 I1=n3366 I2=n4309
XU5733 XNR2HS $PINS O=n3942 I1=FE_OFN1328_weight_1_r_11 I2=data_1_r[22]
XU5734 MOAI1 $PINS O=n6239 A1=n6227 A2=n6226 B1=n6225 B2=n6240
XU5736 NR2 $PINS O=n3105 I1=n6639 I2=n6638
XU5737 ND2 $PINS O=n9740 I1=n6992 I2=n6991
XU5738 OAI22S $PINS O=n4137 A1=n4133 A2=FE_OFN1602_n4195 B1=FE_OFN1701_n6822
+ B2=n4132
XU5739 MOAI1S $PINS O=n6196 A1=FE_DBTN31_n6225 A2=n6171 B1=FE_OFN9125_n3656
+ B2=n6177
XU5740 AOI12HS $PINS O=n6393 A1=n6392 B1=n6390 B2=n7280
XU5742 OA12 $PINS O=n5666 A1=n5653 B1=n2891 B2=FE_OFN9129_weight_0_r_3
XU5743 MOAI1S $PINS O=n7223 A1=FE_OFN1648_n9466 A2=n7209 B1=FE_OFN1545_n7188
+ B2=n7187
XU5745 XNR2HS $PINS O=n6349 I1=n6342 I2=n6340
XU5746 OAI22S $PINS O=n7206 A1=FE_OFN1648_n9466 A2=n6664 B1=FE_OFN1641_n9465
+ B2=n7210
XU5747 XOR2HS $PINS O=n3467 I1=n3468 I2=n4290
XU5748 OAI12HS $PINS O=n3110 A1=n4299 B1=n4300 B2=n4301
XU5749 AOI22S $PINS O=n6671 A1=n6666 A2=FE_OFN1300_weight_0_r_0 B1=n5663
+ B2=n6665
XU5750 ND2P $PINS O=n3346 I1=n3348 I2=n3253
XU5751 INV1S $PINS O=n6921 I=n6932
XU5753 XOR2HS $PINS O=n4445 I1=FE_OFN1661_weight_2_r_9 I2=data_2_r[25]
XU5754 NR2P $PINS O=n6097 I1=n6052 I2=n6051
XU5755 OAI22S $PINS O=n4450 A1=n4431 A2=FE_OFN1479_n4623 B1=FE_OFN1608_n4622
+ B2=n4435
XU5756 MOAI1H $PINS O=n4548 A1=FE_OFN1693_n4596 A2=n4447 B1=n3783
+ B2=FE_OFN9141_n3387
XU5757 AN2 $PINS O=n2810 I1=n9361 I2=n9360
XU5758 NR2 $PINS O=n3156 I1=n5955 I2=n3157
XU5759 NR2 $PINS O=n3539 I1=n4031 I2=n4032
XU5760 MOAI1 $PINS O=n4031 A1=n4021 A2=FE_OFN1672_n4077 B1=n4020
+ B2=FE_OFN1451_n2589
XU5761 INV1S $PINS O=n4011 I=n4020
XU5762 NR2 $PINS O=n3246 I1=n6674 I2=n9457
XU5765 MAOI1H $PINS O=n5496 A1=FE_OFN1516_n5494 A2=n5495 B1=FE_OFN1516_n5494
+ B2=n5913
XU5766 ND2 $PINS O=n5707 I1=n3357 I2=n5706
XU5767 ND2 $PINS O=n2812 I1=n4513 I2=n4514
XU5768 ND2 $PINS O=n2813 I1=n4513 I2=n4512
XU5769 ND2 $PINS O=n2814 I1=n4514 I2=n4512
XU5770 ND3 $PINS O=n4519 I1=n2814 I2=n2813 I3=n2812
XU5771 AN2 $PINS O=n4514 I1=FE_OFN1414_data_2_r_17 I2=n4532
XU5772 OR2 $PINS O=n8968 I1=n4519 I2=n4518
XU5773 ND2 $PINS O=n3334 I1=n8963 I2=n8964
XU5774 INV1S $PINS O=n4078 I=n4074
XU5776 OAI22S $PINS O=n4029 A1=n3942 A2=FE_OFN1672_n4077 B1=FE_OFN1598_n4076
+ B2=n4021
XU5777 FA1 $PINS S=n9242 CO=n9245 A=n9234 B=n9233 CI=n9232
XU5778 XNR3 $PINS O=n2815 I1=n4113 I2=n4111 I3=n3128
XU5779 XOR2HS $PINS O=n3121 I1=n3629 I2=n3631
XU5780 INV2 $PINS O=n3629 I=n4034
XU5781 INV1S $PINS O=n3903 I=n9220
XU5782 XOR2HS $PINS O=pConv_1/product_1_w[12] I1=n2816 I2=n9303
XU5783 AN2 $PINS O=n2816 I1=n3583 I2=n9299
XU5784 XNR2HS $PINS O=n5775 I1=weight_1_r[7] I2=data_1_r[3]
XU5785 MOAI1S $PINS O=n4088 A1=FE_OFN1673_n4077 A2=n4060 B1=n4059
+ B2=FE_OFN1452_n2589
XU5788 AOI22S $PINS O=n5844 A1=n5832 A2=FE_OFN1357_weight_1_r_0
+ B1=FE_OFN1518_n5608 B2=n5815
XU5789 FA1 $PINS S=n7160 CO=n7153 A=n7157 B=n7156 CI=n7155
XU5791 OAI22S $PINS O=n7211 A1=FE_OFN1630_n6658 A2=n6655 B1=FE_OFN1550_n9457
+ B2=n7194
XU5792 MOAI1H $PINS O=n6157 A1=FE_OFN1530_n6178 A2=FE_DBTN31_n6225
+ B1=FE_OFN9125_n3656 B2=n6159
XU5793 MOAI1S $PINS O=n6697 A1=n7180 A2=n6683 B1=FE_OFN1523_n5640 B2=n6682
XU5794 ND3 $PINS O=n4125 I1=n4124 I2=n4123 I3=n9253
XU5795 OAI12HS $PINS O=n3993 A1=n3689 B1=n3691 B2=n3692
XU5797 MOAI1 $PINS O=n3687 A1=n6735 A2=FE_OFN1647_n9466 B1=n6747 B2=n9465
XU5798 NR2P $PINS O=n9739 I1=n6902 I2=n6903
XU5799 MOAI1 $PINS O=n4113 A1=n3669 A2=FE_OCPN9769_FE_OFN1335_weight_1_r_9
+ B1=n3670 B2=n3674
XU5800 NR2 $PINS O=n3669 I1=n3670 I2=n3674
XU5801 MOAI1 $PINS O=n3674 A1=n3888 A2=FE_OFN1638_n9221 B1=n3887
+ B2=FE_OFN1557_FE_DBTN42_n3886
XU5802 XOR2HS $PINS O=n3816 I1=n5724 I2=n3820
XU5803 AOI22S $PINS O=n6052 A1=n6040 A2=weight_2_r[0] B1=n6012
+ B2=FE_OFN1457_n3162
XU5804 XNR2HS $PINS O=n6721 I1=n6718 I2=n6716
XU5805 XNR2HS $PINS O=n6034 I1=n6028 I2=n3392
XU5806 XNR2HS $PINS O=n3392 I1=n6027 I2=n6026
XU5807 ND2 $PINS O=n9239 I1=FE_OFN1329_weight_1_r_11 I2=n3904
XU5808 ND2 $PINS O=n6724 I1=n3712 I2=n3711
XU5810 XNR2HS $PINS O=n6266 I1=FE_OFN1448_n2033 I2=data_1_r[40]
XU5811 NR2P $PINS O=n3454 I1=n8831 I2=n8832
XU5813 AOI22S $PINS O=n7205 A1=n7192 A2=FE_OFN1300_weight_0_r_0 B1=n5663
+ B2=n7189
XU5814 ND2 $PINS O=n3219 I1=n7228 I2=n3329
XU5815 MAO222 $PINS O=n5813 A1=n5777 B1=n5776 C1=n3255
XU5816 OA12P $PINS O=n8833 A1=n6441 B1=n6442 B2=n6443
XU5817 MOAI1S $PINS O=n4456 A1=FE_OFN1479_n4623 A2=n4435 B1=n4460
+ B2=FE_OFN1474_n4495
XU5818 AOI12HS $PINS O=n8979 A1=n8983 B1=n8985 B2=n8981
XU5819 NR2P $PINS O=n7239 I1=n6378 I2=n6379
XU5820 AOI22S $PINS O=n6260 A1=n6251 A2=FE_OFN1315_weight_1_r_16
+ B1=FE_OFN1441_FE_DBTN9_n3607 B2=n6235
XU5821 ND2 $PINS O=n2826 I1=n7011 I2=n9606
XU5822 ND2P $PINS O=n3424 I1=n9557 I2=n9558
XU5823 MAO222 $PINS O=n5806 A1=n5788 B1=n5789 C1=n5790
XU5825 XNR2HS $PINS O=n2828 I1=n3230 I2=n6490
XU5826 XNR2HS $PINS O=n6487 I1=n6490 I2=n3230
XU5827 OAI22S $PINS O=n4373 A1=n4367 A2=FE_OFN1644_FE_DBTN11_n3387
+ B1=FE_OFN1605_n4596 B2=n4376
XU5828 XOR3 $PINS O=n6983 I1=n6966 I2=n6965 I3=n3302
XU5829 MOAI1S $PINS O=n4480 A1=n4479 A2=FE_OFN9142_n B1=n4478 B2=FE_OFN9142_n
XU5831 XOR2H $PINS O=n4360 I1=n4351 I2=n2830
XU5832 ND2 $PINS O=n2831 I1=n4351 I2=n4350
XU5833 ND2 $PINS O=n2832 I1=n4351 I2=n4349
XU5834 ND2 $PINS O=n2833 I1=n4350 I2=n4349
XU5835 ND3 $PINS O=n4147 I1=n2831 I2=n2833 I3=n2832
XU5836 ND2 $PINS O=n9062 I1=n4148 I2=n4147
XU5837 NR2 $PINS O=n3288 I1=n3505 I2=FE_OFN1612_n5691
XU5838 MOAI1S $PINS O=n4418 A1=FE_OFN1480_n4623 A2=n4397
+ B1=FE_OFN1392_weight_2_r_11 B2=FE_OFN1474_n4495
XU5839 NR2P $PINS O=n6520 I1=n4582 I2=n4583
XU5840 XOR2HS $PINS O=n9493 I1=n3172 I2=n3171
XU5841 XNR2HS $PINS O=n9484 I1=n3415 I2=n9474
XU5842 OAI22S $PINS O=n6611 A1=n6573 A2=n6531 B1=n6606 B2=n2727
XU5843 FA1 $PINS S=n6643 CO=n6645 A=n6636 B=n6635 CI=n6634
XU5845 NR2 $PINS O=n5953 I1=weight_2_r[6] I2=FE_OFN1401_weight_2_r_5
XU5846 MAO222 $PINS O=n5789 A1=n3382 B1=n5786 C1=n5787
XU5847 INV1S $PINS O=n6710 I=n6709
XU5848 MOAI1 $PINS O=n5864 A1=n5851 A2=FE_OFN1583_FE_DBTN6_n7135
+ B1=FE_DBTN16_n5612 B2=n5850
XU5849 OR2 $PINS O=n5489 I1=n2071 I2=n9411
XU5850 XOR2HS $PINS O=n6727 I1=n6737 I2=n6736
XU5851 XOR2HS $PINS O=n6698 I1=FE_OFN1296_weight_0_r_1 I2=data_0_r[7]
XU5852 ND2 $PINS O=n6801 I1=n6032 I2=n6031
XU5853 OAI112H $PINS O=n4197 A1=n3373 B1=n3372 C1=n3375
+ C2=FE_OFN1559_FE_DBTN41_n4329
XU5855 INV2 $PINS O=n5843 I=n5842
XU5856 OAI22S $PINS O=n5842 A1=FE_OFN1613_n5691 A2=n5817 B1=n5836
+ B2=FE_OFN1578_FE_DBTN10_n9120
XU5857 XOR2HS $PINS O=n2837 I1=n4569 I2=n4568
XU5858 ND2 $PINS O=n2840 I1=n4569 I2=n4568
XU5860 XNR2HS $PINS O=n6013 I1=FE_OFN1398_weight_2_r_7 I2=data_2_r[6]
XU5861 XNR2HS $PINS O=n6006 I1=FE_OFN1400_weight_2_r_7 I2=data_2_r[5]
XU5862 AOI22S $PINS O=n2842 A1=n2055 A2=n9707 B1=FE_OFN1684_n5496 B2=n6505
XU5863 NR2 $PINS O=n3838 I1=n6737 I2=n6736
XU5864 NR2 $PINS O=n6736 I1=n3774 I2=n3773
XU5865 ND3P $PINS O=n9279 I1=n9277 I2=n9276 I3=n9278
XU5866 OAI22S $PINS O=n6425 A1=n6416 A2=FE_OFN1662_n5980 B1=FE_OFN1619_n6414
+ B2=n6413
XU5868 XNR2HS $PINS O=n6091 I1=FE_OFN1399_weight_2_r_7 I2=data_2_r[8]
XU5871 XOR2HS $PINS O=n3237 I1=n3240 I2=n6971
XU5872 XOR2HS $PINS O=n3231 I1=n6481 I2=n6482
XU5873 OAI22S $PINS O=n6481 A1=n6451 A2=FE_OFN1586_n1873 B1=FE_OFN1539_n6937
+ B2=n6456
XU5874 OAI22H $PINS O=n6958 A1=FE_OFN1622_n6448 A2=n6502 B1=FE_OFN1553_n9713
+ B2=n6943
XU5875 ND2 $PINS O=n3098 I1=n3191 I2=n2846
XU5876 ND2 $PINS O=n9764 I1=n6948 I2=n6949
XU5877 MAO222 $PINS O=n5901 A1=n5890 B1=n3099 C1=n5891
XU5878 OAI12H $PINS O=n6976 A1=n3238 B1=n3240 B2=n3239
XU5879 FA1 $PINS S=n3911 CO=n9247 A=n9242 B=n9241 CI=n9240
XU5880 AOI22S $PINS O=n5828 A1=n5815 A2=FE_OFN1357_weight_1_r_0 B1=n5762
+ B2=FE_OFN1518_n5608
XU5882 MOAI1S $PINS O=n4384 A1=FE_OFN1605_n4596 A2=n4382 B1=FE_OFN9140_n3387
+ B2=n3784
XU5883 MOAI1H $PINS O=n6630 A1=FE_OFN1543_n7067 A2=n3341 B1=n6618
+ B2=FE_OFN1571_FE_DBTN22_n3850
XU5884 XNR3 $PINS O=n4115 I1=n4111 I2=n4113 I3=n3128
XU5886 OA12 $PINS O=n9579 A1=n9582 B1=n9586 B2=n9580
XU5887 XOR2HS $PINS O=n5596 I1=data_2_r[2] I2=FE_OFN1407_weight_2_r_1
XU5888 ND2P $PINS O=n6514 I1=n6474 I2=n6475
XU5889 XNR2HP $PINS O=n6475 I1=n6509 I2=n3251
XU5890 FA1 $PINS S=n7098 CO=n7099 A=n7088 B=n7087 CI=n7086
XU5892 OAI22S $PINS O=n6310 A1=n6190 A2=FE_OFN1618_n6138 B1=n6189 B2=n2918
XU5893 INV1S $PINS O=n5614 I=n5714
XU5895 ND2P $PINS O=n6653 I1=FE_OFN1290_weight_0_r_5 I2=weight_0_r[6]
XU5896 NR2 $PINS O=n4127 I1=weight_2_r[22] I2=FE_OFN1367_weight_2_r_21
XU5897 NR2P $PINS O=n9332 I1=n3955 I2=n3956
XU5898 INV1S $PINS O=n3955 I=n3972
XU5899 OAI12H $PINS O=n5754 A1=n3354 B1=n3841 B2=n3840
XU5900 XOR2HS $PINS O=n5935 I1=FE_OFN1403_weight_2_r_5 I2=data_2_r[2]
XU5901 ND2P $PINS O=n3842 I1=n9144 I2=n3843
XU5902 ND2P $PINS O=n5887 I1=n9144 I2=n7120
XU5903 ND3 $PINS O=n3198 I1=n3815 I2=n7277 I3=n9146
XU5905 ND3 $PINS O=n8932 I1=n8931 I2=n8930 I3=n8929
XU5906 NR2 $PINS O=n6566 I1=weight_0_r[10] I2=FE_OFN1277_weight_0_r_9
XU5907 ND2 $PINS O=n6564 I1=FE_OFN1277_weight_0_r_9 I2=weight_0_r[10]
XU5909 AOI22S $PINS O=n6751 A1=n6729 A2=FE_OFN1300_weight_0_r_0
+ B1=FE_OFN1522_n5640 B2=n6728
XU5910 INV1S $PINS O=n6171 I=n6170
XU5911 AOI12HS $PINS O=n9400 A1=n9399 B1=n2849 B2=FE_OCPN9754_n6785
XU5912 ND3S $PINS O=n9393 I1=n2849 I2=FE_OCPN9754_n6785 I3=n9397
XU5913 OAI12HS $PINS O=n7286 A1=n9281 B1=n9283 B2=n2857
XU5914 ND2P $PINS O=n3834 I1=n9144 I2=n2211
XU5915 ND3 $PINS O=n3706 I1=n3205 I2=n3707 I3=n7126
XU5916 NR2 $PINS O=n9507 I1=n9509 I2=n9505
XU5917 ND3P $PINS O=n3109 I1=n3611 I2=n3612 I3=n3613
XU5918 XOR2HS $PINS O=n2861 I1=n9134 I2=n9133
XU5919 MAO222 $PINS O=n6614 A1=n3333 B1=n6607 C1=n6608
XU5920 AN2 $PINS O=n2862 I1=n9519 I2=n9518
XU5921 XOR2HS $PINS O=n6248 I1=n3503 I2=n2896
XU5922 NR2P $PINS O=n2863 I1=n3738 I2=n3739
XU5923 XNR2HS $PINS O=n5981 I1=FE_OFN1400_weight_2_r_7 I2=data_2_r[3]
XU5924 AOI12HS $PINS O=n6524 A1=n6523 B1=FE_OCPN9753_n6521 B2=n7257
XU5925 XNR2HS $PINS O=n3094 I1=n3325 I2=n3326
XU5926 ND2 $PINS O=n3744 I1=n2890 I2=n6058
XU5927 INV1S $PINS O=n3282 I=n4481
XU5928 MOAI1 $PINS O=n6004 A1=FE_OFN1435_FE_DBTN18_n6407 A2=n5995 B1=n1874
+ B2=n5994
XU5929 OAI22S $PINS O=n5587 A1=n5571 A2=FE_DBTN39_n3378 B1=n6103 B2=n5580
XU5931 AN2 $PINS O=n2866 I1=n9503 I2=n9502
XU5932 XOR2HS $PINS O=n4522 I1=FE_OFN1394_weight_2_r_9 I2=data_2_r[23]
XU5933 XOR2HS $PINS O=n4488 I1=weight_2_r[9] I2=data_2_r[20]
XU5934 AOI12HS $PINS O=n7124 A1=n9275 B1=FE_OFN1157_n4047 B2=n9274
XU5935 ND3 $PINS O=n9551 I1=n9549 I2=n6857 I3=n9548
XU5937 ND2 $PINS O=n3693 I1=n3694 I2=n3924
XU5938 NR2P $PINS O=n7253 I1=n4649 I2=n4650
XU5939 OR2 $PINS O=n2867 I1=n4520 I2=n4521
XU5942 ND2P $PINS O=n3828 I1=n3403 I2=FE_OFN9136_weight_1_r_3
XU5945 XOR2HS $PINS O=n6086 I1=weight_2_r[1] I2=weight_2_r[2]
XU5952 MOAI1H $PINS O=n2908 A1=n6703 A2=FE_OFN9130_weight_0_r_3
+ B1=FE_OFN9130_weight_0_r_3 B2=n5643
XU5953 XNR2HS $PINS O=n4535 I1=FE_OFN9143_n I2=data_2_r[21]
XU5954 ND3P $PINS O=n3409 I1=n3389 I2=n3411 I3=n3408
XU5955 NR2T $PINS O=n3657 I1=weight_1_r[20] I2=n6178
XU5957 INV1S $PINS O=n5466 I=n6213
XU5958 NR2P $PINS O=n9610 I1=n9609 I2=n9620
XU5959 XOR2HS $PINS O=n3381 I1=n5787 I2=n3382
XU5960 ND2P $PINS O=n3664 I1=n9068 I2=n3469
XU5961 NR2 $PINS O=n3468 I1=n4283 I2=n4282
XU5962 NR2 $PINS O=n3738 I1=weight_2_r[3] I2=n5574
XU5963 ND3P $PINS O=n9500 I1=n9499 I2=n9497 I3=n9498
XU5965 ND3 $PINS O=n3794 I1=n3780 I2=n3795 I3=n3781
XU5966 ND2P $PINS O=n9498 I1=n9522 I2=n9487
XU5967 INV1S $PINS O=n6659 I=n6752
XU5968 OAI12H $PINS O=n3060 A1=n8922 B1=n8929 B2=n8924
XU5969 ND2S $PINS O=n8930 I1=n8928 I2=n8927
XU5970 ND2S $PINS O=n3707 I1=n8928 I2=n7127
XU5972 ND3 $PINS O=n3611 I1=n2822 I2=n9750 I3=n9756
XU5973 ND3 $PINS O=n3622 I1=n9758 I2=n7129 I3=n9756
XU5974 ND3 $PINS O=n9744 I1=n2822 I2=n9733 I3=n9756
XU5975 OR2 $PINS O=n9817 I1=n9815 I2=n9816
XU5977 NR2 $PINS O=n7106 I1=n9615 I2=n7096
XU5979 INV2 $PINS O=n9625 I=n3091
XU5980 NR2P $PINS O=n3514 I1=n9629 I2=n3091
XU5981 ND2P $PINS O=n9614 I1=n9628 I2=n9605
XU5982 ND2P $PINS O=n9630 I1=n9628 I2=FE_DBTN5_n7246
XU5983 ND2P $PINS O=n7105 I1=n9628 I2=n7104
XU5984 NR2P $PINS O=n9612 I1=n9611 I2=n9610
XU5985 ND2P $PINS O=n9629 I1=n7093 I2=n7092
XU5986 ND3P $PINS O=n9631 I1=n2031 I2=n9626 I3=FE_DBTN5_n7246
XU5987 ND3P $PINS O=n9613 I1=n6651 I2=n9605 I3=n9626
XU5988 ND3P $PINS O=n9621 I1=n2031 I2=n9626 I3=n9618
XU5989 AOI12HS $PINS O=n9651 A1=n9649 B1=n6651 B2=n9650
XU5990 AOI12H $PINS O=n9643 A1=n9641 B1=n2031 B2=n9642
XU5992 NR2P $PINS O=n9497 I1=n9496 I2=n9495
XU5994 NR2 $PINS O=n9679 I1=n3307 I2=n3214
XU5995 XOR2HS $PINS O=n2902 I1=n9450 I2=n9449
XU5996 AN2 $PINS O=n2903 I1=n9624 I2=n9625
XU5997 NR2P $PINS O=n9605 I1=n9617 I2=n9609
XU5998 NR2 $PINS O=n3161 I1=FE_OFN1536_n6822 I2=n4230
XU5999 XNR2HS $PINS O=n7185 I1=FE_OCPN9755_FE_OFN1289_weight_0_r_5
+ I2=data_0_r[12]
XU6000 NR2 $PINS O=n3218 I1=n6751 I2=n6750
XU6001 AOI22S $PINS O=n6011 A1=n6005 A2=FE_OFN1410_weight_2_r_0 B1=n5989
+ B2=FE_OFN1457_n3162
XU6002 INV1S $PINS O=n6074 I=n6410
XU6004 ND2 $PINS O=n9366 I1=n9364 I2=n9363
XU6008 INV1S $PINS O=n4459 I=n4458
XU6009 MOAI1S $PINS O=n4457 A1=FE_OFN1443_FE_DBTN7_n4532 A2=n4458
+ B1=FE_OFN1433_FE_DBTN19_n4371 B2=n4434
XU6010 ND2P $PINS O=n9508 I1=n9522 I2=n3421
XU6011 ND2 $PINS O=n6056 I1=n4660 I2=n4661
XU6013 MOAI1H $PINS O=n6646 A1=n3105 A2=n3104 B1=n6638 B2=n6639
XU6015 MOAI1 $PINS O=n4313 A1=FE_OFN1601_n4195 A2=n4288 B1=FE_DBTN45_n6822
+ B2=n4307
XU6016 OR2 $PINS O=n8885 I1=n8883 I2=n8884
XU6018 OAI22H $PINS O=n4462 A1=n4438 A2=FE_OFN1693_n4596 B1=n4455
+ B2=FE_DBTN11_n3387
XU6019 OR2 $PINS O=n3204 I1=n7253 I2=n2003
XU6020 MOAI1 $PINS O=n6677 A1=n6660 A2=FE_OFN1704_n9443 B1=n6656
+ B2=FE_OFN9122_n2908
XU6021 INV2 $PINS O=n9379 I=n9371
XU6022 AOI22S $PINS O=n7074 A1=n7032 A2=FE_OFN1283_weight_0_r_8 B1=n5564
+ B2=n6542
XU6023 AOI22S $PINS O=n3864 A1=n6561 A2=weight_0_r[8] B1=FE_OFN1541_n7045
+ B2=n5546
XU6024 AOI22S $PINS O=n6617 A1=n6537 A2=FE_OFN1283_weight_0_r_8 B1=n5564
+ B2=n6604
XU6025 NR2 $PINS O=n9691 I1=n5560 I2=FE_OFN1541_n7045
XU6026 AOI22S $PINS O=n9692 A1=n5561 A2=weight_0_r[8] B1=FE_OFN1541_n7045
+ B2=n2771
XU6027 NR3 $PINS O=n3509 I1=FE_OFN1368_weight_2_r_21 I2=n4202
+ I3=FE_OFN1371_weight_2_r_19
XU6028 XNR2HS $PINS O=n6613 I1=n2899 I2=n3216
XU6030 NR2 $PINS O=n3439 I1=weight_2_r[13] I2=n3438
XU6031 OAI12HS $PINS O=n4662 A1=n8920 B1=n8919 B2=n8922
XU6032 AOI22S $PINS O=n4261 A1=n4254 A2=FE_OFN1378_weight_2_r_16 B1=n4152
+ B2=n4248
XU6038 XOR2HS $PINS O=n6728 I1=FE_OFN1296_weight_0_r_1 I2=data_0_r[9]
XU6039 XOR2HS $PINS O=n5660 I1=FE_OFN1297_weight_0_r_1 I2=data_0_r[2]
XU6040 XNR2H $PINS O=n2918 I1=FE_OFN1309_weight_1_r_21 I2=weight_1_r[22]
XU6042 XNR2HS $PINS O=n3952 I1=data_1_r[18] I2=FE_DBTN44_weight_1_r_11
XU6043 XNR2HS $PINS O=n4059 I1=data_1_r[30]
+ I2=FE_OCPN9731_FE_OFN1327_weight_1_r_11
XU6049 AOI22S $PINS O=n4549 A1=n4445 A2=FE_OFN1396_weight_2_r_8 B1=n4523
+ B2=FE_OFN1477_n4591
XU6052 MOAI1 $PINS O=n2932 A1=n4184 A2=FE_OFN1463_n4128 B1=n4182
+ B2=FE_OFN1463_n4128
XU6053 MOAI1 $PINS O=n4345 A1=n2932 A2=n4330 B1=FE_OFN1471_n4329 B2=n4328
XU6054 OAI22S $PINS O=n4289 A1=n4281 A2=n2932 B1=FE_OFN1559_FE_DBTN41_n4329
+ B2=n4293
XU6055 MOAI1H $PINS O=n4256 A1=n4253 A2=FE_OFN1588_n2932 B1=n4259
+ B2=FE_OFN1471_n4329
XU6059 AOI22S $PINS O=n4097 A1=n4061 A2=FE_OFN1338_weight_1_r_8
+ B1=FE_OFN1461_n3961 B2=n4053
XU6060 AOI22S $PINS O=n4028 A1=n4013 A2=FE_OFN1338_weight_1_r_8
+ B1=FE_OFN1461_n3961 B2=n4012
XU6064 MOAI1 $PINS O=n6121 A1=FE_OFN1436_FE_DBTN18_n6407 A2=n6084 B1=n2890
+ B2=n6099
XU6065 NR2 $PINS O=n3398 I1=FE_DBTN18_n6407 I2=FE_OFN1532_n6412
XU6067 MOAI1H $PINS O=n4180 A1=FE_OFN1577_FE_DBTN17_n6819 A2=n4173
+ B1=FE_OFN1592_n3599 B2=FE_OFN1368_weight_2_r_21
XU6068 MOAI1 $PINS O=n4276 A1=FE_DBTN17_n6819 A2=n4277 B1=FE_OFN1594_n3599
+ B2=n4258
XU6069 MOAI1 $PINS O=n7047 A1=FE_OFN1544_n7067 A2=n7028 B1=n7027
+ B2=FE_OFN1571_FE_DBTN22_n3850
XU6070 OAI12HS $PINS O=n9231 A1=FE_OFN1323_weight_1_r_13
+ B1=FE_OFN1557_FE_DBTN42_n3886 B2=n9216
XU6071 ND2 $PINS O=n3298 I1=FE_OFN1556_FE_DBTN42_n3886 I2=n4018
XU6072 AOI22S $PINS O=n6951 A1=n6917 A2=FE_OFN1266_weight_0_r_16 B1=n6941
+ B2=FE_OFN1696_n5491
XU6073 AOI22S $PINS O=n5767 A1=n5762 A2=FE_OFN1357_weight_1_r_0 B1=n5628
+ B2=n5761
XU6074 AOI22S $PINS O=n5858 A1=n5834 A2=FE_OFN1357_weight_1_r_0
+ B1=FE_OFN1518_n5608 B2=n5832
XU6075 ND2 $PINS O=n3256 I1=n5768 I2=FE_OFN1439_FE_DBTN16_n5612
XU6076 MOAI1 $PINS O=n5820 A1=FE_OFN1585_FE_DBTN6_n7135 A2=n5822 B1=n5759
+ B2=FE_OFN1439_FE_DBTN16_n5612
XU6077 NR2 $PINS O=n5553 I1=FE_OFN1456_n2771 I2=FE_OFN1542_n7067
XU6078 NR2 $PINS O=n3413 I1=FE_OFN1543_n7067 I2=n3286
XU6094 MUX2S $PINS O=o_data[10] S=FE_OFN1214_n5429 A=conv[10] B=o_data_temp[10]
XU6095 MUX2S $PINS O=o_data[9] S=FE_OFN1214_n5429 A=conv[9] B=o_data_temp[9]
XU6096 MUX2S $PINS O=o_data[11] S=FE_OFN1212_n5429 A=conv[11] B=o_data_temp[11]
XU6097 MUX2S $PINS O=o_data[12] S=FE_OFN1212_n5429 A=conv[12] B=o_data_temp[12]
XU6098 MUX2S $PINS O=o_data[13] S=FE_OFN1212_n5429 A=conv[13] B=o_data_temp[13]
XU6099 MUX2S $PINS O=o_data[8] S=FE_OFN1217_n5429 A=conv[8] B=o_data_temp[8]
XU6100 MUX2 $PINS O=o_data[14] S=FE_OFN1212_n5429 A=conv[14] B=o_data_temp[14]
XU6101 OAI12HS $PINS O=n4751 A1=n4749 B1=n2967 B2=n4750
XU6102 OAI12HS $PINS O=n4743 A1=n4741 B1=n2967 B2=n4742
XU6103 AOI12HS $PINS O=n4885 A1=n4711 B1=n4765 B2=n4712
XU6104 OAI12HS $PINS O=n4973 A1=n4971 B1=n2968 B2=n4972
XU6105 OAI12HS $PINS O=n4965 A1=n4963 B1=n2968 B2=n4964
XU6106 AOI12HS $PINS O=n5107 A1=n4933 B1=n4987 B2=n4934
XU6107 XNR2HS $PINS O=n4467 I1=FE_OFN1472_n4404 I2=FE_OFN1414_data_2_r_17
XU6108 OAI12HS $PINS O=n4781 A1=n4779 B1=FE_DBTN15_n4765 B2=n4780
XU6109 OAI12HS $PINS O=n5003 A1=n5001 B1=FE_DBTN14_n4987 B2=n5002
XU6111 OAI12HS $PINS O=n5225 A1=n5223 B1=FE_OFN1134_FE_DBTN13_n5209 B2=n5224
XU6112 OAI12HS $PINS O=n5209 A1=n5131 B1=n5274 B2=n5132
XU6113 NR2 $PINS O=n6076 I1=n6063 I2=FE_OFN1440_FE_DBTN12_weight_2_r_7
XU6116 ND3 $PINS O=n9372 I1=FE_OFN1240_n6309 I2=n9379 I3=n9376
XU6119 XNR2HS $PINS O=n6824 I1=data_2_r[46] I2=FE_OFN1366_weight_2_r_23
XU6120 XNR2HS $PINS O=n9045 I1=data_2_r[47] I2=FE_OFN1366_weight_2_r_23
XU6121 XNR2HS $PINS O=n4146 I1=data_2_r[45] I2=FE_OFN9147_n
XU6122 MOAI1 $PINS O=n3861 A1=FE_OFN1602_n4195 A2=n4333 B1=FE_DBTN45_n6822
+ B2=n4332
XU6123 XNR2HS $PINS O=n4019 I1=FE_OFN1325_weight_1_r_13 I2=data_1_r[22]
XU6124 XNR2HS $PINS O=n4071 I1=FE_OFN1326_weight_1_r_13 I2=data_1_r[25]
XU6125 XNR2HS $PINS O=n3996 I1=FE_OFN1326_weight_1_r_13 I2=data_1_r[24]
XU6126 XOR2HS $PINS O=n4018 I1=FE_OFN1325_weight_1_r_13 I2=data_1_r[21]
XU6127 XOR2HS $PINS O=n6251 I1=FE_OFN1313_weight_1_r_17 I2=data_1_r[41]
XU6128 ND3S $PINS O=n3957 I1=FE_OFN1451_n2589 I2=FE_OFN1247_n9348
+ I3=FE_OFN1426_FE_DBTN44_weight_1_r_11
XU6130 MOAI1H $PINS O=n4545 A1=FE_OFN1605_n4596 A2=n4525 B1=FE_OFN9141_n3387
+ B2=n4524
XU6131 XOR2HS $PINS O=n3387 I1=FE_OFN1472_n4404 I2=weight_2_r[14]
XU6134 ND2 $PINS O=n9725 I1=FE_OFN1248_weight_0_r_23 I2=data_0_r[37]
XU6135 XNR2HS $PINS O=n6464 I1=weight_0_r[23] I2=data_0_r[36]
XU6136 XOR2HS $PINS O=n5721 I1=FE_OFN1354_weight_1_r_1 I2=data_1_r[7]
XU6137 XNR2HS $PINS O=n6263 I1=weight_1_r[23] I2=data_1_r[36]
XU6138 OAI22S $PINS O=n6075 A1=n6064 A2=FE_OFN1663_n5980 B1=FE_OFN1619_n6414
+ B2=n6072
XU6139 XNR2HS $PINS O=n4066 I1=FE_OFN1320_weight_1_r_15 I2=data_1_r[24]
XU6140 XNR2HS $PINS O=n3519 I1=data_1_r[20] I2=FE_OFN1321_weight_1_r_15
XU6141 NR2 $PINS O=n3289 I1=FE_OFN1578_FE_DBTN10_n9120 I2=n5764
XU6142 XOR2HS $PINS O=n6410 I1=FE_OFN1402_weight_2_r_5 I2=data_2_r[15]
XU6143 AOI22H $PINS O=n6279 A1=n6271 A2=FE_OFN1315_weight_1_r_16
+ B1=FE_OFN1442_FE_DBTN9_n3607 B2=n6262
XU6144 AOI22S $PINS O=n6332 A1=n6187 A2=FE_DBTN2_weight_1_r_16
+ B1=FE_OFN1442_FE_DBTN9_n3607 B2=n6319
XU6145 OAI12HS $PINS O=n4481 A1=n3283 B1=n4623 B2=n4486
XU6146 NR2 $PINS O=n5911 I1=FE_DBTN29_data_0_r_33 I2=n9713
XU6147 XNR2HS $PINS O=n3949 I1=FE_OFN1426_FE_DBTN44_weight_1_r_11 I2=n3927
XU6148 XNR2HS $PINS O=n7040 I1=FE_OFN1269_weight_0_r_15 I2=data_0_r[26]
XU6149 XNR2HS $PINS O=n6606 I1=weight_0_r[15] I2=data_0_r[19]
XU6150 INV3 $PINS O=n6178 I=FE_OFN1310_weight_1_r_21
XU6154 INV1S $PINS O=n9696 I=FE_OFN1281_weight_0_r_8
XU6156 XOR2HS $PINS O=n6012 I1=data_2_r[12] I2=FE_OFN1408_weight_2_r_1
XU6157 XOR2HS $PINS O=n6040 I1=data_2_r[13] I2=FE_OFN1408_weight_2_r_1
XU6158 XOR2HS $PINS O=n5578 I1=data_2_r[5] I2=FE_OFN1407_weight_2_r_1
XU6161 NR2 $PINS O=n3571 I1=FE_OFN1564_FE_DBTN36_n9707 I2=n6466
XU6163 AOI22S $PINS O=n9116 A1=n4150 A2=weight_2_r[16] B1=FE_OFN1468_n4306
+ B2=FE_DBTN30_data_2_r_33
XU6170 AOI22S $PINS O=n8991 A1=n4500 A2=weight_2_r[8] B1=FE_OFN1666_n4591
+ B2=FE_OFN1546_n8995
XU6172 XNR2HS $PINS O=n5760 I1=data_1_r[10] I2=FE_OFN1348_weight_1_r_3
XU6175 MOAI1 $PINS O=n3985 A1=n9221 A2=n3914 B1=FE_OFN1556_FE_DBTN42_n3886
+ B2=n3977
XU6176 MOAI1 $PINS O=n4099 A1=FE_OFN1637_n9221 A2=n4071
+ B1=FE_OFN1558_FE_DBTN42_n3886 B2=n3997
XU6177 AOI13HS $PINS O=n3316 A1=weight_0_r[11] B1=n7006 B2=n6576
+ B3=FE_OFN9748_weight_0_r_13
XU6178 OAI12HS $PINS O=n9055 A1=FE_OFN1370_weight_2_r_21 B1=FE_OFN1654_n3599
+ B2=n6819
XU6179 AOI13HS $PINS O=n4203 A1=FE_OFN1462_n4128 B1=n4202 B2=n4201
+ B3=FE_OFN1368_weight_2_r_21
XU6180 INV3 $PINS O=n4145 I=FE_OFN1370_weight_2_r_21
XU6184 MAO222 $PINS O=n3536 A1=n6589 B1=n6590 C1=n3242
XU6185 NR2 $PINS O=n6589 I1=n3864 I2=n6570
XU6186 INV2 $PINS O=n6597 I=n6596
XU6187 XNR2HS $PINS O=n5807 I1=n3035 I2=n5812
XU6188 XOR2HS $PINS O=n7036 I1=FE_OFN1277_weight_0_r_9 I2=weight_0_r[10]
XU6190 MOAI1S $PINS O=n4168 A1=n7115 A2=n4166 B1=FE_OFN1470_n4306 B2=n4165
XU6191 XNR2HS $PINS O=n3520 I1=n6430 I2=n3521
XU6192 ND2F $PINS O=n7103 I1=n2069 I2=n3032
XU6193 XNR2HS $PINS O=n6434 I1=n6425 I2=n3394
XU6194 ND2 $PINS O=n8828 I1=n6438 I2=n6437
XU6195 XOR2HS $PINS O=n6747 I1=FE_OFN9128_weight_0_r_3 I2=data_0_r[8]
XU6196 XOR2HS $PINS O=n6543 I1=FE_OFN1269_weight_0_r_15 I2=data_0_r[23]
XU6197 NR2 $PINS O=n3364 I1=n3366 I2=n4309
XU6198 NR2F $PINS O=n3484 I1=n6364 I2=n6365
XU6200 INV1S $PINS O=n9433 I=FE_OFN1358_data_1_r_33
XU6201 FA1 $PINS S=n4652 CO=n4658 A=n4641 B=n4640 CI=n4639
XU6202 XNR2HS $PINS O=n5805 I1=n5788 I2=n3034
XU6203 XNR2HS $PINS O=n3034 I1=n5790 I2=n5789
XU6204 INV1S $PINS O=n5759 I=n5758
XU6205 NR2 $PINS O=n5724 I1=FE_OFN1360_data_1_r_1 I2=FE_DBTN10_n9120
XU6206 OR2P $PINS O=n9182 I1=n5719 I2=n5720
XU6207 XOR2HS $PINS O=n9120 I1=weight_1_r[6] I2=FE_OFN1343_weight_1_r_5
XU6208 AOI22S $PINS O=n6108 A1=n6087 A2=weight_2_r[0] B1=n6040
+ B2=FE_OFN1457_n3162
XU6209 NR2 $PINS O=n5527 I1=n5525 I2=n5524
XU6210 NR2P $PINS O=n9769 I1=n6976 I2=n6977
XU6211 NR2 $PINS O=n6092 I1=n2059 I2=n3537
XU6212 XNR2HS $PINS O=n3041 I1=n6111 I2=n6110
XU6213 MOAI1 $PINS O=n6135 A1=n3043 A2=n3042 B1=n6110 B2=n6111
XU6214 NR2 $PINS O=n3043 I1=n6111 I2=n6110
XU6215 MOAI1 $PINS O=n5992 A1=FE_OFN1435_FE_DBTN18_n6407 A2=n5993 B1=n2890
+ B2=n5984
XU6216 XNR3 $PINS O=n6001 I1=n3319 I2=n5991 I3=n3320
XU6218 MAO222 $PINS O=n7229 A1=n7223 B1=n7224 C1=n3044
XU6219 OA12P $PINS O=n3624 A1=n9779 B1=n9778 B2=n9784
XU6220 ND2 $PINS O=n9539 I1=n7235 I2=n7236
XU6221 ND3P $PINS O=n9506 I1=n2751 I2=n3421 I3=n9520
XU6225 NR2 $PINS O=n6809 I1=n6034 I2=n6033
XU6226 INV1S $PINS O=n4193 I=n4191
XU6227 INV1S $PINS O=n5839 I=n5850
XU6228 ND2 $PINS O=n7119 I1=n7117 I2=n6442
XU6229 NR2 $PINS O=n3185 I1=n4216 I2=n3769
XU6230 INV1S $PINS O=n6412 I=weight_2_r[5]
XU6231 ND3 $PINS O=n3191 I1=n9767 I2=n2822 I3=n9765
XU6232 ND2 $PINS O=n6949 I1=n3051 I2=n3050
XU6233 ND2 $PINS O=n3050 I1=n6974 I2=n6975
XU6234 ND2 $PINS O=n3051 I1=n6973 I2=n3052
XU6235 MOAI1 $PINS O=n6945 A1=FE_OFN1685_n5496 A2=n3529 B1=n6913 B2=n9707
XU6239 NR2 $PINS O=n4449 I1=n4567 I2=n4433
XU6240 ND2 $PINS O=n6556 I1=n3081 I2=n3080
XU6241 INV1S $PINS O=n3948 I=n3947
XU6242 NR2T $PINS O=n9520 I1=n9529 I2=n7237
XU6243 AOI22S $PINS O=n6741 A1=n6673 A2=FE_OFN1300_weight_0_r_0
+ B1=FE_OFN1522_n5640 B2=n6729
XU6244 ND2 $PINS O=n5930 I1=n5925 I2=n5924
XU6245 XNR2HS $PINS O=n4577 I1=n4440 I2=n4441
XU6246 ND3P $PINS O=n3558 I1=n9175 I2=n9172 I3=n9174
XU6247 XNR2HS $PINS O=n5651 I1=n6680 I2=n3056
XU6248 AOI22S $PINS O=n4614 A1=n4412 A2=FE_OFN1397_weight_2_r_8
+ B1=FE_OFN1475_n4591 B2=n4593
XU6249 XOR2HS $PINS O=n5465 I1=FE_OFN1308_weight_1_r_21
+ I2=FE_OFN1358_data_1_r_33
XU6250 INV1S $PINS O=n5684 I=n5696
XU6251 INV1S $PINS O=n3300 I=n9068
XU6252 MOAI1 $PINS O=n3857 A1=n3102 A2=n3800 B1=FE_OFN1520_n5608 B2=n5620
XU6253 NR2 $PINS O=n3507 I1=n4274 I2=FE_OFN1702_n6822
XU6254 NR2F $PINS O=n9640 I1=n3884 I2=n3883
XU6255 OR2 $PINS O=n8992 I1=n8990 I2=n8991
XU6256 INV1S $PINS O=n6683 I=n6698
XU6257 AOI22S $PINS O=n5778 A1=n5761 A2=FE_OFN1357_weight_1_r_0 B1=n5628
+ B2=n5774
XU6258 ND2P $PINS O=n9390 I1=n6305 I2=n6304
XU6259 INV1S $PINS O=n6288 I=n6287
XU6260 ND2 $PINS O=n8840 I1=n8835 I2=n8834
XU6261 ND2 $PINS O=n8848 I1=n8842 I2=n8843
XU6263 INV1S $PINS O=n3458 I=n6163
XU6264 OAI22S $PINS O=n7021 A1=n7008 A2=FE_OFN1626_n6531 B1=n7007
+ B2=FE_OFN1454_n2727
XU6265 OAI12H $PINS O=n9671 A1=n9677 B1=n9680 B2=n9679
XU6266 XOR2HS $PINS O=n4517 I1=n4516 I2=n4515
XU6268 ND2 $PINS O=n5686 I1=FE_OFN1343_weight_1_r_5 I2=weight_1_r[6]
XU6269 AOI22S $PINS O=n4547 A1=n4523 A2=FE_OFN1396_weight_2_r_8 B1=n4522
+ B2=n4503
XU6270 XNR2HS $PINS O=n3516 I1=n6485 I2=n6484
XU6271 AOI22S $PINS O=n6454 A1=n6457 A2=FE_OFN1265_weight_0_r_16 B1=n5907
+ B2=FE_OFN1698_n5491
XU6272 XNR2HS $PINS O=n3768 I1=n3769 I2=n4216
XU6273 INV1S $PINS O=n5893 I=n5907
XU6274 MOAI1S $PINS O=n6044 A1=n6019 A2=FE_OFN1129_FE_DBTN39_n3378
+ B1=FE_OFN1529_n6086 B2=n6048
XU6276 ND2P $PINS O=n3453 I1=n3449 I2=n3454
XU6277 ND2P $PINS O=n3626 I1=n9755 I2=n7129
XU6278 OAI12HP $PINS O=n6217 A1=n9416 B1=n9419 B2=n9418
XU6279 NR2 $PINS O=n5605 I1=n5593 I2=n5594
XU6280 XNR2HS $PINS O=n4102 I1=n3698 I2=n3696
XU6281 NR2 $PINS O=n3074 I1=n4097 I2=n4056
XU6282 INV1S $PINS O=n4055 I=n4054
XU6283 MOAI1 $PINS O=n4343 A1=FE_OFN1659_n4331 A2=n4136 B1=FE_OFN1471_n4329
+ B2=FE_OFN1462_n4128
XU6284 XNR2HS $PINS O=n3620 I1=n6590 I2=n3242
XU6285 INV1S $PINS O=n5485 I=n5483
XU6286 INV1S $PINS O=n4151 I=n4150
XU6287 INV1S $PINS O=n4472 I=n4522
XU6288 OA12 $PINS O=n9110 A1=n9112 B1=n9117 B2=n9111
XU6289 ND3 $PINS O=n6993 I1=n3622 I2=n3626 I3=n9740
XU6290 XNR2HS $PINS O=n3079 I1=n6633 I2=n6632
XU6291 ND2 $PINS O=n3080 I1=n6632 I2=n6633
XU6292 AOI22S $PINS O=n4221 A1=n4212 A2=FE_OFN1377_weight_2_r_16 B1=n4194
+ B2=FE_OFN1467_n4306
XU6293 MOAI1S $PINS O=n7224 A1=n7185 A2=FE_OFN1580_FE_DBTN8_n9443
+ B1=FE_OFN9122_n2908 B2=n7208
XU6294 XNR2HS $PINS O=n3082 I1=n4227 I2=n4228
XU6295 MOAI1 $PINS O=n4266 A1=n3084 A2=n3083 B1=n4228 B2=n4227
XU6296 OAI12HS $PINS O=n3085 A1=n6427 B1=n6429 B2=n6428
XU6297 XNR2HS $PINS O=n3521 I1=n6432 I2=n6431
XU6298 INV1S $PINS O=n3087 I=n6429
XU6299 ND3P $PINS O=n9261 I1=n9260 I2=n9259 I3=n9258
XU6300 ND2 $PINS O=n9243 I1=n3273 I2=n3272
XU6301 MOAI1 $PINS O=n5950 A1=n8889 A2=n5934 B1=n5933 B2=FE_OFN1458_n3162
XU6302 INV2 $PINS O=n9665 I=n3616
XU6303 INV1S $PINS O=n4391 I=n4416
XU6304 MOAI1 $PINS O=n6482 A1=n6450 A2=FE_OFN1564_FE_DBTN36_n9707
+ B1=FE_OFN1683_n5496 B2=n6449
XU6305 XNR2HS $PINS O=n4572 I1=n3782 I2=n3094
XU6306 NR2F $PINS O=n9274 I1=n7285 I2=n4122
XU6308 MOAI1H $PINS O=n5612 A1=n5611 A2=FE_OCPN9762_FE_OFN9133_weight_1_r_3
+ B1=n5610 B2=FE_OCPN9762_FE_OFN9133_weight_1_r_3
XU6309 OAI12HS $PINS O=n3393 A1=n4262 B1=n3750 B2=n4263
XU6310 OR2 $PINS O=n9693 I1=n9691 I2=n9692
XU6312 MOAI1S $PINS O=n6078 A1=n6062 A2=FE_OFN1128_FE_DBTN39_n3378
+ B1=weight_2_r[3] B2=FE_OFN1528_n6086
XU6313 INV1S $PINS O=n3254 I=n3255
XU6314 OAI12HS $PINS O=n3099 A1=n3100 B1=n5498 B2=FE_OFN1564_FE_DBTN36_n9707
XU6315 ND2 $PINS O=n3100 I1=FE_OFN1683_n5496 I2=n5497
XU6316 OAI12H $PINS O=n6331 A1=n3106 B1=FE_OFN1618_n6138 B2=n6321
XU6317 ND2 $PINS O=n3106 I1=FE_OFN1656_n6322 I2=n6188
XU6318 OR2P $PINS O=n8832 I1=n6443 I2=n6436
XU6319 MOAI1 $PINS O=n5665 A1=FE_OFN1655_n5640 A2=n5662 B1=n5661
+ B2=weight_0_r[0]
XU6320 OAI12HP $PINS O=n3582 A1=n5924 B1=n7242 B2=n5923
XU6321 OAI22S $PINS O=n6116 A1=n6070 A2=FE_OFN1663_n5980 B1=FE_OFN1619_n6414
+ B2=n6069
XU6322 ND2 $PINS O=n9267 I1=n9266 I2=n9275
XU6323 ND3P $PINS O=n3788 I1=n8926 I2=n2596 I3=n3792
XU6325 XNR2HS $PINS O=n3931 I1=FE_OFN1328_weight_1_r_11 I2=data_1_r[21]
XU6326 XOR2HS $PINS O=n6073 I1=FE_OFN1402_weight_2_r_5 I2=data_2_r[14]
XU6327 NR2 $PINS O=n9790 I1=n2072 I2=n5919
XU6328 NR2 $PINS O=n6118 I1=n6108 I2=n6107
XU6329 INV1S $PINS O=n7120 I=n7165
XU6330 INV1S $PINS O=n4166 I=n4174
XU6331 ND2 $PINS O=n5889 I1=n7162 I2=n5703
XU6332 ND2 $PINS O=n7269 I1=n7267 I2=n7266
XU6333 ND2 $PINS O=n4478 I1=n4477 I2=n4476
XU6334 XNR2HS $PINS O=n3131 I1=n3132 I2=n4250
XU6336 INV2 $PINS O=n9794 I=n3772
XU6337 OAI12HP $PINS O=n8928 A1=n3885 B1=n2003 B2=n4653
XU6338 XNR2HS $PINS O=n3730 I1=n3733 I2=n6076
XU6340 INV1S $PINS O=n9534 I=n9530
XU6341 MOAI1S $PINS O=n6095 A1=FE_OFN1128_FE_DBTN39_n3378 A2=n6066 B1=n6065
+ B2=FE_OFN1528_n6086
XU6342 INV1S $PINS O=n3652 I=n6218
XU6343 AOI22S $PINS O=n4567 A1=n4436 A2=FE_OFN1397_weight_2_r_8
+ B1=FE_OFN1477_n4591 B2=n4445
XU6344 XNR2HS $PINS O=n6490 I1=n3349 I2=n3231
XU6345 AOI22S $PINS O=n6244 A1=n6235 A2=FE_OFN1315_weight_1_r_16
+ B1=FE_OFN1441_FE_DBTN9_n3607 B2=n6219
XU6346 AOI22S $PINS O=n6270 A1=n6262 A2=FE_OFN1315_weight_1_r_16
+ B1=FE_OFN1441_FE_DBTN9_n3607 B2=n6251
XU6347 NR2T $PINS O=n9756 I1=n3145 I2=n3627
XU6348 OR2T $PINS O=n3627 I1=n7265 I2=n7268
XU6349 ND2 $PINS O=n9738 I1=n6903 I2=n6902
XU6351 INV1S $PINS O=n3319 I=n5992
XU6352 ND2 $PINS O=n9081 I1=n4272 I2=n4271
XU6353 AOI22S $PINS O=n6588 A1=n6583 A2=n2791 B1=n6584
+ B2=FE_OFN1282_weight_0_r_8
XU6355 XNR2HS $PINS O=n3230 I1=n6492 I2=n6491
XU6356 XOR2HS $PINS O=n3117 I1=n3384 I2=n3858
XU6358 XOR2HS $PINS O=n6621 I1=FE_OFN1275_weight_0_r_11 I2=data_0_r[24]
XU6360 MOAI1 $PINS O=n4091 A1=FE_OFN1597_n3897 A2=n3899 B1=n3898
+ B2=FE_OFN1459_n3428
XU6361 INV1S $PINS O=n3214 I=n5568
XU6362 INV1S $PINS O=n6620 I=n6618
XU6363 INV1S $PINS O=n3888 I=n3889
XU6365 ND2 $PINS O=n7256 I1=n4581 I2=n4580
XU6366 NR2T $PINS O=n9059 I1=n6815 I2=n3122
XU6367 ND2P $PINS O=n7242 I1=n4358 I2=n4357
XU6368 AOI12H $PINS O=n7238 A1=n9522 B1=n2751 B2=n9520
XU6370 AOI22S $PINS O=n6096 A1=n6089 A2=weight_2_r[0] B1=FE_OFN1457_n3162
+ B2=n6087
XU6371 XOR2HS $PINS O=pConv_1/product_1_w[16] I1=n7288 I2=n3186
XU6373 NR2T $PINS O=n8924 I1=n4654 I2=n4655
XU6374 FA1 $PINS S=n4401 CO=n4379 A=n4385 B=n4384 CI=n4383
XU6375 ND2 $PINS O=n5895 I1=weight_0_r[17] I2=weight_0_r[18]
XU6376 INV1S $PINS O=n4410 I=n4408
XU6377 ND2 $PINS O=n7016 I1=n7005 I2=FE_OFN1276_weight_0_r_11
XU6378 NR2F $PINS O=n8926 I1=n7252 I2=n4653
XU6379 OAI12HS $PINS O=n5808 A1=n3812 B1=n3814 B2=n3813
XU6380 OAI12HP $PINS O=n3414 A1=n6844 B1=n6846 B2=n3402
XU6381 ND2P $PINS O=n6844 I1=n6643 I2=n6642
XU6382 NR2 $PINS O=n6526 I1=n4578 I2=n4579
XU6383 ND2 $PINS O=n9634 I1=n7099 I2=n7100
XU6384 XNR2HS $PINS O=n3399 I1=n3400 I2=n4143
XU6385 OAI12H $PINS O=n3925 A1=n3920 B1=FE_OFN1598_n4076 B2=n3931
XU6386 OR2 $PINS O=n9203 I1=n9201 I2=n9202
XU6387 FA1 $PINS S=n4318 CO=n4344 A=n4336 B=n4335 CI=n4334
XU6388 INV1S $PINS O=n3766 I=n4192
XU6389 INV1S $PINS O=n3128 I=n4112
XU6390 MAO222 $PINS O=n3910 A1=n4112 B1=n4113 C1=n4111
XU6392 NR2T $PINS O=n9418 I1=n2458 I2=n5479
XU6393 INV1S $PINS O=n5462 I=n5468
XU6394 ND2S $PINS O=n8842 I1=n6134 I2=n6135
XU6395 INV1S $PINS O=n4135 I=n4134
XU6396 MAO222 $PINS O=n4589 A1=n3183 B1=n4457 C1=n4456
XU6397 OAI12HS $PINS O=n3132 A1=n3512 B1=n4242 B2=FE_DBTN17_n6819
XU6398 XNR2HS $PINS O=n5548 I1=data_0_r[19] I2=FE_OFN1274_weight_0_r_11
XU6399 OAI12H $PINS O=n3756 A1=n2061 B1=n9145 B2=n9138
XU6400 MOAI1S $PINS O=n6569 A1=n6568 A2=FE_OFN1274_weight_0_r_11 B1=n6567
+ B2=FE_OFN1274_weight_0_r_11
XU6401 NR2 $PINS O=n3537 I1=n6091 I2=FE_OFN1663_n5980
XU6402 NR2 $PINS O=n3573 I1=n3519 I2=FE_OFN1596_n3897
XU6403 NR2P $PINS O=n9664 I1=n6598 I2=n6597
XU6404 ND2 $PINS O=n3820 I1=n5709 I2=n5710
XU6405 ND2 $PINS O=n3299 I1=n1961 I2=n2068
XU6406 ND2P $PINS O=n6774 I1=n9547 I2=n6773
XU6407 INV1S $PINS O=n9752 I=n9751
XU6408 INV2 $PINS O=n6462 I=n6477
XU6409 FA1 $PINS S=n7156 CO=n9130 A=n7149 B=n7148 CI=n7147
XU6410 XOR2HS $PINS O=n4232 I1=data_2_r[37] I2=FE_OFN1367_weight_2_r_21
XU6411 INV1S $PINS O=n3136 I=n6013
XU6413 XNR2HS $PINS O=n4257 I1=data_2_r[40] I2=FE_OFN1369_weight_2_r_21
XU6416 AOI22S $PINS O=n6473 A1=n6463 A2=FE_OFN1265_weight_0_r_16
+ B1=FE_OFN1698_n5491 B2=n6458
XU6417 XOR2HS $PINS O=n7018 I1=FE_OFN1271_weight_0_r_13 I2=data_0_r[30]
XU6418 ND2 $PINS O=n3403 I1=FE_OFN1351_weight_1_r_1 I2=weight_1_r[2]
XU6419 INV1S $PINS O=n4485 I=n4483
XU6420 INV1S $PINS O=n5610 I=n5726
XU6421 ND2 $PINS O=n7122 I1=n7120 I2=n7163
XU6423 OAI12HS $PINS O=n6368 A1=n3141 B1=n3143 B2=n3142
XU6424 INV1S $PINS O=n3143 I=n6348
XU6425 OAI22H $PINS O=n6277 A1=n6263 A2=FE_OCPN9729_n6138 B1=n6272 B2=n2918
XU6426 OA12P $PINS O=n9768 A1=n9766 B1=n3202 B2=n3145
XU6428 XNR2HS $PINS O=n5518 I1=n5525 I2=n5524
XU6429 AOI22S $PINS O=n4609 A1=n4590 A2=FE_OFN1397_weight_2_r_8 B1=n4454
+ B2=FE_OFN1477_n4591
XU6430 ND2T $PINS O=n9754 I1=n6904 I2=n7129
XU6432 ND3HT $PINS O=n6857 I1=n3426 I2=n3424 I3=n9556
XU6433 OAI12HT $PINS O=n9628 A1=n3881 B1=n9640 B2=n7103
XU6434 XNR2HS $PINS O=n6822 I1=weight_2_r[22] I2=FE_OFN1367_weight_2_r_21
XU6435 MOAI1 $PINS O=n5972 A1=n3158 A2=n3156 B1=n3157 B2=n5955
XU6436 OAI12HS $PINS O=n3157 A1=n5940 B1=n6103 B2=n5960
XU6437 ND2P $PINS O=n3642 I1=n2718 I2=n3643
XU6438 NR2 $PINS O=n3714 I1=n9526 I2=n9533
XU6439 INV2 $PINS O=n6269 I=n6268
XU6440 NR2 $PINS O=n3162 I1=FE_OFN1410_weight_2_r_0 I2=FE_OFN1409_weight_2_r_1
XU6441 INV1S $PINS O=n6335 I=n6334
XU6442 ND2P $PINS O=n9761 I1=n9755 I2=n9757
XU6443 INV1S $PINS O=n5526 I=n5527
XU6444 MOAI1 $PINS O=n4191 A1=n3164 A2=n3163 B1=n4180 B2=n3165
XU6445 INV1S $PINS O=n3163 I=n4179
XU6446 NR2 $PINS O=n3164 I1=n3165 I2=n4180
XU6447 ND3P $PINS O=n3166 I1=n3304 I2=n3303 I3=n9562
XU6448 ND2 $PINS O=n9770 I1=n6976 I2=n6977
XU6449 AN2 $PINS O=n6137 I1=n6441 I2=n6081
XU6450 OR2 $PINS O=n3463 I1=n5901 I2=n5902
XU6451 XNR2HS $PINS O=n6760 I1=n3218 I2=n3168
XU6452 XNR2HS $PINS O=n3168 I1=n6755 I2=n6754
XU6453 XOR3 $PINS O=n6509 I1=n6504 I2=n6503 I3=n3169
XU6455 ND3 $PINS O=n9762 I1=n9760 I2=n9761 I3=n9759
XU6456 OA12 $PINS O=n4161 A1=n4157 B1=FE_OFN1603_n4331 B2=n4158
XU6457 INV1S $PINS O=n6467 I=n6466
XU6459 MOAI1 $PINS O=n5991 A1=FE_OFN1128_FE_DBTN39_n3378 A2=n5985 B1=n6086
+ B2=n5996
XU6460 OAI22H $PINS O=n6106 A1=n6042 A2=FE_OFN1663_n5980 B1=n6091
+ B2=FE_OFN1619_n6414
XU6461 ND2 $PINS O=n4131 I1=FE_OFN1659_n4331 I2=FE_OFN1559_FE_DBTN41_n4329
XU6462 XNR2HS $PINS O=n7088 I1=n7079 I2=n3174
XU6463 XNR2HS $PINS O=n5606 I1=n5588 I2=n3175
XU6464 XNR2HS $PINS O=n3175 I1=n5589 I2=n5587
XU6465 INV1S $PINS O=n4136 I=n4328
XU6466 INV1S $PINS O=n5570 I=n5578
XU6467 INV1S $PINS O=n5641 I=n5648
XU6468 INV1S $PINS O=n5934 I=n5951
XU6469 FA1 $PINS S=n6328 CO=n6200 A=n6199 B=n6198 CI=n6197
XU6470 AOI22S $PINS O=n5749 A1=n5739 A2=FE_OFN1356_weight_1_r_0 B1=n5721
+ B2=n5628
XU6471 MAO222 $PINS O=n6024 A1=n3320 B1=n5992 C1=n5991
XU6472 AN2 $PINS O=n6879 I1=n6871 I2=n6870
XU6474 NR2P $PINS O=n3713 I1=n3715 I2=n3714
XU6475 XNR2HS $PINS O=n4438 I1=FE_OFN1384_weight_2_r_15 I2=data_2_r[21]
XU6476 NR2 $PINS O=n9137 I1=n7152 I2=n7153
XU6477 ND2 $PINS O=n8943 I1=n4648 I2=n4647
XU6478 INV1S $PINS O=n9069 I=n6815
XU6479 XNR2HS $PINS O=n4299 I1=n3477 I2=n3727
XU6480 XNR2HS $PINS O=n9713 I1=weight_0_r[22] I2=FE_OFN1254_weight_0_r_21
XU6481 NR2 $PINS O=n6750 I1=n3560 I2=n3559
XU6482 INV2 $PINS O=n3425 I=n6723
XU6483 FA1 $PINS S=n4424 CO=n4426 A=n4419 B=n4418 CI=n4417
XU6484 ND2 $PINS O=n3705 I1=n9465 I2=n5649
XU6485 NR2 $PINS O=n3430 I1=n5775 I2=FE_OFN1611_n5691
XU6486 OR2 $PINS O=n3366 I1=n3368 I2=n3367
XU6487 NR2 $PINS O=n6687 I1=weight_0_r[2] I2=weight_0_r[1]
XU6488 INV1S $PINS O=n5541 I=n5546
XU6489 XNR2HS $PINS O=n3224 I1=n3360 I2=n3225
XU6490 NR2T $PINS O=n9645 I1=n7101 I2=n7102
XU6491 MOAI1 $PINS O=n5797 A1=FE_OFN1668_n5855 A2=n5782 B1=FE_DBTN37_n5853
+ B2=n5781
XU6492 INV1S $PINS O=n6549 I=n6548
XU6494 XNR2HS $PINS O=n3677 I1=n3423 I2=n3422
XU6495 INV1S $PINS O=n5994 I=n5993
XU6496 INV1S $PINS O=n6046 I=n6045
XU6497 ND2P $PINS O=n3402 I1=n6641 I2=n6640
XU6498 OR2P $PINS O=n9273 I1=n9252 I2=n9246
XU6499 NR2P $PINS O=n6874 I1=n9351 I2=n9354
XU6500 OA12P $PINS O=n9773 A1=n9775 B1=n3202 B2=n9772
XU6501 INV1S $PINS O=n7169 I=n7185
XU6502 MOAI1 $PINS O=n6353 A1=FE_OFN1681_n3135 A2=n6290 B1=FE_DBTN48_n1875
+ B2=n6336
XU6503 ND2 $PINS O=n5477 I1=FE_DBTN48_n1875 I2=n5476
XU6504 INV2 $PINS O=n9757 I=n9754
XU6505 INV1S $PINS O=n6661 I=n6660
XU6506 INV1S $PINS O=n3412 I=n3695
XU6507 NR2 $PINS O=n3503 I1=n6244 I2=n6243
XU6508 FA1 $PINS S=n6175 CO=n6151 A=n6158 B=n6157 CI=n6156
XU6509 ND2 $PINS O=n7260 I1=n6133 I2=n6132
XU6510 FA1 $PINS S=n7086 CO=n7089 A=n7085 B=n7084 CI=n7083
XU6511 INV2 $PINS O=n6554 I=n6553
XU6513 XNR2HS $PINS O=n4382 I1=FE_OFN9137_n I2=data_2_r[29]
XU6514 MOAI1S $PINS O=n4389 A1=FE_OFN1605_n4596 A2=n4388 B1=FE_OFN9140_n3387
+ B2=n3785
XU6517 NR2P $PINS O=n6792 I1=n4268 I2=n3487
XU6518 AOI12H $PINS O=n7121 A1=n9144 B1=n3757 B2=n1923
XU6519 MOAI1 $PINS O=n5630 A1=FE_OFN1688_n5608 A2=n5627 B1=n5626
+ B2=weight_1_r[0]
XU6520 INV1S $PINS O=n5634 I=n5631
XU6521 MXL2HS $PINS OB=n4623 S=n4443 A=n4477 B=n3203
XU6522 NR2 $PINS O=n4477 I1=weight_2_r[10] I2=weight_2_r[9]
XU6523 OAI22S $PINS O=n4231 A1=n4219 A2=FE_OFN1588_n2932 B1=FE_DBTN41_n4329
+ B2=n4233
XU6524 INV1S $PINS O=n6890 I=FE_OFN1266_weight_0_r_16
XU6525 ND2P $PINS O=n9784 I1=n6511 I2=n6512
XU6526 XNR2HS $PINS O=n6322 I1=weight_1_r[22] I2=FE_OFN1309_weight_1_r_21
XU6527 OAI22S $PINS O=n6165 A1=FE_OFN1617_n6138 A2=n6163 B1=n2918 B2=n6154
XU6528 INV1S $PINS O=n6061 I=n6073
XU6529 OAI22S $PINS O=n3876 A1=n6540 A2=FE_OFN1627_n6531 B1=FE_OFN1454_n2727
+ B2=n6539
XU6530 MOAI1S $PINS O=n6429 A1=n6074 A2=FE_DBTN18_n6407 B1=n1874 B2=n6073
XU6531 NR2 $PINS O=n3740 I1=n5957 I2=FE_OFN1401_weight_2_r_5
XU6532 OR2 $PINS O=n8963 I1=n4560 I2=n4561
XU6533 OR2B1S $PINS O=n3700 I1=n4014 B1=FE_OFN1459_n3428
XU6534 ND2 $PINS O=n3337 I1=n4550 I2=n2050
XU6535 OAI12HS $PINS O=n4563 A1=n3337 B1=n3339 B2=n3338
XU6536 MXL2HS $PINS OB=n3920 S=FE_OFN1327_weight_1_r_11 A=n3464 B=n3919
XU6537 ND2P $PINS O=n3612 I1=n9755 I2=n9750
XU6538 NR2 $PINS O=n4596 I1=n3441 I2=n3439
XU6539 ND2 $PINS O=n7279 I1=n5808 I2=n5809
XU6540 INV1S $PINS O=n7019 I=n7018
XU6541 INV1S $PINS O=n5741 I=n5740
XU6542 INV1S $PINS O=n3344 I=n9081
XU6543 FA1 $PINS S=n7055 CO=n7023 A=n7017 B=n7016 CI=n7015
XU6544 NR2P $PINS O=n6861 I1=n6771 I2=n6772
XU6545 ND2 $PINS O=n6862 I1=n6770 I2=n6769
XU6546 NR2 $PINS O=n7045 I1=FE_OFN1281_weight_0_r_8 I2=n7046
XU6547 NR2P $PINS O=n9487 I1=n9511 I2=n9494
XU6548 OR2P $PINS O=n9511 I1=n9517 I2=n9486
XU6549 NR2P $PINS O=n9517 I1=n9493 I2=n9492
XU6550 OAI12HS $PINS O=n7199 A1=n3219 B1=n3718 B2=n3717
XU6551 OR2 $PINS O=n9494 I1=n9501 I2=n9510
XU6552 NR2 $PINS O=n9501 I1=n9491 I2=n9490
XU6553 MOAI1 $PINS O=n6756 A1=n3220 A2=FE_OFN1704_n9443 B1=FE_OFN9122_n2908
+ B2=n6743
XU6554 XOR2HS $PINS O=n10408 I1=n3221 I2=n5679
XU6555 AOI12HS $PINS O=n6852 A1=n3414 B1=n3222 B2=FE_OCPN9756_n6842
XU6556 OR2 $PINS O=n9101 I1=n3223 I2=n4167
XU6557 OR2 $PINS O=n3565 I1=n4162 I2=n4161
XU6558 XNR2HS $PINS O=n3370 I1=n3662 I2=n3224
XU6559 AOI22S $PINS O=n6351 A1=n6316 A2=FE_OFN1442_FE_DBTN9_n3607
+ B1=FE_DBTN2_weight_1_r_16 B2=n6319
XU6560 NR2 $PINS O=n3234 I1=weight_0_r[18] I2=weight_0_r[17]
XU6561 XNR2HS $PINS O=n6948 I1=n6929 I2=n3235
XU6562 XNR2HS $PINS O=n3235 I1=n6931 I2=n6930
XU6564 XOR2HS $PINS O=n6914 I1=data_0_r[44] I2=n9711
XU6565 NR2 $PINS O=n5510 I1=data_0_r[33] I2=FE_DBTN35_weight_0_r_17
XU6566 XOR2HS $PINS O=n3243 I1=FE_OFN1264_weight_0_r_17 I2=n6922
XU6567 NR2T $PINS O=n9411 I1=n5472 I2=n5471
XU6568 XOR2HS $PINS O=n6762 I1=n6741 I2=n6675
XU6569 NR2 $PINS O=n6675 I1=n3246 I2=n3245
XU6570 MOAI1H $PINS O=n4223 A1=n3248 A2=n3247 B1=n4198 B2=n4197
XU6571 ND2S $PINS O=n9086 I1=n9083 I2=n3253
XU6572 AOI12HS $PINS O=n6799 A1=n3253 B1=n3478 B2=FE_OCPN9766_n6788
XU6573 XNR3 $PINS O=n5788 I1=n5776 I2=n5777 I3=n3254
XU6574 OAI12HS $PINS O=n3255 A1=n3256 B1=n5758 B2=FE_OFN1585_FE_DBTN6_n7135
XU6575 ND3P $PINS O=n3258 I1=FE_OFN1156_n2894 I2=n8838 I3=n8835
XU6577 ND2T $PINS O=n9617 I1=n9625 I2=FE_DBTN5_n7246
XU6578 ND2 $PINS O=n7250 I1=n4652 I2=n4651
XU6579 OA12 $PINS O=n3266 A1=n8850 B1=n8855 B2=n8849
XU6580 ND3HT $PINS O=n6804 I1=n3596 I2=n3593 I3=n8859
XU6581 NR2P $PINS O=n6803 I1=n6031 I2=n6032
XU6582 ND2 $PINS O=n3272 I1=n9239 I2=n3274
XU6583 OR2P $PINS O=n7129 I1=n6991 I2=n6992
XU6584 MAO222 $PINS O=n3750 A1=n3384 B1=n4238 C1=n4239
XU6585 MAO222 $PINS O=n5802 A1=n3275 B1=n5797 C1=n5798
XU6586 OR2T $PINS O=n3599 I1=n3510 I2=n3509
XU6587 ND2 $PINS O=n3277 I1=n4342 I2=n3278
XU6588 OR2 $PINS O=n3278 I1=n4343 I2=n3280
XU6589 INV1S $PINS O=n3281 I=n4343
XU6590 NR2 $PINS O=n4526 I1=n3282 I2=n4482
XU6591 ND2 $PINS O=n3283 I1=n4470 I2=n4495
XU6592 OA12P $PINS O=n9354 A1=n9360 B1=n9365 B2=n9359
XU6593 NR2T $PINS O=n9653 I1=n6646 I2=n6647
XU6594 NR2T $PINS O=n6644 I1=n9653 I2=n6851
XU6595 INV1S $PINS O=n3286 I=n6619
XU6596 XNR2HS $PINS O=n6619 I1=n3287 I2=FE_OFN1271_weight_0_r_13
XU6597 ND2 $PINS O=n3293 I1=n3294 I2=n2067
XU6598 NR2P $PINS O=n3294 I1=n3296 I2=n3295
XU6599 NR2 $PINS O=n3296 I1=n9435 I2=n9447
XU6600 OAI12HS $PINS O=n3628 A1=n4033 B1=n3631 B2=n4034
XU6601 XNR2HS $PINS O=n3297 I1=n4032 I2=n4031
XU6602 ND2 $PINS O=n9068 I1=n3299 I2=n9072
XU6603 OAI112HS $PINS O=n6817 A1=n6816 B1=n9066 C1=n3300 C2=n3363
XU6604 XOR3 $PINS O=n5829 I1=n5837 I2=n5838 I3=n3301
XU6605 XNR2HS $PINS O=n4243 I1=data_2_r[40] I2=FE_OFN1466_n4128
XU6606 NR2P $PINS O=n9572 I1=n3704 I2=n3703
XU6607 NR2 $PINS O=n3305 I1=n3306 I2=n5568
XU6608 INV1S $PINS O=n3306 I=n3307
XU6609 AOI12HS $PINS O=n9680 A1=n9684 B1=n9686 B2=n9682
XU6610 OR2 $PINS O=n3307 I1=n5559 I2=n5558
XU6611 ND2P $PINS O=n9382 I1=n6371 I2=n6370
XU6612 ND2 $PINS O=n9385 I1=n6369 I2=n6368
XU6613 NR2P $PINS O=n7268 I1=n6949 I2=n6948
XU6614 MOAI1S $PINS O=n6591 A1=n6577 A2=n3316 B1=n6580 B2=n6996
XU6615 NR2 $PINS O=n6866 I1=n6765 I2=n6766
XU6617 XNR2HS $PINS O=n3323 I1=n3866 I2=n3865
XU6618 OAI12HS $PINS O=n4576 A1=n3324 B1=n3326 B2=n3325
XU6619 OAI12HS $PINS O=n3324 A1=n3782 B1=n4571 B2=n3327
XU6620 ND2 $PINS O=n3328 I1=n4444 I2=FE_OFN1474_n4495
XU6621 INV1S $PINS O=n3329 I=n3330
XU6622 XNR2HS $PINS O=n5656 I1=FE_OFN9129_weight_0_r_3 I2=data_0_r[2]
XU6623 ND2 $PINS O=n3497 I1=n5804 I2=n5805
XU6624 ND3P $PINS O=n3335 I1=n3799 I2=n8963 I3=n8965
XU6625 NR2 $PINS O=n6522 I1=n4580 I2=n4581
XU6626 ND2 $PINS O=n8962 I1=n4560 I2=n4561
XU6627 OR2 $PINS O=n8965 I1=n2820 I2=n4558
XU6628 XOR2HS $PINS O=n4556 I1=n3336 I2=n4550
XU6629 XOR2HS $PINS O=n3336 I1=n3340 I2=n4551
XU6630 OAI22S $PINS O=n3340 A1=n4622 A2=n4544 B1=n4623 B2=n4535
XU6631 NR2P $PINS O=n3478 I1=n6787 I2=n6792
XU6632 NR2P $PINS O=n6787 I1=n4266 I2=n4267
XU6633 ND2P $PINS O=n9146 I1=n5883 I2=n5882
XU6634 OA12P $PINS O=n6306 A1=n9390 B1=n9389 B2=n9398
XU6635 NR2T $PINS O=n9633 I1=n7100 I2=n7099
XU6636 ND2S $PINS O=n6783 I1=n3351 I2=n6779
XU6637 ND2 $PINS O=n9785 I1=n3352 I2=n9781
XU6638 AOI12HS $PINS O=n6516 A1=n3352 B1=n3572 B2=FE_OCPN9765_n6986
XU6639 OAI12HS $PINS O=n3354 A1=n5750 B1=n5751 B2=n5752
XU6640 ND2P $PINS O=n3557 I1=n9172 I2=n9173
XU6641 NR2P $PINS O=n9173 I1=n3829 I2=n3831
XU6643 NR2P $PINS O=n3357 I1=weight_1_r[2] I2=FE_OFN1351_weight_1_r_1
XU6644 NR2 $PINS O=n3779 I1=n8995 I2=FE_DBTN11_n3387
XU6645 MOAI1 $PINS O=n4440 A1=FE_OFN1693_n4596 A2=n4439 B1=FE_OFN9141_n3387
+ B2=n3358
XU6646 OR2P $PINS O=n7252 I1=n8944 I2=n8941
XU6647 NR2 $PINS O=n8944 I1=n4645 I2=n4646
XU6649 NR2 $PINS O=n3367 I1=n4293 I2=n2932
XU6650 ND2 $PINS O=n3373 I1=n4185 I2=FE_OFN1463_n4128
XU6651 ND2 $PINS O=n5938 I1=n3379 I2=n6071
XU6652 XOR2HS $PINS O=n3863 I1=n3380 I2=n3534
XU6653 ND2S $PINS O=n8863 I1=n2064 I2=n8859
XU6654 ND3P $PINS O=n3596 I1=n3589 I2=n8861 I3=n2064
XU6655 NR2 $PINS O=n3384 I1=n3472 I2=n4234
XU6656 MAO222 $PINS O=n6002 A1=n3587 B1=n5983 C1=n5982
XU6657 INV1S $PINS O=n3385 I=n5969
XU6658 XOR2HS $PINS O=pConv_2/product_1_w[17] I1=n7128 I2=n3386
XU6659 AOI12HS $PINS O=n3386 A1=n8928 B1=n2596 B2=n8926
XU6660 OAI22S $PINS O=n4566 A1=n4446 A2=FE_OFN1693_n4596 B1=FE_DBTN11_n3387
+ B2=n4439
XU6661 XNR2HS $PINS O=n4439 I1=data_2_r[20] I2=FE_OFN1380_weight_2_r_15
XU6662 OAI12HS $PINS O=n4269 A1=n3393 B1=n3749 B2=n3488
XU6663 ND2 $PINS O=n3395 I1=n3397 I2=n3396
XU6664 OAI12HS $PINS O=n3400 A1=n3401 B1=FE_OFN1576_FE_DBTN17_n6819 B2=n4130
XU6665 INV1S $PINS O=n6847 I=n3402
XU6666 NR2 $PINS O=n5708 I1=n5706 I2=n3403
XU6667 ND3 $PINS O=n4363 I1=n4362 I2=n4361 I3=n3404
XU6668 XOR2HS $PINS O=n6594 I1=n6587 I2=n6588
XU6669 OA12 $PINS O=n6587 A1=n3405 B1=n6531 B2=n6586
XU6670 ND2 $PINS O=n3405 I1=n6532 I2=n6585
XU6672 ND2 $PINS O=n9527 I1=n7233 I2=n7234
XU6673 XNR2HS $PINS O=n3407 I1=n7230 I2=n7229
XU6674 NR2F $PINS O=n3408 I1=n2321 I2=n6136
XU6675 OAI12HT $PINS O=n3449 A1=n3455 B1=n8836 B2=n6136
XU6676 OA12P $PINS O=n3410 A1=n2063 B1=n8833 B2=n6444
XU6677 AOI12HS $PINS O=n3695 A1=n3413 B1=FE_DBTN22_n3850 B2=n6609
XU6678 NR2P $PINS O=n6841 I1=n6640 I2=n6641
XU6679 NR2T $PINS O=n6846 I1=n6642 I2=n6643
XU6680 ND2S $PINS O=n9660 I1=n3414 I2=n9656
XU6681 OR2 $PINS O=n9559 I1=n6722 I2=n6723
XU6682 OR2T $PINS O=n9557 I1=n6724 I2=n6725
XU6683 MOAI1S $PINS O=n9208 A1=n3897 A2=n9213 B1=FE_OFN1317_weight_1_r_15
+ B2=FE_OFN1459_n3428
XU6684 ND2 $PINS O=n9091 I1=n3432 I2=n9089
XU6685 ND2P $PINS O=n7126 I1=n4659 I2=n4658
XU6686 ND2 $PINS O=n3435 I1=n6165 I2=n3436
XU6687 OAI12HS $PINS O=n6176 A1=n3435 B1=n6193 B2=n3437
XU6688 OR2B1S $PINS O=n3436 I1=n6166 B1=n6193
XU6689 XOR2HS $PINS O=n4411 I1=data_2_r[27] I2=FE_OFN9138_n
XU6690 XOR2HS $PINS O=n4507 I1=n3444 I2=n4497
XU6691 OAI12HS $PINS O=n3444 A1=n4490 B1=n4623 B2=n4491
XU6692 XOR2HS $PINS O=n5626 I1=data_1_r[3] I2=weight_1_r[1]
XU6693 XOR2HS $PINS O=n5815 I1=FE_OFN1355_weight_1_r_1 I2=data_1_r[13]
XU6694 XOR2HS $PINS O=n5832 I1=data_1_r[14] I2=FE_OFN1355_weight_1_r_1
XU6695 XOR2HS $PINS O=n10405 I1=n2843 I2=n6447
XU6696 AOI12HS $PINS O=n6782 A1=n6780 B1=n6781 B2=n2843
XU6697 OR2P $PINS O=n9352 I1=n9359 I2=n7239
XU6698 MAO222 $PINS O=n6167 A1=n3457 B1=n6173 C1=n6193
XU6699 XOR2HS $PINS O=n4296 I1=n4289 I2=n3467
XU6700 ND2 $PINS O=n4341 I1=FE_OFN9145_n I2=data_2_r[34]
XU6701 XNR2HS $PINS O=n4237 I1=data_2_r[36] I2=FE_OFN9145_n
XU6702 XNR2HS $PINS O=n4288 I1=data_2_r[40] I2=FE_OFN1364_weight_2_r_23
XU6703 XNR2HS $PINS O=n4333 I1=data_2_r[42] I2=FE_OFN1364_weight_2_r_23
XU6704 NR2T $PINS O=n6834 I1=n9058 I2=n3551
XU6705 NR2T $PINS O=n4356 I1=n5923 I2=n5926
XU6706 AOI22S $PINS O=n3472 A1=n4229 A2=FE_OFN1377_weight_2_r_16 B1=n4212
+ B2=FE_OFN1467_n4306
XU6707 NR2 $PINS O=n4149 I1=data_2_r[33] I2=FE_OFN1694_weight_2_r_17
XU6708 ND2 $PINS O=n9540 I1=n6678 I2=n6679
XU6709 XNR2HS $PINS O=n3480 I1=n6343 I2=n6344
XU6710 ND2 $PINS O=n5937 I1=weight_2_r[1] I2=weight_2_r[2]
XU6711 MOAI1 $PINS O=n4516 A1=FE_DBTN7_n4532 A2=n4469
+ B1=FE_OCPN9759_FE_DBTN19_n4371 B2=FE_OFN1388_weight_2_r_13
XU6713 MOAI1S $PINS O=n7218 A1=FE_DBTN47_weight_0_r_1 A2=n7180 B1=n7192
+ B2=n5663
XU6714 ND2 $PINS O=n9518 I1=n9492 I2=n9493
XU6715 NR2 $PINS O=n4250 I1=n4247 I2=n4246
XU6716 FA1 $PINS S=n4351 CO=n6830 A=n4141 B=n4140 CI=n4139
XU6717 AOI22S $PINS O=n3486 A1=n4248 A2=FE_OFN1378_weight_2_r_16
+ B1=FE_OFN1467_n4306 B2=n4236
XU6718 ND2 $PINS O=n6790 I1=n3487 I2=n4268
XU6719 ND2P $PINS O=n6793 I1=n4267 I2=n4266
XU6720 NR2 $PINS O=n6436 I1=n6128 I2=n6129
XU6721 INV2 $PINS O=n7237 I=n3489
XU6722 OA12 $PINS O=n9339 A1=n9341 B1=n3490 B2=n9340
XU6723 INV1S $PINS O=n3490 I=n9346
XU6724 XNR2HS $PINS O=pConv_1/product_1_w[2] I1=n9346 I2=n9343
XU6725 NR2 $PINS O=n9346 I1=n9344 I2=n9345
XU6726 XOR2HS $PINS O=n3802 I1=n5699 I2=n7146
XU6727 XOR2HS $PINS O=n3962 I1=data_1_r[18] I2=FE_OFN1331_weight_1_r_9
XU6728 OR2P $PINS O=n9321 I1=n3992 I2=n3991
XU6729 OR2P $PINS O=n9319 I1=n3993 I2=n3994
XU6730 ND2 $PINS O=n3498 I1=n4515 I2=n4516
XU6731 ND2 $PINS O=n4475 I1=weight_2_r[9] I2=weight_2_r[10]
XU6732 XOR2HS $PINS O=n4500 I1=weight_2_r[9] I2=data_2_r[18]
XU6733 XOR2HS $PINS O=n4437 I1=data_2_r[27] I2=FE_OFN1660_weight_2_r_9
XU6734 XOR2HS $PINS O=n4590 I1=data_2_r[29] I2=FE_OFN1660_weight_2_r_9
XU6735 XNR2HS $PINS O=n3505 I1=data_1_r[4] I2=weight_1_r[7]
XU6736 NR2 $PINS O=n4282 I1=n3507 I2=n3506
XU6737 NR2 $PINS O=n3506 I1=n4255 I2=FE_OFN1601_n4195
XU6738 ND2 $PINS O=n3512 I1=n4241 I2=FE_OFN1594_n3599
XU6739 ND2 $PINS O=n4580 I1=n3513 I2=n4565
XU6740 NR2P $PINS O=n9620 I1=n3515 I2=n3514
XU6742 MOAI1 $PINS O=n6897 A1=n2053 A2=FE_OFN1565_FE_DBTN36_n9707
+ B1=FE_OFN1684_n5496 B2=n6882
XU6743 OAI12HS $PINS O=n3527 A1=n9729 B1=n9730 B2=n9731
XU6744 ND2 $PINS O=n9720 I1=n3530 I2=FE_OFN1255_weight_0_r_21
XU6745 ND2 $PINS O=n3530 I1=FE_OFN1685_n5496 I2=FE_OFN1565_FE_DBTN36_n9707
XU6746 ND2 $PINS O=n8947 I1=n4645 I2=n4646
XU6747 ND2S $PINS O=n6800 I1=n3532 I2=n9083
XU6748 ND2S $PINS O=n9668 I1=n3533 I2=n9663
XU6749 ND3HT $PINS O=n3615 I1=n9666 I2=n9665 I3=n3533
XU6750 OR2T $PINS O=n3533 I1=n6600 I2=n6599
XU6751 NR2P $PINS O=n3616 I1=n6595 I2=n6596
XU6752 XOR2HS $PINS O=n6115 I1=n6092 I2=n6096
XU6753 AOI12HS $PINS O=n9792 A1=n9790 B1=n9791 B2=n3541
XU6754 XOR2HS $PINS O=n10402 I1=n3541 I2=n5922
XU6755 ND2 $PINS O=n3544 I1=FE_OFN1560_FE_DBTN40_n3656 I2=n6313
XU6756 ND2 $PINS O=n8856 I1=n3545 I2=n8852
XU6757 NR2P $PINS O=n9753 I1=n9734 I2=n9735
XU6758 MAO222 $PINS O=n9718 A1=n9724 B1=n9725 C1=n3552
XU6759 ND3HT $PINS O=n6390 I1=n3558 I2=n3557 I3=n9171
XU6760 XNR2HS $PINS O=n5618 I1=n5704 I2=n3561
XU6761 XNR2HS $PINS O=n3561 I1=n5705 I2=n3562
XU6762 OAI12HS $PINS O=n3562 A1=n3563 B1=n5614 B2=FE_OFN1584_FE_DBTN6_n7135
XU6763 ND2 $PINS O=n3563 I1=FE_OFN1438_FE_DBTN16_n5612 I2=n5613
XU6764 ND2 $PINS O=n6232 I1=n6231 I2=n3564
XU6765 ND2 $PINS O=n6233 I1=n6230 I2=n3564
XU6766 MOAI1 $PINS O=n3564 A1=n6216 A2=FE_OFN1316_weight_1_r_16 B1=n6215
+ B2=FE_OFN1441_FE_DBTN9_n3607
XU6767 NR2 $PINS O=n9413 I1=n3652 I2=n3566
XU6768 INV2 $PINS O=n3566 I=n3655
XU6769 AOI12HS $PINS O=n3722 A1=n3571 B1=FE_OFN1683_n5496 B2=n6455
XU6770 NR2P $PINS O=n9257 I1=n9254 I2=n9273
XU6771 OR2P $PINS O=n9254 I1=n9262 I2=n9272
XU6772 NR2 $PINS O=n3574 I1=FE_OFN1572_FE_DBTN21_n3428 I2=n4003
XU6773 ND2 $PINS O=n3575 I1=n3579 I2=n4296
XU6774 INV1S $PINS O=n3578 I=n4296
XU6775 ND2 $PINS O=n5924 I1=n4360 I2=n4359
XU6776 NR2T $PINS O=n5923 I1=n4359 I2=n4360
XU6777 OA12P $PINS O=n4044 A1=n3583 B1=n9298 B2=n9304
XU6778 ND2 $PINS O=n3584 I1=FE_OFN1325_weight_1_r_13 I2=FE_OFN1247_n9348
XU6779 XOR2HS $PINS O=n10406 I1=n3589 I2=n6855
XU6780 AOI12HS $PINS O=n8862 A1=n8860 B1=n8861 B2=n3589
XU6781 OAI12HS $PINS O=n3591 A1=n6001 B1=n6002 B2=n6003
XU6782 XOR2HS $PINS O=n5597 I1=data_2_r[3] I2=weight_2_r[1]
XU6783 XOR2HS $PINS O=n4561 I1=n4562 I2=n4552
XU6784 INV1S $PINS O=n3594 I=n5975
XU6785 OR2 $PINS O=n8861 I1=n5974 I2=n5975
XU6786 INV2 $PINS O=n3597 I=n8866
XU6787 MOAI1 $PINS O=n4239 A1=FE_OFN1577_FE_DBTN17_n6819 A2=n4240
+ B1=FE_OFN1594_n3599 B2=n4232
XU6788 XNR2HS $PINS O=n6695 I1=n3601 I2=n6700
XU6789 NR2 $PINS O=n6700 I1=n6690 I2=n3600
XU6790 OR2 $PINS O=n3602 I1=FE_OFN1699_n7188 I2=n6706
XU6791 XNR2HS $PINS O=n6706 I1=data_0_r[5] I2=FE_OFN9128_weight_0_r_3
XU6792 OR2T $PINS O=n6382 I1=n6869 I2=n9351
XU6793 OAI12HS $PINS O=n6311 A1=n3608 B1=FE_OFN1316_weight_1_r_16
+ B2=FE_OFN1531_n6191
XU6794 ND2P $PINS O=n3607 I1=FE_OFN1316_weight_1_r_16 I2=weight_1_r[17]
XU6795 NR2P $PINS O=n6513 I1=n6496 I2=n6497
XU6796 OA12P $PINS O=n3613 A1=n9751 B1=n9759 B2=n9753
XU6797 OA12P $PINS O=n3621 A1=n7266 B1=n7265 B2=n9764
XU6798 MAO222 $PINS O=n3631 A1=n3760 B1=n4029 C1=n4030
XU6799 XNR2HS $PINS O=n5555 I1=data_0_r[18]
+ I2=FE_OFN1428_FE_DBTN34_weight_0_r_11
XU6800 XNR2H $PINS O=n3633 I1=n7050 I2=n3637
XU6801 ND2 $PINS O=n3634 I1=n3637 I2=n7050
XU6802 MOAI1 $PINS O=n3637 A1=n7020 A2=FE_OFN1635_n7070 B1=FE_OFN1676_n7036
+ B2=FE_OFN1276_weight_0_r_11
XU6803 XNR2HS $PINS O=pConv_2/product_2_w[21] I1=n9065 I2=n3638
XU6804 NR2P $PINS O=n3640 I1=n9064 I2=n3641
XU6805 NR2P $PINS O=n7104 I1=n9617 I2=n9616
XU6806 INV1S $PINS O=n5903 I=n5902
XU6807 XNR2HS $PINS O=n6184 I1=data_1_r[47] I2=FE_OFN1449_n2033
XU6808 ND2 $PINS O=n9410 I1=n5471 I2=n5472
XU6809 NR2P $PINS O=n6222 I1=n6224 I2=FE_OFN1309_weight_1_r_21
XU6810 XNR2HS $PINS O=n3659 I1=n6153 I2=n6152
XU6811 MOAI1S $PINS O=n6149 A1=n3661 A2=n3660 B1=n6152 B2=n6153
XU6812 INV1S $PINS O=n3660 I=n6151
XU6813 NR2 $PINS O=n3661 I1=n6153 I2=n6152
XU6814 NR2P $PINS O=n5926 I1=n4357 I2=n4358
XU6815 XOR2HS $PINS O=n3665 I1=n9234 I2=n3906
XU6816 ND2P $PINS O=n9375 I1=n6365 I2=n6364
XU6817 XOR2HS $PINS O=n4213 I1=data_2_r[34] I2=FE_OFN9145_n
XU6818 XOR2HS $PINS O=n4332 I1=data_2_r[43] I2=FE_OFN9147_n
XU6819 OR2 $PINS O=n3679 I1=n6701 I2=n3681
XU6820 INV1S $PINS O=n3680 I=n6701
XU6821 XNR2HS $PINS O=n3696 I1=n4101 I2=n4100
XU6822 MOAI1 $PINS O=n4106 A1=n3699 A2=n3697 B1=n4101 B2=n4100
XU6823 NR2 $PINS O=n3698 I1=n4081 I2=n4080
XU6824 NR2 $PINS O=n3699 I1=n4101 I2=n4100
XU6825 ND2 $PINS O=n9302 I1=n3702 I2=n9305
XU6826 AOI12HS $PINS O=n9307 A1=n3702 B1=n7290 B2=n9306
XU6827 ND2 $PINS O=n9654 I1=n6647 I2=n6646
XU6828 NR2 $PINS O=n9742 I1=n9741 I2=n9759
XU6829 OA12P $PINS O=n9759 A1=n9738 B1=n9739 B2=n9740
XU6830 XOR2HS $PINS O=n7188 I1=weight_0_r[2] I2=weight_0_r[1]
XU6831 MOAI1S $PINS O=n6691 A1=n3708 A2=n3709 B1=n6681 B2=n3710
XU6832 ND2 $PINS O=n3711 I1=n6720 I2=n6721
XU6833 OAI12HS $PINS O=n3712 A1=n6719 B1=n6720 B2=n6721
XU6834 OAI12HP $PINS O=n9522 A1=n3713 B1=n9535 B2=n7237
XU6835 NR2 $PINS O=n5595 I1=data_2_r[1] I2=FE_OFN1409_weight_2_r_1
XU6836 XNR3 $PINS O=n6493 I1=n6465 I2=n3722 I3=n3723
XU6837 NR2P $PINS O=n3723 I1=n6462 I2=n6478
XU6838 MOAI1S $PINS O=n4220 A1=n4195 A2=n4196 B1=FE_DBTN45_n6822 B2=n4213
XU6839 MOAI1S $PINS O=n4215 A1=n4195 A2=n6821 B1=FE_DBTN45_n6822 B2=n4205
XU6840 ND2 $PINS O=n3725 I1=n6491 I2=n6492
XU6841 ND2 $PINS O=n3726 I1=n6490 I2=n2049
XU6842 XNR2HS $PINS O=n3727 I1=n4276 I2=n4275
XU6843 NR2 $PINS O=n4198 I1=FE_OFN1130_FE_DBTN30_data_2_r_33
+ I2=FE_OFN1536_n6822
XU6844 OAI22S $PINS O=n4260 A1=n4249 A2=FE_OFN1601_n4195 B1=FE_OFN1536_n6822
+ B2=n4255
XU6845 NR2P $PINS O=n6424 I1=n3735 I2=FE_OFN1440_FE_DBTN12_weight_2_r_7
XU6846 NR2P $PINS O=n3739 I1=n5573 I2=n3740
XU6847 NR2 $PINS O=n8841 I1=n6135 I2=n6134
XU6848 OR2P $PINS O=n9063 I1=n9058 I2=n9061
XU6849 XNR2HS $PINS O=n3748 I1=n6830 I2=n6829
XU6850 XNR2HS $PINS O=n3751 I1=n5801 I2=n5800
XU6851 INV2 $PINS O=n3753 I=n3756
XU6852 XNR2HS $PINS O=n3759 I1=n4029 I2=n4030
XU6853 ND2P $PINS O=n9093 I1=n4177 I2=n4178
XU6854 AOI12H $PINS O=n9104 A1=n9108 B1=n9110 B2=n9106
XU6855 XNR2HS $PINS O=n4327 I1=data_2_r[46] I2=FE_OFN1466_n4128
XU6857 XOR2HS $PINS O=n4312 I1=data_2_r[45] I2=FE_OFN1466_n4128
XU6858 XNR2HS $PINS O=n4181 I1=FE_OFN1465_n4128 I2=data_2_r[37]
XU6859 NR2P $PINS O=n9097 I1=n4193 I2=n3766
XU6860 XNR2HS $PINS O=n3767 I1=n4207 I2=n4208
XU6861 OAI22H $PINS O=n3769 A1=FE_OFN1559_FE_DBTN41_n4329 A2=n4219
+ B1=FE_OFN1603_n4331 B2=n3375
XU6863 NR2 $PINS O=n3774 I1=n9457 I2=n6731
XU6864 NR2 $PINS O=n6856 I1=n6769 I2=n6770
XU6865 ND3P $PINS O=n3780 I1=n2596 I2=n8926 I3=n3796
XU6866 OR2T $PINS O=n4653 I1=n7249 I2=n7253
XU6868 ND3P $PINS O=n4663 I1=n3788 I2=n3789 I3=n3791
XU6869 NR2T $PINS O=n3789 I1=n4662 I2=n3790
XU6870 XOR2HS $PINS O=n4307 I1=data_2_r[41] I2=FE_OFN1364_weight_2_r_23
XU6871 XOR2HS $PINS O=n10407 I1=n3799 I2=n7113
XU6872 AOI12HS $PINS O=n8966 A1=n8964 B1=n3799 B2=n8965
XU6873 ND2 $PINS O=n9066 I1=n4353 I2=n4352
XU6874 XNR2HS $PINS O=n3853 I1=n5636 I2=n3857
XU6875 XNR2HS $PINS O=n5700 I1=n3802 I2=n5698
XU6876 AOI12HS $PINS O=n3807 A1=n9139 B1=n3805 B2=n3804
XU6877 NR2 $PINS O=n5624 I1=FE_OFN1425_FE_DBTN49_data_1_r_1 I2=n3063
XU6878 XOR2HS $PINS O=n5732 I1=n5723 I2=n3816
XU6879 OAI12H $PINS O=n5751 A1=n3817 B1=n3819 B2=n3818
XU6880 OAI12HS $PINS O=n3817 A1=n5723 B1=n3820 B2=n5724
XU6881 MAO222 $PINS O=n4425 A1=n4416 B1=n3826 C1=FE_OFN9749_n
XU6882 OAI12HS $PINS O=n3826 A1=n3827 B1=FE_OFN1444_FE_DBTN7_n4532 B2=n4406
XU6883 INV2 $PINS O=n3829 I=n5753
XU6884 NR2P $PINS O=n7249 I1=n4651 I2=n4652
XU6885 XNR2HS $PINS O=n4395 I1=FE_OFN1473_n4404 I2=data_2_r[30]
XU6886 MOAI1 $PINS O=n6832 A1=n3836 A2=n3835 B1=n6829 B2=n6830
XU6887 NR2 $PINS O=n3835 I1=n6830 I2=n6829
XU6888 NR2T $PINS O=n3843 I1=n9140 I2=n9141
XU6889 ND2 $PINS O=n7158 I1=n3845 I2=n3844
XU6890 ND2 $PINS O=n7155 I1=n3848 I2=n3847
XU6891 OAI12HS $PINS O=n7001 A1=n3851 B1=FE_DBTN33_weight_0_r_13
+ B2=FE_OFN1543_n7067
XU6892 ND2 $PINS O=n3851 I1=FE_OFN1571_FE_DBTN22_n3850 I2=n7003
XU6893 NR2T $PINS O=n9616 I1=n3852 I2=n7091
XU6894 XNR2H $PINS O=n3852 I1=n7023 I2=n3867
XU6895 ND2 $PINS O=n3854 I1=n3857 I2=n5636
XU6896 ND2 $PINS O=n3855 I1=n5635 I2=n3856
XU6897 OR2 $PINS O=n3856 I1=n5636 I2=n3857
XU6898 MOAI1S $PINS O=n4346 A1=n3862 A2=n3860 B1=n4345 B2=n3861
XU6899 INV1S $PINS O=n3862 I=n4344
XU6900 XOR2HS $PINS O=n3865 I1=n7051 I2=n7052
XU6901 NR2 $PINS O=n7096 I1=n9616 I2=n9620
XU6902 MOAI1 $PINS O=n7010 A1=n3868 A2=n3869 B1=n7024 B2=n7025
XU6903 OR2 $PINS O=n3871 I1=n6617 I2=n6533
XU6904 NR2P $PINS O=n9673 I1=n3873 I2=n3872
XU6905 INV1S $PINS O=n3872 I=n6572
XU6906 INV1S $PINS O=n3873 I=n6571
XU6907 OR2 $PINS O=n9672 I1=n6571 I2=n6572
XU6908 ND2 $PINS O=n9688 I1=n5565 I2=n3875
XU6909 NR2 $PINS O=n9687 I1=n3875 I2=n5565
XU6911 OA12 $PINS O=n4159 A1=n4155 B1=FE_OFN1588_n2932 B2=FE_OFN1465_n4128
XU6912 ND2 $PINS O=n4157 I1=n4329 I2=n4163
XU6913 AOI12HS $PINS O=n6527 A1=n8953 B1=n8955 B2=FE_OCPN9753_n6521
XU6914 INV1S $PINS O=n6208 I=data_1_r[36]
XU6915 OR2 $PINS O=n7277 I1=n9148 I2=n3057
XU6916 INV1S $PINS O=n7172 I=n9463
XU6917 INV2 $PINS O=n6453 I=n6452
XU6918 ND2 $PINS O=n9151 I1=n9147 I2=n9146
XU6919 ND2 $PINS O=n9394 I1=n9399 I2=n9397
XU6920 INV1S $PINS O=n3928 I=weight_1_r[12]
XU6921 OA12 $PINS O=n5593 A1=n5585 B1=FE_DBTN39_n3378 B2=n5586
XU6922 INV2 $PINS O=n9642 I=n9635
XU6923 FA1 $PINS S=n6330 CO=n6202 A=n6193 B=FE_OFN1531_n6191 CI=n6192
XU6924 INV1S $PINS O=n5682 I=n5683
XU6925 FA1 $PINS S=n6678 CO=n7235 A=n7203 B=n7202 CI=n7201
XU6926 FA1 $PINS S=n7228 CO=n9481 A=n7198 B=n7197 CI=n7196
XU6927 ND3HT $PINS O=n6309 I1=n6308 I2=n6306 I3=n6307
XU6928 NR2P $PINS O=n9750 I1=n9754 I2=n9753
XU6929 OR2 $PINS O=n9741 I1=n9747 I2=n9753
XU6930 ND3HT $PINS O=n4047 I1=n4046 I2=n4045 I3=n4044
XU6931 OR2 $PINS O=n6444 I1=n8825 I2=n8831
XU6932 INV1S $PINS O=n6536 I=n6535
XU6933 ND2P $PINS O=n8834 I1=n6131 I2=n6130
XU6934 FA1 $PINS S=n4083 CO=n4109 A=n4089 B=n4088 CI=n4087
XU6935 MOAI1 $PINS O=n5588 A1=n8889 A2=n5570 B1=FE_OFN1458_n3162 B2=n5583
XU6936 INV1S $PINS O=n6998 I=data_0_r[20]
XU6937 FA1 $PINS S=n4656 CO=n4377 A=n4381 B=n4380 CI=n4379
XU6938 NR2 $PINS O=n9797 I1=n5904 I2=n5903
XU6939 OA12 $PINS O=n8878 A1=n8880 B1=n8879 B2=n8885
XU6940 MOAI1S $PINS O=n4421 A1=FE_OFN1606_n4596 A2=n4414 B1=FE_OFN9140_n3387
+ B2=n4411
XU6941 NR2P $PINS O=n6385 I1=n6384 I2=n6383
XU6942 MOAI1 $PINS O=n4101 A1=n4073 A2=FE_OFN1638_n9221
+ B1=FE_OFN1558_FE_DBTN42_n3886 B2=n4072
XU6943 INV1S $PINS O=n4321 I=n4320
XU6944 MOAI1 $PINS O=n7204 A1=FE_OFN1630_n6658 A2=n7194 B1=FE_OFN9144_n9457
+ B2=n7193
XU6946 INV1S $PINS O=n4476 I=data_2_r[20]
XU6947 INV2 $PINS O=n9618 I=n9617
XU6948 NR2 $PINS O=n9262 I1=n9249 I2=n9250
XU6949 FA1 $PINS S=n9249 CO=n9227 A=n9231 B=n9230 CI=n9229
XU6950 AOI12HS $PINS O=n9176 A1=n9173 B1=n9175 B2=n9174
XU6951 NR2 $PINS O=n3966 I1=n9348 I2=FE_OFN1598_n4076
XU6952 AOI12HS $PINS O=n7244 A1=n2718 B1=n9078 B2=n9059
XU6954 NR2 $PINS O=n3918 I1=weight_1_r[10] I2=FE_OFN1332_weight_1_r_9
XU6955 MOAI1S $PINS O=n5733 A1=n3102 A2=n5717 B1=FE_OFN1519_n5608 B2=n5716
XU6956 AOI22S $PINS O=n9345 A1=n3962 A2=weight_1_r[8] B1=FE_OFN1460_n3961
+ B2=n9348
XU6957 INV1S $PINS O=n3964 I=n3962
XU6958 INV1S $PINS O=n6461 I=n6459
XU6959 FA1 $PINS S=n6768 CO=n6679 A=n6759 B=n6758 CI=n6757
XU6960 MOAI1 $PINS O=n5747 A1=n5691 A2=n5722 B1=n9120 B2=n5740
XU6961 INV1S $PINS O=n6745 I=n6744
XU6962 INV1S $PINS O=n6216 I=n6219
XU6963 INV1S $PINS O=n5576 I=n2863
XU6964 FA1S $PINS S=n9244 CO=n9229 A=n9237 B=n9236 CI=n9235
XU6965 FA1 $PINS S=n6375 CO=n6377 A=n6176 B=n6175 CI=n6174
XU6966 FA1 $PINS S=n6420 CO=n6404 A=n3396 B=n6409 CI=n6408
XU6967 FA1 $PINS S=n9490 CO=n9449 A=n9453 B=n9452 CI=n9451
XU6968 ND2 $PINS O=n9318 I1=n3994 I2=n3993
XU6969 ND3 $PINS O=n9167 I1=n9165 I2=n6390 I3=n9164
XU6970 NR2 $PINS O=n9584 I1=n5659 I2=n5663
XU6971 ND2 $PINS O=n5267 I1=n5134 I2=n5133
XU6972 ND2 $PINS O=n4823 I1=n4690 I2=n4689
XU7029 XOR2HS $PINS O=pConv_2/product_0_w[8] I1=n8863 I2=n8862
XU7030 XOR2HS $PINS O=n3889 I1=FE_OFN1323_weight_1_r_13 I2=data_1_r[29]
XU7031 NR2 $PINS O=n3926 I1=FE_OCPN9768_weight_1_r_13 I2=n3928
XU7033 XNR2HS $PINS O=n4058 I1=FE_OFN1326_weight_1_r_13 I2=data_1_r[28]
XU7034 XOR2HS $PINS O=n3902 I1=FE_OFN1323_weight_1_r_13 I2=data_1_r[30]
XU7036 INV1S $PINS O=n3891 I=n3895
XU7038 XOR2HS $PINS O=n3898 I1=FE_OFN1319_weight_1_r_15 I2=data_1_r[27]
XU7039 XNR2HS $PINS O=n3901 I1=FE_OFN1319_weight_1_r_15 I2=data_1_r[28]
XU7040 OAI22S $PINS O=n3905 A1=n3894 A2=FE_OFN1597_n3897 B1=FE_DBTN21_n3428
+ B2=n3901
XU7041 INV1S $PINS O=n9348 I=data_1_r[17]
XU7042 NR2 $PINS O=n4049 I1=FE_DBTN26_weight_1_r_15 I2=FE_OFN1247_n9348
XU7043 NR2P $PINS O=n3961 I1=FE_OFN1337_weight_1_r_8 I2=n4086
XU7044 NR2 $PINS O=n9233 I1=n3917 I2=FE_OFN1431_FE_DBTN26_weight_1_r_15
XU7045 XNR2HS $PINS O=n9226 I1=FE_OFN1319_weight_1_r_15 I2=data_1_r[29]
XU7046 OAI22S $PINS O=n9232 A1=n3901 A2=FE_OFN1597_n3897 B1=FE_DBTN21_n3428
+ B2=n9226
XU7047 XOR2HS $PINS O=n9220 I1=FE_OFN1323_weight_1_r_13 I2=data_1_r[31]
XU7048 FA1 $PINS S=n4112 CO=n9240 A=n3909 B=n3908 CI=n3907
XU7049 INV1S $PINS O=n3912 I=n9252
XU7050 XNR2HS $PINS O=n3914 I1=FE_OFN1324_weight_1_r_13 I2=n3927
XU7051 XOR2HS $PINS O=n3977 I1=FE_OFN1324_weight_1_r_13 I2=data_1_r[18]
XU7052 XOR2HS $PINS O=n3947 I1=FE_OFN1331_weight_1_r_9 I2=data_1_r[21]
XU7053 XNR2HS $PINS O=n3923 I1=weight_1_r[15] I2=data_1_r[17]
XU7054 XOR2HS $PINS O=n3935 I1=weight_1_r[15] I2=data_1_r[18]
XU7055 INV1S $PINS O=n3941 I=n4018
XU7056 MOAI1 $PINS O=n4030 A1=FE_OFN1637_n9221 A2=n3941
+ B1=FE_OFN1556_FE_DBTN42_n3886 B2=n3940
XU7057 XOR2HS $PINS O=n3951 I1=FE_OFN1331_weight_1_r_9 I2=data_1_r[20]
XU7058 XOR2HS $PINS O=n3963 I1=FE_OFN1331_weight_1_r_9 I2=data_1_r[19]
XU7059 AOI22S $PINS O=n3959 A1=n3951 A2=weight_1_r[8] B1=FE_OFN1460_n3961
+ B2=n3963
XU7060 OR2 $PINS O=n9335 I1=n3968 I2=n3969
XU7061 NR2 $PINS O=n3960 I1=data_1_r[17] I2=n4086
XU7062 MOAI1 $PINS O=n3967 A1=n3965 A2=n3964 B1=n3963 B2=weight_1_r[8]
XU7063 NR2 $PINS O=n9340 I1=n3966 I2=n3967
XU7064 ND2S $PINS O=n9341 I1=n3967 I2=n3966
XU7065 INV1S $PINS O=n3970 I=n3969
XU7066 XOR2HS $PINS O=n3978 I1=FE_OCPN9768_weight_1_r_13 I2=data_1_r[17]
XU7067 XOR2HS $PINS O=n4053 I1=FE_OCPN9769_FE_OFN1335_weight_1_r_9
+ I2=data_1_r[29]
XU7068 XOR2HS $PINS O=n4054 I1=FE_OFN1320_weight_1_r_15 I2=data_1_r[23]
XU7069 XNR2HS $PINS O=n4010 I1=FE_OFN1328_weight_1_r_11 I2=data_1_r[25]
XU7070 XOR2HS $PINS O=n3998 I1=FE_OFN1329_weight_1_r_11 I2=data_1_r[26]
XU7071 XOR2HS $PINS O=n4074 I1=data_1_r[27] I2=FE_OFN1329_weight_1_r_11
XU7072 XNR2HS $PINS O=n4025 I1=n4005 I2=n4006
XU7073 XOR2HS $PINS O=n4020 I1=data_1_r[24] I2=FE_OFN1328_weight_1_r_11
XU7074 XOR2HS $PINS O=n4057 I1=FE_OFN1326_weight_1_r_13 I2=data_1_r[27]
XU7075 INV1S $PINS O=n4052 I=n4057
XU7076 XOR2HS $PINS O=n4070 I1=FE_OFN1326_weight_1_r_13 I2=data_1_r[26]
XU7077 MOAI1 $PINS O=n4082 A1=FE_OFN1638_n9221 A2=n4052 B1=n4070
+ B2=FE_OFN1558_FE_DBTN42_n3886
XU7078 XNR2HS $PINS O=n4075 I1=FE_OFN1329_weight_1_r_11 I2=data_1_r[28]
XU7079 XNR2HS $PINS O=n4060 I1=FE_OFN1329_weight_1_r_11 I2=data_1_r[29]
XU7080 XNR2HS $PINS O=n4107 I1=n4068 I2=n4069
XU7081 FA1 $PINS S=n4108 CO=n4111 A=n4092 B=n4091 CI=n4090
XU7082 XNR2HS $PINS O=n4104 I1=n4096 I2=n4097
XU7083 INV1S $PINS O=n4183 I=data_2_r[36]
XU7084 NR2 $PINS O=n4140 I1=n4183 I2=n6821
XU7086 OAI22S $PINS O=n4139 A1=n4132 A2=FE_OFN1602_n4195 B1=FE_OFN1701_n6822
+ B2=n4146
XU7087 XOR2HS $PINS O=n4144 I1=FE_OFN1370_weight_2_r_21 I2=data_2_r[47]
XU7088 INV1S $PINS O=n4130 I=n4144
XU7089 XOR2HS $PINS O=n4134 I1=data_2_r[46] I2=FE_OFN1370_weight_2_r_21
XU7090 NR2 $PINS O=n4184 I1=weight_2_r[18] I2=n3475
XU7092 ND2S $PINS O=n4143 I1=n4131 I2=FE_OFN1462_n4128
XU7093 INV1S $PINS O=n4201 I=data_2_r[35]
XU7094 NR2 $PINS O=n4138 I1=n4201 I2=n6821
XU7095 INV1S $PINS O=n4133 I=n4332
XU7096 XOR2HS $PINS O=n4319 I1=data_2_r[45] I2=FE_OFN1370_weight_2_r_21
XU7097 XOR2HS $PINS O=n4328 I1=FE_OFN1462_n4128 I2=data_2_r[47]
XU7098 FA1 $PINS S=n4342 CO=n4142 A=n4138 B=n4341 CI=n4137
XU7099 OAI22S $PINS O=n6825 A1=n4146 A2=FE_OFN1602_n4195 B1=FE_OFN1701_n6822
+ B2=n6824
XU7100 INV1S $PINS O=n6836 I=n9062
XU7101 NR2 $PINS O=n9115 I1=n4149 I2=FE_OFN1468_n4306
XU7102 XOR2HS $PINS O=n4150 I1=n3475 I2=data_2_r[34]
XU7103 NR2 $PINS O=n4153 I1=FE_OFN1130_FE_DBTN30_data_2_r_33 I2=FE_DBTN41_n4329
XU7104 XOR2HS $PINS O=n4156 I1=FE_OFN1374_weight_2_r_17 I2=data_2_r[35]
XU7105 MOAI1 $PINS O=n4154 A1=FE_OFN1653_n4306 A2=n4151 B1=n4156
+ B2=weight_2_r[16]
XU7106 NR2 $PINS O=n9111 I1=n4153 I2=n4154
XU7107 XOR2HS $PINS O=n4165 I1=FE_OFN1374_weight_2_r_17 I2=data_2_r[36]
XU7108 AOI22S $PINS O=n4162 A1=n4165 A2=weight_2_r[16] B1=FE_OFN1468_n4306
+ B2=n4156
XU7109 XNR2HS $PINS O=n4158 I1=FE_OCPN9767_weight_2_r_19 I2=data_2_r[33]
XU7110 XOR2HS $PINS O=n4174 I1=data_2_r[37] I2=n3475
XU7111 XOR2HS $PINS O=n4187 I1=FE_OFN1368_weight_2_r_21 I2=data_2_r[34]
XU7112 XOR2HS $PINS O=n4171 I1=weight_2_r[21] I2=data_2_r[33]
XU7113 ND2S $PINS O=n4173 I1=FE_DBTN30_data_2_r_33 I2=weight_2_r[21]
XU7114 AOI22S $PINS O=n4186 A1=n4189 A2=FE_OFN1377_weight_2_r_16 B1=n4174
+ B2=FE_OFN1470_n4306
XU7115 XNR2HS $PINS O=n4188 I1=weight_2_r[21] I2=data_2_r[35]
XU7116 XOR2HS $PINS O=n4194 I1=FE_OFN1376_weight_2_r_17 I2=data_2_r[39]
XU7117 OR2 $PINS O=n9096 I1=n4191 I2=n4192
XU7118 XOR2HS $PINS O=n4212 I1=FE_OFN1376_weight_2_r_17 I2=data_2_r[40]
XU7119 AOI12HS $PINS O=n4204 A1=FE_OFN1465_n4128 B1=n4200 B2=data_2_r[35]
XU7120 XNR2HS $PINS O=n4219 I1=weight_2_r[19] I2=data_2_r[38]
XU7121 NR2 $PINS O=n4205 I1=data_2_r[33] I2=n6821
XU7122 ND2S $PINS O=n4209 I1=n4208 I2=n4207
XU7123 INV1S $PINS O=n4214 I=n4213
XU7124 XNR2HS $PINS O=n4233 I1=FE_OCPN9767_weight_2_r_19 I2=data_2_r[39]
XU7125 XOR2HS $PINS O=n4236 I1=FE_OFN1376_weight_2_r_17 I2=data_2_r[42]
XU7126 XNR2HS $PINS O=n4235 I1=n4245 I2=n4247
XU7127 XNR2HS $PINS O=n4240 I1=FE_OFN1367_weight_2_r_21 I2=data_2_r[38]
XU7128 XOR2HS $PINS O=n4252 I1=FE_OFN1369_weight_2_r_21 I2=data_2_r[39]
XU7129 INV1S $PINS O=n4242 I=n4252
XU7130 INV1S $PINS O=n4244 I=n4243
XU7131 XOR2HS $PINS O=n4273 I1=FE_OFN1695_weight_2_r_17 I2=data_2_r[45]
XU7132 XNR2HS $PINS O=n4277 I1=FE_OFN1369_weight_2_r_21 I2=data_2_r[41]
XU7133 INV1S $PINS O=n4258 I=n4257
XU7134 XOR2HS $PINS O=n4285 I1=FE_OFN1695_weight_2_r_17 I2=data_2_r[46]
XU7135 AOI22S $PINS O=n4295 A1=n4285 A2=FE_OFN1378_weight_2_r_16 B1=n4152
+ B2=n4273
XU7136 XOR2HS $PINS O=n4291 I1=FE_OFN1369_weight_2_r_21 I2=data_2_r[42]
XU7137 INV1S $PINS O=n4281 I=n4279
XU7138 XNR2HS $PINS O=n4293 I1=weight_2_r[19] I2=data_2_r[44]
XU7139 XNR2HS $PINS O=n4304 I1=n4313 I2=n4315
XU7140 XOR2HS $PINS O=n4311 I1=FE_OFN1369_weight_2_r_21 I2=data_2_r[43]
XU7141 NR2 $PINS O=n4336 I1=n6821 I2=FE_OFN1130_FE_DBTN30_data_2_r_33
XU7143 XNR2HS $PINS O=n4320 I1=FE_OFN1370_weight_2_r_21 I2=data_2_r[44]
XU7144 FA1 $PINS S=n4353 CO=n4354 A=n4318 B=n4317 CI=n4316
XU7145 FA1 $PINS S=n4316 CO=n4338 A=n4326 B=n4325 CI=n4324
XU7146 ND2 $PINS O=n4365 I1=FE_OFN1382_weight_2_r_15 I2=data_2_r[23]
XU7147 XNR2HS $PINS O=n4367 I1=FE_OFN9137_n I2=data_2_r[31]
XU7148 XNR2HS $PINS O=n4369 I1=n4365 I2=n4364
XU7149 ND2S $PINS O=n4385 I1=FE_OFN1382_weight_2_r_15 I2=data_2_r[21]
XU7150 INV1S $PINS O=n4366 I=data_2_r[22]
XU7151 NR2 $PINS O=n4374 I1=n4538 I2=n4366
XU7152 XNR2HS $PINS O=n4376 I1=FE_OFN9137_n I2=data_2_r[30]
XU7153 XNR2HS $PINS O=n4378 I1=n4369 I2=n4368
XU7155 XOR2H $PINS O=n4532 I1=FE_OFN9142_n I2=weight_2_r[12]
XU7156 MOAI1S $PINS O=n4383 A1=FE_OFN1473_n4404 A2=FE_OFN1444_FE_DBTN7_n4532
+ B1=FE_OFN1434_FE_DBTN19_n4371 B2=n4386
XU7157 NR2 $PINS O=n4390 I1=n4476 I2=n4538
XU7158 XNR2HS $PINS O=n4388 I1=FE_OFN9137_n I2=data_2_r[28]
XU7159 MOAI1 $PINS O=n4394 A1=FE_OFN1444_FE_DBTN7_n4532 A2=n1983
+ B1=FE_OFN1434_FE_DBTN19_n4371 B2=n4395
XU7160 ND2S $PINS O=n4387 I1=FE_OFN1480_n4623 I2=FE_OFN1608_n4622
XU7161 INV1S $PINS O=n4530 I=data_2_r[19]
XU7162 FA1 $PINS S=n4428 CO=n4402 A=n4391 B=n4390 CI=n4389
XU7163 XOR2HS $PINS O=n4409 I1=FE_OFN1392_weight_2_r_11 I2=data_2_r[31]
XU7164 INV1S $PINS O=n4397 I=n4409
XU7165 FA1 $PINS S=n4417 CO=n4392 A=n4399 B=n4416 CI=n4398
XU7166 INV1S $PINS O=n4406 I=n4403
XU7167 XNR2HS $PINS O=n4407 I1=FE_OFN1387_weight_2_r_13 I2=data_2_r[28]
XU7169 XOR2HS $PINS O=n4617 I1=FE_OFN1387_weight_2_r_13 I2=data_2_r[27]
XU7170 XNR2HS $PINS O=n4621 I1=FE_OFN1392_weight_2_r_11 I2=data_2_r[29]
XU7171 XOR2HS $PINS O=n4408 I1=FE_OFN1392_weight_2_r_11 I2=data_2_r[30]
XU7172 NR2 $PINS O=n4591 I1=FE_OFN1396_weight_2_r_8 I2=FE_OFN1393_weight_2_r_9
XU7173 XNR2HS $PINS O=n4595 I1=FE_OFN1384_weight_2_r_15 I2=data_2_r[24]
XU7174 XOR2HS $PINS O=n4413 I1=FE_OFN9138_n I2=data_2_r[25]
XU7175 XNR2HS $PINS O=n4414 I1=FE_OFN9138_n I2=data_2_r[26]
XU7176 NR2 $PINS O=n4633 I1=n4538 I2=n8995
XU7177 INV1S $PINS O=n4415 I=n4413
XU7178 FA1 $PINS S=n4639 CO=n4423 A=n4422 B=n4421 CI=n4420
XU7180 AOI22S $PINS O=n4464 A1=n4454 A2=FE_OFN1397_weight_2_r_8
+ B1=FE_OFN1477_n4591 B2=n4437
XU7181 XNR2HS $PINS O=n4453 I1=n4464 I2=n4462
XU7182 INV1S $PINS O=n4430 I=n4434
XU7183 XOR2HS $PINS O=n4444 I1=FE_OFN1391_weight_2_r_11 I2=data_2_r[24]
XU7184 INV1S $PINS O=n4431 I=n4444
XU7185 XNR2HS $PINS O=n4435 I1=FE_OFN1391_weight_2_r_11 I2=data_2_r[25]
XU7186 XNR2HS $PINS O=n4446 I1=FE_OFN1380_weight_2_r_15 I2=data_2_r[19]
XU7187 XOR2HS $PINS O=n4460 I1=FE_OFN1391_weight_2_r_11 I2=data_2_r[26]
XU7188 MOAI1 $PINS O=n4571 A1=FE_OFN1443_FE_DBTN7_n4532 A2=n4442
+ B1=FE_OFN1433_FE_DBTN19_n4371 B2=n4540
XU7190 XNR2HS $PINS O=n4543 I1=FE_OFN1391_weight_2_r_11 I2=data_2_r[23]
XU7191 XNR2HS $PINS O=n4601 I1=FE_OFN1387_weight_2_r_13 I2=data_2_r[25]
XU7192 INV1S $PINS O=n4461 I=n4460
XU7193 XOR2HS $PINS O=n4604 I1=FE_OFN1391_weight_2_r_11 I2=data_2_r[27]
XU7194 INV1S $PINS O=n4468 I=n4473
XU7195 XNR2HS $PINS O=n4486 I1=FE_OCPN9758_weight_2_r_11 I2=data_2_r[19]
XU7196 XNR2HS $PINS O=n4515 I1=n4481 I2=n4482
XU7197 XNR2HS $PINS O=n4474 I1=FE_OCPN9716_weight_2_r_13 I2=data_2_r[19]
XU7198 NR2 $PINS O=n4479 I1=n4476 I2=n4475
XU7199 XOR2HS $PINS O=n4489 I1=FE_OCPN9758_weight_2_r_11 I2=data_2_r[18]
XU7200 INV1S $PINS O=n4487 I=n4489
XU7201 AOI22S $PINS O=n4497 A1=n4488 A2=weight_2_r[8] B1=n4501
+ B2=FE_OFN1666_n4591
XU7202 XNR2HS $PINS O=n4491 I1=FE_OCPN9758_weight_2_r_11 I2=data_2_r[17]
XU7203 ND2S $PINS O=n4490 I1=n4495 I2=n4489
XU7204 NR2 $PINS O=n8978 I1=n4492 I2=n4493
XU7205 ND3S $PINS O=n4496 I1=n4495 I2=weight_2_r[11] I3=n8995
XU7206 OR2 $PINS O=n8981 I1=n4506 I2=n4507
XU7207 NR2 $PINS O=n4499 I1=FE_OFN1414_data_2_r_17 I2=FE_OFN1393_weight_2_r_9
XU7208 NR2 $PINS O=n8990 I1=n4499 I2=FE_OFN1666_n4591
XU7209 MOAI1S $PINS O=n4505 A1=FE_OFN1667_n4591 A2=n4502 B1=n4501
+ B2=weight_2_r[8]
XU7210 NR2 $PINS O=n8986 I1=n4504 I2=n4505
XU7211 ND2S $PINS O=n8987 I1=n4505 I2=n4504
XU7212 OA12 $PINS O=n8985 A1=n8987 B1=n8992 B2=n8986
XU7213 INV1S $PINS O=n4509 I=n4506
XU7214 OR2 $PINS O=n8976 I1=n4510 I2=n4511
XU7215 XNR2HS $PINS O=n4525 I1=FE_OFN1380_weight_2_r_15
+ I2=FE_OFN1414_data_2_r_17
XU7216 AOI12HS $PINS O=n4534 A1=n4443 B1=n4528 B2=data_2_r[19]
XU7217 XOR2HS $PINS O=n4541 I1=FE_OCPN9716_weight_2_r_13 I2=data_2_r[20]
XU7218 MOAI1S $PINS O=n4551 A1=n4534 A2=n4533 B1=n4532 B2=n4541
XU7219 NR2 $PINS O=n4536 I1=FE_OFN1414_data_2_r_17 I2=n4538
XU7220 MOAI1S $PINS O=n4570 A1=FE_DBTN7_n4532 A2=n4542
+ B1=FE_OCPN9759_FE_DBTN19_n4371 B2=n4541
XU7221 FA1 $PINS S=n4521 CO=n4558 A=n4555 B=FE_OCPN9752_n4554 CI=n4553
XU7222 ND2S $PINS O=n4565 I1=n4564 I2=n4563
XU7223 XNR2HS $PINS O=n4574 I1=n4567 I2=n4566
XU7224 FA1 $PINS S=n4583 CO=n4578 A=n4577 B=n4576 CI=n4575
XU7226 XNR2HS $PINS O=n4612 I1=n4625 I2=n4627
XU7227 XOR2HS $PINS O=n4618 I1=FE_OFN1387_weight_2_r_13 I2=data_2_r[26]
XU7228 XNR2HS $PINS O=n4624 I1=FE_OFN1392_weight_2_r_11 I2=data_2_r[28]
XU7229 XNR2HS $PINS O=n4630 I1=n4614 I2=n4613
XU7230 FA1 $PINS S=n4648 CO=n4649 A=n4630 B=n4629 CI=n4628
XU7231 FA1 $PINS S=n4644 CO=n4420 A=n4633 B=n4632 CI=n4631
XU7232 FA1 $PINS S=n4628 CO=n4643 A=n4636 B=n4635 CI=n4634
XU7233 OR2 $PINS O=n4881 I1=DP_OP_56J1_122_9379/n253 I2=n4664
XU7234 ND2 $PINS O=n4879 I1=n4664 I2=DP_OP_56J1_122_9379/n253
XU7235 ND2 $PINS O=n4728 I1=n4881 I2=n4879
XU7236 NR2 $PINS O=n4855 I1=n4673 I2=n4674
XU7237 FA1S $PINS S=n4672 CO=n4673 A=pConv_0/product_1_r[3]
+ B=pConv_0/product_2_r[3] CI=pConv_0/product_0_r[3]
XU7238 NR2 $PINS O=n4676 I1=n4855 I2=n4861
XU7239 FA1S $PINS S=n4670 CO=n4671 A=pConv_0/product_1_r[2]
+ B=pConv_0/product_2_r[2] CI=pConv_0/product_0_r[2]
XU7240 HA1 $PINS S=n4667 C=n4669 A=pConv_0/product_1_r[1]
+ B=pConv_0/product_0_r[1]
XU7241 NR2 $PINS O=n4874 I1=pConv_0/product_0_r[0] I2=pConv_0/product_1_r[0]
XU7242 INV1S $PINS O=n4666 I=pConv_0/product_2_r[0]
XU7243 ND2 $PINS O=n4875 I1=pConv_0/product_1_r[0] I2=pConv_0/product_0_r[0]
XU7244 OAI12HS $PINS O=n4873 A1=n4875 B1=n4874 B2=n4666
XU7245 ND2 $PINS O=n4871 I1=n4667 I2=pConv_0/product_2_r[1]
XU7246 INV1S $PINS O=n4668 I=n4871
XU7247 AOI12HS $PINS O=n4870 A1=n4668 B1=n4665 B2=n4873
XU7248 ND2 $PINS O=n4867 I1=n4670 I2=n4669
XU7249 ND2 $PINS O=n4862 I1=n4672 I2=n4671
XU7250 ND2 $PINS O=n4856 I1=n4674 I2=n4673
XU7251 OAI12HS $PINS O=n4675 A1=n4856 B1=n4855 B2=n4862
XU7252 AOI12HS $PINS O=n4830 A1=n4675 B1=n4676 B2=n4858
XU7253 FA1S $PINS S=n4674 CO=n4677 A=pConv_0/product_1_r[4]
+ B=pConv_0/product_2_r[4] CI=pConv_0/product_0_r[4]
XU7254 FA1S $PINS S=n4678 CO=n4679 A=pConv_0/product_1_r[5]
+ B=pConv_0/product_2_r[5] CI=pConv_0/product_0_r[5]
XU7255 NR2 $PINS O=n4847 I1=n4677 I2=n4678
XU7256 FA1S $PINS S=n4680 CO=n4681 A=pConv_0/product_1_r[6]
+ B=pConv_0/product_2_r[6] CI=pConv_0/product_0_r[6]
XU7257 FA1S $PINS S=n4682 CO=n4683 A=pConv_0/product_1_r[7]
+ B=pConv_0/product_2_r[7] CI=pConv_0/product_0_r[7]
XU7258 NR2 $PINS O=n4837 I1=n4681 I2=n4682
XU7259 ND2 $PINS O=n4688 I1=n4841 I2=n4686
XU7260 ND2 $PINS O=n4851 I1=n4678 I2=n4677
XU7261 ND2 $PINS O=n4845 I1=n4680 I2=n4679
XU7262 OAI12HS $PINS O=n4840 A1=n4845 B1=n4844 B2=n4851
XU7263 ND2 $PINS O=n4838 I1=n4682 I2=n4681
XU7264 ND2 $PINS O=n4828 I1=n4684 I2=n4683
XU7265 OAI12HS $PINS O=n4685 A1=n4828 B1=n4827 B2=n4838
XU7266 AOI12HS $PINS O=n4687 A1=n4685 B1=n4686 B2=n4840
XU7267 FA1S $PINS S=n4700 CO=n4701 A=pConv_0/product_1_r[13]
+ B=pConv_0/product_2_r[13] CI=pConv_0/product_0_r[13]
XU7268 FA1S $PINS S=n4702 CO=n4703 A=pConv_0/product_1_r[14]
+ B=pConv_0/product_2_r[14] CI=pConv_0/product_0_r[14]
XU7269 FA1S $PINS S=n4704 CO=n4705 A=pConv_0/product_1_r[15]
+ B=pConv_0/product_2_r[15] CI=pConv_0/product_0_r[15]
XU7270 NR2 $PINS O=n4774 I1=n4703 I2=n4704
XU7271 NR2 $PINS O=n4708 I1=n4762 I2=n4774
XU7272 ND2 $PINS O=n4710 I1=n4778 I2=n4708
XU7273 FA1S $PINS S=n4684 CO=n4689 A=pConv_0/product_1_r[8]
+ B=pConv_0/product_2_r[8] CI=pConv_0/product_0_r[8]
XU7274 FA1S $PINS S=n4690 CO=n4691 A=pConv_0/product_1_r[9]
+ B=pConv_0/product_2_r[9] CI=pConv_0/product_0_r[9]
XU7275 NR2 $PINS O=n4811 I1=n4817 I2=n4822
XU7276 FA1S $PINS S=n4696 CO=n4699 A=pConv_0/product_1_r[12]
+ B=pConv_0/product_2_r[12] CI=pConv_0/product_0_r[12]
XU7277 NR2 $PINS O=n4800 I1=n4695 I2=n4696
XU7278 FA1S $PINS S=n4692 CO=n4693 A=pConv_0/product_1_r[10]
+ B=pConv_0/product_2_r[10] CI=pConv_0/product_0_r[10]
XU7279 FA1S $PINS S=n4694 CO=n4695 A=pConv_0/product_1_r[11]
+ B=pConv_0/product_2_r[11] CI=pConv_0/product_0_r[11]
XU7280 ND2 $PINS O=n4797 I1=n4811 I2=n4698
XU7281 ND2 $PINS O=n4818 I1=n4692 I2=n4691
XU7282 OAI12HS $PINS O=n4812 A1=n4818 B1=n4817 B2=n4823
XU7283 ND2 $PINS O=n4809 I1=n4694 I2=n4693
XU7284 ND2 $PINS O=n4801 I1=n4696 I2=n4695
XU7285 OAI12HS $PINS O=n4697 A1=n4801 B1=n4800 B2=n4809
XU7286 AOI12HS $PINS O=n4796 A1=n4697 B1=n4698 B2=n4812
XU7287 ND2 $PINS O=n4794 I1=n4700 I2=n4699
XU7288 ND2 $PINS O=n4784 I1=n4702 I2=n4701
XU7289 OAI12HS $PINS O=n4777 A1=n4784 B1=n4783 B2=n4794
XU7290 ND2 $PINS O=n4775 I1=n4704 I2=n4703
XU7291 ND2 $PINS O=n4763 I1=n4706 I2=n4705
XU7292 OAI12HS $PINS O=n4707 A1=n4763 B1=n4762 B2=n4775
XU7293 AOI12HS $PINS O=n4709 A1=n4707 B1=n4708 B2=n4777
XU7294 FA1S $PINS S=n4724 CO=n4664 A=pConv_0/product_1_r[21]
+ B=DP_OP_56J1_122_9379/n251 CI=DP_OP_56J1_122_9379/n252
XU7295 NR2 $PINS O=n4729 I1=n4723 I2=n4724
XU7296 NR2 $PINS O=n4753 I1=n4715 I2=n4716
XU7297 FA1S $PINS S=n4706 CO=n4713 A=pConv_0/product_1_r[16]
+ B=pConv_0/product_2_r[16] CI=pConv_0/product_0_r[16]
XU7298 FA1S $PINS S=n4714 CO=n4715 A=pConv_0/product_1_r[17]
+ B=pConv_0/product_2_r[17] CI=pConv_0/product_0_r[17]
XU7299 NR2 $PINS O=n4758 I1=n4713 I2=n4714
XU7300 NR2 $PINS O=n4747 I1=n4753 I2=n4758
XU7301 FA1S $PINS S=n4720 CO=n4723 A=pConv_0/product_1_r[20]
+ B=pConv_0/product_2_r[20] CI=pConv_0/product_0_r[20]
XU7302 NR2 $PINS O=n4736 I1=n4719 I2=n4720
XU7303 FA1S $PINS S=n4716 CO=n4717 A=pConv_0/product_1_r[18]
+ B=pConv_0/product_2_r[18] CI=pConv_0/product_0_r[18]
XU7304 FA1S $PINS S=n4718 CO=n4719 A=pConv_0/product_1_r[19]
+ B=pConv_0/product_2_r[19] CI=pConv_0/product_0_r[19]
XU7305 NR2 $PINS O=n4739 I1=n4717 I2=n4718
XU7306 NR2 $PINS O=n4722 I1=n4736 I2=n4739
XU7307 ND2 $PINS O=n4733 I1=n4747 I2=n4722
XU7308 NR2 $PINS O=n4878 I1=n4729 I2=n4733
XU7309 INV1S $PINS O=n4726 I=n4878
XU7310 ND2 $PINS O=n4759 I1=n4714 I2=n4713
XU7311 ND2 $PINS O=n4754 I1=n4716 I2=n4715
XU7312 OAI12HS $PINS O=n4748 A1=n4754 B1=n4753 B2=n4759
XU7313 ND2 $PINS O=n4745 I1=n4718 I2=n4717
XU7314 ND2 $PINS O=n4737 I1=n4720 I2=n4719
XU7315 OAI12HS $PINS O=n4721 A1=n4737 B1=n4736 B2=n4745
XU7316 AOI12HS $PINS O=n4732 A1=n4721 B1=n4722 B2=n4748
XU7317 ND2 $PINS O=n4730 I1=n4724 I2=n4723
XU7318 OAI12HS $PINS O=n4882 A1=n4730 B1=n4732 B2=n4729
XU7319 INV1S $PINS O=n4725 I=n4882
XU7320 OAI12HS $PINS O=n4727 A1=n4725 B1=n4885 B2=n4726
XU7321 XNR2HS $PINS O=pconv_0_w[22] I1=n4728 I2=n4727
XU7322 INV1S $PINS O=n4731 I=n4729
XU7323 ND2 $PINS O=n4735 I1=n4731 I2=n4730
XU7324 OAI12HS $PINS O=n4734 A1=n4732 B1=n4885 B2=n4733
XU7325 XNR2HS $PINS O=pconv_0_w[21] I1=n4735 I2=n4734
XU7326 INV1S $PINS O=n4738 I=n4736
XU7327 INV1S $PINS O=n4746 I=n4739
XU7328 INV1S $PINS O=n4740 I=n4745
XU7329 AOI12HS $PINS O=n4741 A1=n4740 B1=n4748 B2=n4746
XU7330 XNR2HS $PINS O=pconv_0_w[20] I1=n4744 I2=n4743
XU7331 ND2 $PINS O=n4752 I1=n4746 I2=n4745
XU7332 INV1S $PINS O=n4750 I=n4747
XU7333 INV1S $PINS O=n4749 I=n4748
XU7334 XNR2HS $PINS O=pconv_0_w[19] I1=n4752 I2=n4751
XU7335 INV1S $PINS O=n4755 I=n4753
XU7336 OAI12HS $PINS O=n4756 A1=n4759 B1=n4885 B2=n4758
XU7337 XNR2HS $PINS O=pconv_0_w[18] I1=n4757 I2=n4756
XU7338 INV1S $PINS O=n4760 I=n4758
XU7339 XOR2HS $PINS O=pconv_0_w[17] I1=n4761 I2=n2967
XU7340 INV1S $PINS O=n4764 I=n4762
XU7341 INV1S $PINS O=n4766 I=n4778
XU7342 NR2 $PINS O=n4769 I1=n4774 I2=n4766
XU7343 INV1S $PINS O=n4787 I=n4797
XU7344 INV1S $PINS O=n4789 I=n4796
XU7345 INV1S $PINS O=n4767 I=n4777
XU7346 OAI12HS $PINS O=n4768 A1=n4775 B1=n4767 B2=n4774
XU7347 AOI12HS $PINS O=n4770 A1=n4768 B1=n4789 B2=n4769
XU7348 OAI12HS $PINS O=n4772 A1=n4770 B1=FE_DBTN15_n4765 B2=n4771
XU7349 XNR2HS $PINS O=pconv_0_w[16] I1=n4773 I2=n4772
XU7350 INV1S $PINS O=n4776 I=n4774
XU7351 ND2 $PINS O=n4782 I1=n4776 I2=n4775
XU7352 AOI12HS $PINS O=n4779 A1=n4777 B1=n4789 B2=n4778
XU7353 XNR2HS $PINS O=pconv_0_w[15] I1=n4782 I2=n4781
XU7354 INV1S $PINS O=n4785 I=n4783
XU7355 ND2S $PINS O=n4793 I1=n4785 I2=n4784
XU7356 INV1S $PINS O=n4795 I=n4786
XU7357 INV1S $PINS O=n4788 I=n4794
XU7358 AOI12HS $PINS O=n4790 A1=n4788 B1=n4789 B2=n4795
XU7359 OAI12HS $PINS O=n4792 A1=n4790 B1=FE_DBTN15_n4765 B2=n4791
XU7360 XNR2HS $PINS O=pconv_0_w[14] I1=n4793 I2=n4792
XU7361 OAI12HS $PINS O=n4798 A1=n4796 B1=FE_OFN1132_FE_DBTN15_n4765 B2=n4797
XU7362 XNR2HS $PINS O=pconv_0_w[13] I1=n4799 I2=n4798
XU7363 INV1S $PINS O=n4802 I=n4800
XU7364 INV1S $PINS O=n4810 I=n4803
XU7365 INV1S $PINS O=n4804 I=n4809
XU7366 AOI12HS $PINS O=n4805 A1=n4804 B1=n4812 B2=n4810
XU7367 XNR2HS $PINS O=pconv_0_w[12] I1=n4808 I2=n4807
XU7368 INV1S $PINS O=n4814 I=n4811
XU7369 INV1S $PINS O=n4813 I=n4812
XU7370 XNR2HS $PINS O=pconv_0_w[11] I1=n4816 I2=n4815
XU7371 INV1S $PINS O=n4819 I=n4817
XU7372 ND2S $PINS O=n4821 I1=n4819 I2=n4818
XU7373 OAI12HS $PINS O=n4820 A1=n4823 B1=FE_OFN1132_FE_DBTN15_n4765 B2=n4822
XU7374 XNR2HS $PINS O=pconv_0_w[10] I1=n4821 I2=n4820
XU7375 INV1S $PINS O=n4824 I=n4822
XU7376 XOR2HS $PINS O=pconv_0_w[9] I1=n4826 I2=FE_OFN1132_FE_DBTN15_n4765
XU7377 INV1S $PINS O=n4829 I=n4827
XU7378 INV1S $PINS O=n4853 I=n4830
XU7379 INV1S $PINS O=n4831 I=n4841
XU7380 NR2 $PINS O=n4834 I1=n4837 I2=n4831
XU7381 INV1S $PINS O=n4832 I=n4840
XU7382 OAI12HS $PINS O=n4833 A1=n4838 B1=n4832 B2=n4837
XU7383 AOI12HS $PINS O=n4835 A1=n4833 B1=n4853 B2=n4834
XU7384 XOR2HS $PINS O=pconv_0_w[8] I1=n4836 I2=n4835
XU7385 INV1S $PINS O=n4839 I=n4837
XU7386 AOI12HS $PINS O=n4842 A1=n4840 B1=n4853 B2=n4841
XU7387 XOR2HS $PINS O=pconv_0_w[7] I1=n4843 I2=n4842
XU7388 INV1S $PINS O=n4846 I=n4844
XU7389 ND2S $PINS O=n4850 I1=n4846 I2=n4845
XU7390 INV1S $PINS O=n4852 I=n4847
XU7391 INV1S $PINS O=n4848 I=n4851
XU7392 AOI12HS $PINS O=n4849 A1=n4848 B1=n4853 B2=n4852
XU7393 XOR2HS $PINS O=pconv_0_w[6] I1=n4850 I2=n4849
XU7394 XNR2HS $PINS O=pconv_0_w[5] I1=n4854 I2=n4853
XU7395 INV1S $PINS O=n4857 I=n4855
XU7396 INV1S $PINS O=n4864 I=n4858
XU7397 OAI12HS $PINS O=n4859 A1=n4862 B1=n4864 B2=n4861
XU7398 XNR2HS $PINS O=pconv_0_w[4] I1=n4860 I2=n4859
XU7399 INV1S $PINS O=n4863 I=n4861
XU7400 XOR2HS $PINS O=pconv_0_w[3] I1=n4865 I2=n4864
XU7401 INV1S $PINS O=n4868 I=n4866
XU7402 XOR2HS $PINS O=pconv_0_w[2] I1=n4870 I2=n4869
XU7403 ND2 $PINS O=n4872 I1=n4665 I2=n4871
XU7404 XNR2HS $PINS O=pconv_0_w[1] I1=n4873 I2=n4872
XU7405 INV1S $PINS O=n4876 I=n4874
XU7406 ND2 $PINS O=n4877 I1=n4876 I2=n4875
XU7407 XNR2HS $PINS O=pconv_0_w[0] I1=pConv_0/product_2_r[0] I2=n4877
XU7408 INV1S $PINS O=n4880 I=n4879
XU7409 AOI12HS $PINS O=n4883 A1=n4880 B1=n4882 B2=n4881
XU7410 OR2 $PINS O=n5103 I1=DP_OP_57J1_123_9379/n253 I2=n4886
XU7411 ND2 $PINS O=n5101 I1=n4886 I2=DP_OP_57J1_123_9379/n253
XU7412 ND2 $PINS O=n4950 I1=n5103 I2=n5101
XU7413 NR2 $PINS O=n5077 I1=n4895 I2=n4896
XU7414 FA1S $PINS S=n4894 CO=n4895 A=pConv_1/product_1_r[3]
+ B=pConv_1/product_2_r[3] CI=pConv_1/product_0_r[3]
XU7415 NR2 $PINS O=n4898 I1=n5077 I2=n5083
XU7416 FA1S $PINS S=n4892 CO=n4893 A=pConv_1/product_1_r[2]
+ B=pConv_1/product_2_r[2] CI=pConv_1/product_0_r[2]
XU7417 HA1 $PINS S=n4889 C=n4891 A=pConv_1/product_1_r[1]
+ B=pConv_1/product_0_r[1]
XU7418 NR2 $PINS O=n5096 I1=pConv_1/product_0_r[0] I2=pConv_1/product_1_r[0]
XU7419 INV1S $PINS O=n4888 I=pConv_1/product_2_r[0]
XU7420 ND2 $PINS O=n5097 I1=pConv_1/product_1_r[0] I2=pConv_1/product_0_r[0]
XU7421 OAI12HS $PINS O=n5095 A1=n5097 B1=n5096 B2=n4888
XU7422 ND2 $PINS O=n5093 I1=n4889 I2=pConv_1/product_2_r[1]
XU7423 INV1S $PINS O=n4890 I=n5093
XU7424 AOI12HS $PINS O=n5092 A1=n4890 B1=n4887 B2=n5095
XU7425 ND2 $PINS O=n5089 I1=n4892 I2=n4891
XU7426 ND2 $PINS O=n5084 I1=n4894 I2=n4893
XU7427 ND2 $PINS O=n5078 I1=n4896 I2=n4895
XU7428 OAI12HS $PINS O=n4897 A1=n5078 B1=n5077 B2=n5084
XU7429 AOI12HS $PINS O=n5052 A1=n4897 B1=n4898 B2=n5080
XU7430 FA1S $PINS S=n4896 CO=n4899 A=pConv_1/product_1_r[4]
+ B=pConv_1/product_2_r[4] CI=pConv_1/product_0_r[4]
XU7431 FA1S $PINS S=n4900 CO=n4901 A=pConv_1/product_1_r[5]
+ B=pConv_1/product_2_r[5] CI=pConv_1/product_0_r[5]
XU7432 NR2 $PINS O=n5069 I1=n4899 I2=n4900
XU7433 FA1S $PINS S=n4902 CO=n4903 A=pConv_1/product_1_r[6]
+ B=pConv_1/product_2_r[6] CI=pConv_1/product_0_r[6]
XU7434 FA1S $PINS S=n4904 CO=n4905 A=pConv_1/product_1_r[7]
+ B=pConv_1/product_2_r[7] CI=pConv_1/product_0_r[7]
XU7435 NR2 $PINS O=n5059 I1=n4903 I2=n4904
XU7436 ND2 $PINS O=n4910 I1=n5063 I2=n4908
XU7437 ND2 $PINS O=n5073 I1=n4900 I2=n4899
XU7438 ND2 $PINS O=n5067 I1=n4902 I2=n4901
XU7439 OAI12HS $PINS O=n5062 A1=n5067 B1=n5066 B2=n5073
XU7440 ND2 $PINS O=n5060 I1=n4904 I2=n4903
XU7441 ND2 $PINS O=n5050 I1=n4906 I2=n4905
XU7442 OAI12HS $PINS O=n4907 A1=n5050 B1=n5049 B2=n5060
XU7443 FA1S $PINS S=n4922 CO=n4923 A=pConv_1/product_1_r[13]
+ B=pConv_1/product_2_r[13] CI=pConv_1/product_0_r[13]
XU7444 FA1S $PINS S=n4924 CO=n4925 A=pConv_1/product_1_r[14]
+ B=pConv_1/product_2_r[14] CI=pConv_1/product_0_r[14]
XU7445 FA1S $PINS S=n4926 CO=n4927 A=pConv_1/product_1_r[15]
+ B=pConv_1/product_2_r[15] CI=pConv_1/product_0_r[15]
XU7446 NR2 $PINS O=n4996 I1=n4925 I2=n4926
XU7447 NR2 $PINS O=n4930 I1=n4984 I2=n4996
XU7448 ND2 $PINS O=n4932 I1=n5000 I2=n4930
XU7449 FA1S $PINS S=n4906 CO=n4911 A=pConv_1/product_1_r[8]
+ B=pConv_1/product_2_r[8] CI=pConv_1/product_0_r[8]
XU7450 FA1S $PINS S=n4912 CO=n4913 A=pConv_1/product_1_r[9]
+ B=pConv_1/product_2_r[9] CI=pConv_1/product_0_r[9]
XU7451 NR2 $PINS O=n5044 I1=n4911 I2=n4912
XU7452 NR2 $PINS O=n5033 I1=n5039 I2=n5044
XU7453 FA1S $PINS S=n4918 CO=n4921 A=pConv_1/product_1_r[12]
+ B=pConv_1/product_2_r[12] CI=pConv_1/product_0_r[12]
XU7454 NR2 $PINS O=n5022 I1=n4917 I2=n4918
XU7455 FA1S $PINS S=n4914 CO=n4915 A=pConv_1/product_1_r[10]
+ B=pConv_1/product_2_r[10] CI=pConv_1/product_0_r[10]
XU7456 FA1S $PINS S=n4916 CO=n4917 A=pConv_1/product_1_r[11]
+ B=pConv_1/product_2_r[11] CI=pConv_1/product_0_r[11]
XU7457 ND2 $PINS O=n5019 I1=n5033 I2=n4920
XU7458 ND2 $PINS O=n5040 I1=n4914 I2=n4913
XU7459 OAI12HS $PINS O=n5034 A1=n5040 B1=n5039 B2=n5045
XU7460 ND2 $PINS O=n5031 I1=n4916 I2=n4915
XU7461 ND2 $PINS O=n5023 I1=n4918 I2=n4917
XU7462 OAI12HS $PINS O=n4919 A1=n5023 B1=n5022 B2=n5031
XU7463 AOI12HS $PINS O=n5018 A1=n4919 B1=n4920 B2=n5034
XU7464 ND2 $PINS O=n5016 I1=n4922 I2=n4921
XU7465 ND2 $PINS O=n5006 I1=n4924 I2=n4923
XU7466 OAI12HS $PINS O=n4999 A1=n5006 B1=n5005 B2=n5016
XU7467 ND2 $PINS O=n4997 I1=n4926 I2=n4925
XU7468 ND2 $PINS O=n4985 I1=n4928 I2=n4927
XU7469 OAI12HS $PINS O=n4929 A1=n4985 B1=n4984 B2=n4997
XU7470 AOI12HS $PINS O=n4931 A1=n4929 B1=n4930 B2=n4999
XU7471 FA1S $PINS S=n4946 CO=n4886 A=pConv_1/product_1_r[21]
+ B=DP_OP_57J1_123_9379/n251 CI=DP_OP_57J1_123_9379/n252
XU7472 NR2 $PINS O=n4951 I1=n4945 I2=n4946
XU7473 NR2 $PINS O=n4975 I1=n4937 I2=n4938
XU7474 FA1S $PINS S=n4928 CO=n4935 A=pConv_1/product_1_r[16]
+ B=pConv_1/product_2_r[16] CI=pConv_1/product_0_r[16]
XU7475 FA1S $PINS S=n4936 CO=n4937 A=pConv_1/product_1_r[17]
+ B=pConv_1/product_2_r[17] CI=pConv_1/product_0_r[17]
XU7476 NR2 $PINS O=n4980 I1=n4935 I2=n4936
XU7477 NR2 $PINS O=n4969 I1=n4975 I2=n4980
XU7478 FA1S $PINS S=n4942 CO=n4945 A=pConv_1/product_1_r[20]
+ B=pConv_1/product_2_r[20] CI=pConv_1/product_0_r[20]
XU7479 NR2 $PINS O=n4958 I1=n4941 I2=n4942
XU7480 FA1S $PINS S=n4938 CO=n4939 A=pConv_1/product_1_r[18]
+ B=pConv_1/product_2_r[18] CI=pConv_1/product_0_r[18]
XU7481 FA1S $PINS S=n4940 CO=n4941 A=pConv_1/product_1_r[19]
+ B=pConv_1/product_2_r[19] CI=pConv_1/product_0_r[19]
XU7482 NR2 $PINS O=n4961 I1=n4939 I2=n4940
XU7483 NR2 $PINS O=n4944 I1=n4958 I2=n4961
XU7484 ND2 $PINS O=n4955 I1=n4969 I2=n4944
XU7485 NR2 $PINS O=n5100 I1=n4951 I2=n4955
XU7486 INV1S $PINS O=n4948 I=n5100
XU7487 ND2 $PINS O=n4981 I1=n4936 I2=n4935
XU7488 ND2 $PINS O=n4976 I1=n4938 I2=n4937
XU7489 OAI12HS $PINS O=n4970 A1=n4976 B1=n4975 B2=n4981
XU7490 ND2 $PINS O=n4967 I1=n4940 I2=n4939
XU7491 ND2 $PINS O=n4959 I1=n4942 I2=n4941
XU7492 OAI12HS $PINS O=n4943 A1=n4959 B1=n4958 B2=n4967
XU7493 AOI12HS $PINS O=n4954 A1=n4943 B1=n4944 B2=n4970
XU7494 ND2 $PINS O=n4952 I1=n4946 I2=n4945
XU7495 OAI12HS $PINS O=n5104 A1=n4952 B1=n4954 B2=n4951
XU7496 INV1S $PINS O=n4947 I=n5104
XU7497 OAI12HS $PINS O=n4949 A1=n4947 B1=n5107 B2=n4948
XU7498 XNR2HS $PINS O=pconv_1_w[22] I1=n4950 I2=n4949
XU7499 INV1S $PINS O=n4953 I=n4951
XU7500 ND2 $PINS O=n4957 I1=n4953 I2=n4952
XU7501 OAI12HS $PINS O=n4956 A1=n4954 B1=n5107 B2=n4955
XU7502 XNR2HS $PINS O=pconv_1_w[21] I1=n4957 I2=n4956
XU7503 INV1S $PINS O=n4960 I=n4958
XU7504 INV1S $PINS O=n4968 I=n4961
XU7505 INV1S $PINS O=n4962 I=n4967
XU7506 AOI12HS $PINS O=n4963 A1=n4962 B1=n4970 B2=n4968
XU7507 XNR2HS $PINS O=pconv_1_w[20] I1=n4966 I2=n4965
XU7508 ND2 $PINS O=n4974 I1=n4968 I2=n4967
XU7509 INV1S $PINS O=n4972 I=n4969
XU7510 INV1S $PINS O=n4971 I=n4970
XU7511 XNR2HS $PINS O=pconv_1_w[19] I1=n4974 I2=n4973
XU7512 INV1S $PINS O=n4977 I=n4975
XU7513 OAI12HS $PINS O=n4978 A1=n4981 B1=n5107 B2=n4980
XU7514 XNR2HS $PINS O=pconv_1_w[18] I1=n4979 I2=n4978
XU7515 INV1S $PINS O=n4982 I=n4980
XU7516 XOR2HS $PINS O=pconv_1_w[17] I1=n4983 I2=n2968
XU7517 INV1S $PINS O=n4986 I=n4984
XU7518 INV1S $PINS O=n4988 I=n5000
XU7519 NR2 $PINS O=n4991 I1=n4996 I2=n4988
XU7520 INV1S $PINS O=n5009 I=n5019
XU7521 INV1S $PINS O=n5011 I=n5018
XU7522 INV1S $PINS O=n4989 I=n4999
XU7523 OAI12HS $PINS O=n4990 A1=n4997 B1=n4989 B2=n4996
XU7524 AOI12HS $PINS O=n4992 A1=n4990 B1=n5011 B2=n4991
XU7525 OAI12HS $PINS O=n4994 A1=n4992 B1=FE_DBTN14_n4987 B2=n4993
XU7526 XNR2HS $PINS O=pconv_1_w[16] I1=n4995 I2=n4994
XU7527 INV1S $PINS O=n4998 I=n4996
XU7528 ND2S $PINS O=n5004 I1=n4998 I2=n4997
XU7529 AOI12HS $PINS O=n5001 A1=n4999 B1=n5011 B2=n5000
XU7530 XNR2HS $PINS O=pconv_1_w[15] I1=n5004 I2=n5003
XU7531 INV1S $PINS O=n5007 I=n5005
XU7532 ND2S $PINS O=n5015 I1=n5007 I2=n5006
XU7533 INV1S $PINS O=n5017 I=n5008
XU7534 INV1S $PINS O=n5010 I=n5016
XU7535 AOI12HS $PINS O=n5012 A1=n5010 B1=n5011 B2=n5017
XU7536 OAI12HS $PINS O=n5014 A1=n5012 B1=FE_DBTN14_n4987 B2=n5013
XU7537 XNR2HS $PINS O=pconv_1_w[14] I1=n5015 I2=n5014
XU7538 OAI12HS $PINS O=n5020 A1=n5018 B1=FE_DBTN14_n4987 B2=n5019
XU7539 XNR2HS $PINS O=pconv_1_w[13] I1=n5021 I2=n5020
XU7540 INV1S $PINS O=n5024 I=n5022
XU7541 INV1S $PINS O=n5032 I=n5025
XU7542 INV1S $PINS O=n5026 I=n5031
XU7543 AOI12HS $PINS O=n5027 A1=n5026 B1=n5034 B2=n5032
XU7544 XNR2HS $PINS O=pconv_1_w[12] I1=n5030 I2=n5029
XU7545 INV1S $PINS O=n5036 I=n5033
XU7546 INV1S $PINS O=n5035 I=n5034
XU7547 XNR2HS $PINS O=pconv_1_w[11] I1=n5038 I2=n5037
XU7548 INV1S $PINS O=n5041 I=n5039
XU7549 ND2S $PINS O=n5043 I1=n5041 I2=n5040
XU7550 OAI12HS $PINS O=n5042 A1=n5045 B1=FE_OFN1133_FE_DBTN14_n4987 B2=n5044
XU7551 XNR2HS $PINS O=pconv_1_w[10] I1=n5043 I2=n5042
XU7552 INV1S $PINS O=n5046 I=n5044
XU7553 ND2 $PINS O=n5048 I1=n5046 I2=n5045
XU7554 XOR2HS $PINS O=pconv_1_w[9] I1=n5048 I2=FE_OFN1133_FE_DBTN14_n4987
XU7555 INV1S $PINS O=n5051 I=n5049
XU7556 INV1S $PINS O=n5075 I=n5052
XU7557 INV1S $PINS O=n5053 I=n5063
XU7558 NR2 $PINS O=n5056 I1=n5059 I2=n5053
XU7559 INV1S $PINS O=n5054 I=n5062
XU7560 OAI12HS $PINS O=n5055 A1=n5060 B1=n5054 B2=n5059
XU7561 AOI12HS $PINS O=n5057 A1=n5055 B1=n5075 B2=n5056
XU7562 XOR2HS $PINS O=pconv_1_w[8] I1=n5058 I2=n5057
XU7563 INV1S $PINS O=n5061 I=n5059
XU7564 AOI12HS $PINS O=n5064 A1=n5062 B1=n5075 B2=n5063
XU7565 XOR2HS $PINS O=pconv_1_w[7] I1=n5065 I2=n5064
XU7566 INV1S $PINS O=n5068 I=n5066
XU7567 ND2S $PINS O=n5072 I1=n5068 I2=n5067
XU7568 INV1S $PINS O=n5074 I=n5069
XU7569 INV1S $PINS O=n5070 I=n5073
XU7570 AOI12HS $PINS O=n5071 A1=n5070 B1=n5075 B2=n5074
XU7571 XOR2HS $PINS O=pconv_1_w[6] I1=n5072 I2=n5071
XU7572 XNR2HS $PINS O=pconv_1_w[5] I1=n5076 I2=n5075
XU7573 INV1S $PINS O=n5079 I=n5077
XU7574 INV1S $PINS O=n5086 I=n5080
XU7575 OAI12HS $PINS O=n5081 A1=n5084 B1=n5086 B2=n5083
XU7576 XNR2HS $PINS O=pconv_1_w[4] I1=n5082 I2=n5081
XU7577 INV1S $PINS O=n5085 I=n5083
XU7578 XOR2HS $PINS O=pconv_1_w[3] I1=n5087 I2=n5086
XU7579 INV1S $PINS O=n5090 I=n5088
XU7580 XOR2HS $PINS O=pconv_1_w[2] I1=n5092 I2=n5091
XU7581 ND2 $PINS O=n5094 I1=n4887 I2=n5093
XU7582 XNR2HS $PINS O=pconv_1_w[1] I1=n5095 I2=n5094
XU7583 INV1S $PINS O=n5098 I=n5096
XU7584 ND2 $PINS O=n5099 I1=n5098 I2=n5097
XU7585 XNR2HS $PINS O=pconv_1_w[0] I1=pConv_1/product_2_r[0] I2=n5099
XU7586 INV1S $PINS O=n5102 I=n5101
XU7587 AOI12HS $PINS O=n5105 A1=n5102 B1=n5104 B2=n5103
XU7588 OR2 $PINS O=n5325 I1=DP_OP_58J1_124_9379/n253 I2=n5108
XU7589 ND2 $PINS O=n5323 I1=n5108 I2=DP_OP_58J1_124_9379/n253
XU7590 ND2 $PINS O=n5172 I1=n5325 I2=n5323
XU7591 NR2 $PINS O=n5299 I1=n5117 I2=n5118
XU7592 FA1S $PINS S=n5116 CO=n5117 A=pConv_2/product_1_r[3]
+ B=pConv_2/product_2_r[3] CI=pConv_2/product_0_r[3]
XU7593 NR2 $PINS O=n5305 I1=n5115 I2=n5116
XU7594 NR2 $PINS O=n5120 I1=n5299 I2=n5305
XU7595 FA1S $PINS S=n5114 CO=n5115 A=pConv_2/product_1_r[2]
+ B=pConv_2/product_2_r[2] CI=pConv_2/product_0_r[2]
XU7596 HA1 $PINS S=n5111 C=n5113 A=pConv_2/product_1_r[1]
+ B=pConv_2/product_0_r[1]
XU7597 NR2 $PINS O=n5318 I1=pConv_2/product_0_r[0] I2=pConv_2/product_1_r[0]
XU7598 INV1S $PINS O=n5110 I=pConv_2/product_2_r[0]
XU7599 ND2 $PINS O=n5319 I1=pConv_2/product_1_r[0] I2=pConv_2/product_0_r[0]
XU7600 OAI12HS $PINS O=n5317 A1=n5319 B1=n5318 B2=n5110
XU7601 ND2 $PINS O=n5315 I1=n5111 I2=pConv_2/product_2_r[1]
XU7602 INV1S $PINS O=n5112 I=n5315
XU7603 AOI12HS $PINS O=n5314 A1=n5112 B1=n5109 B2=n5317
XU7604 ND2 $PINS O=n5311 I1=n5114 I2=n5113
XU7605 ND2 $PINS O=n5306 I1=n5116 I2=n5115
XU7606 ND2 $PINS O=n5300 I1=n5118 I2=n5117
XU7607 OAI12HS $PINS O=n5119 A1=n5300 B1=n5299 B2=n5306
XU7608 AOI12HS $PINS O=n5274 A1=n5119 B1=n5120 B2=n5302
XU7609 FA1S $PINS S=n5118 CO=n5121 A=pConv_2/product_1_r[4]
+ B=pConv_2/product_2_r[4] CI=pConv_2/product_0_r[4]
XU7610 FA1S $PINS S=n5122 CO=n5123 A=pConv_2/product_1_r[5]
+ B=pConv_2/product_2_r[5] CI=pConv_2/product_0_r[5]
XU7611 NR2 $PINS O=n5291 I1=n5121 I2=n5122
XU7612 FA1S $PINS S=n5124 CO=n5125 A=pConv_2/product_1_r[6]
+ B=pConv_2/product_2_r[6] CI=pConv_2/product_0_r[6]
XU7613 FA1S $PINS S=n5126 CO=n5127 A=pConv_2/product_1_r[7]
+ B=pConv_2/product_2_r[7] CI=pConv_2/product_0_r[7]
XU7614 NR2 $PINS O=n5281 I1=n5125 I2=n5126
XU7615 ND2 $PINS O=n5132 I1=n5285 I2=n5130
XU7616 ND2 $PINS O=n5295 I1=n5122 I2=n5121
XU7617 ND2 $PINS O=n5289 I1=n5124 I2=n5123
XU7618 OAI12HS $PINS O=n5284 A1=n5289 B1=n5288 B2=n5295
XU7619 ND2 $PINS O=n5282 I1=n5126 I2=n5125
XU7620 ND2 $PINS O=n5272 I1=n5128 I2=n5127
XU7621 OAI12HS $PINS O=n5129 A1=n5272 B1=n5271 B2=n5282
XU7622 FA1S $PINS S=n5144 CO=n5145 A=pConv_2/product_1_r[13]
+ B=pConv_2/product_2_r[13] CI=pConv_2/product_0_r[13]
XU7623 FA1S $PINS S=n5146 CO=n5147 A=pConv_2/product_1_r[14]
+ B=pConv_2/product_2_r[14] CI=pConv_2/product_0_r[14]
XU7624 FA1S $PINS S=n5148 CO=n5149 A=pConv_2/product_1_r[15]
+ B=pConv_2/product_2_r[15] CI=pConv_2/product_0_r[15]
XU7625 NR2 $PINS O=n5218 I1=n5147 I2=n5148
XU7626 NR2 $PINS O=n5152 I1=n5206 I2=n5218
XU7627 ND2 $PINS O=n5154 I1=n5222 I2=n5152
XU7628 FA1S $PINS S=n5128 CO=n5133 A=pConv_2/product_1_r[8]
+ B=pConv_2/product_2_r[8] CI=pConv_2/product_0_r[8]
XU7629 FA1S $PINS S=n5134 CO=n5135 A=pConv_2/product_1_r[9]
+ B=pConv_2/product_2_r[9] CI=pConv_2/product_0_r[9]
XU7630 NR2 $PINS O=n5266 I1=n5133 I2=n5134
XU7631 NR2 $PINS O=n5255 I1=n5261 I2=n5266
XU7632 FA1S $PINS S=n5140 CO=n5143 A=pConv_2/product_1_r[12]
+ B=pConv_2/product_2_r[12] CI=pConv_2/product_0_r[12]
XU7633 NR2 $PINS O=n5244 I1=n5139 I2=n5140
XU7634 FA1S $PINS S=n5136 CO=n5137 A=pConv_2/product_1_r[10]
+ B=pConv_2/product_2_r[10] CI=pConv_2/product_0_r[10]
XU7635 FA1S $PINS S=n5138 CO=n5139 A=pConv_2/product_1_r[11]
+ B=pConv_2/product_2_r[11] CI=pConv_2/product_0_r[11]
XU7636 ND2 $PINS O=n5241 I1=n5255 I2=n5142
XU7637 ND2 $PINS O=n5262 I1=n5136 I2=n5135
XU7638 OAI12HS $PINS O=n5256 A1=n5262 B1=n5261 B2=n5267
XU7639 ND2 $PINS O=n5253 I1=n5138 I2=n5137
XU7640 ND2 $PINS O=n5245 I1=n5140 I2=n5139
XU7641 OAI12HS $PINS O=n5141 A1=n5245 B1=n5244 B2=n5253
XU7642 AOI12HS $PINS O=n5240 A1=n5141 B1=n5142 B2=n5256
XU7643 ND2 $PINS O=n5238 I1=n5144 I2=n5143
XU7644 ND2 $PINS O=n5228 I1=n5146 I2=n5145
XU7645 OAI12HS $PINS O=n5221 A1=n5228 B1=n5227 B2=n5238
XU7646 ND2 $PINS O=n5219 I1=n5148 I2=n5147
XU7647 ND2 $PINS O=n5207 I1=n5150 I2=n5149
XU7648 OAI12HS $PINS O=n5151 A1=n5207 B1=n5206 B2=n5219
XU7649 AOI12HS $PINS O=n5153 A1=n5151 B1=n5152 B2=n5221
XU7650 OAI12HS $PINS O=n5155 A1=n5153 B1=n5240 B2=n5154
XU7651 AOI12HS $PINS O=n5329 A1=n5155 B1=n5209 B2=n5156
XU7652 FA1S $PINS S=n5168 CO=n5108 A=pConv_2/product_1_r[21]
+ B=DP_OP_58J1_124_9379/n251 CI=DP_OP_58J1_124_9379/n252
XU7653 NR2 $PINS O=n5173 I1=n5167 I2=n5168
XU7654 NR2 $PINS O=n5197 I1=n5159 I2=n5160
XU7655 FA1S $PINS S=n5150 CO=n5157 A=pConv_2/product_1_r[16]
+ B=pConv_2/product_2_r[16] CI=pConv_2/product_0_r[16]
XU7656 FA1S $PINS S=n5158 CO=n5159 A=n1975 B=pConv_2/product_2_r[17]
+ CI=pConv_2/product_0_r[17]
XU7657 NR2 $PINS O=n5202 I1=n5157 I2=n5158
XU7658 NR2 $PINS O=n5191 I1=n5197 I2=n5202
XU7659 FA1S $PINS S=n5164 CO=n5167 A=n1914 B=pConv_2/product_2_r[20]
+ CI=pConv_2/product_0_r[20]
XU7660 NR2 $PINS O=n5180 I1=n5163 I2=n5164
XU7661 FA1S $PINS S=n5160 CO=n5161 A=pConv_2/product_1_r[18]
+ B=pConv_2/product_2_r[18] CI=pConv_2/product_0_r[18]
XU7662 FA1S $PINS S=n5162 CO=n5163 A=pConv_2/product_1_r[19]
+ B=pConv_2/product_2_r[19] CI=pConv_2/product_0_r[19]
XU7663 NR2 $PINS O=n5183 I1=n5161 I2=n5162
XU7664 NR2 $PINS O=n5166 I1=n5180 I2=n5183
XU7665 ND2 $PINS O=n5177 I1=n5191 I2=n5166
XU7666 NR2 $PINS O=n5322 I1=n5173 I2=n5177
XU7667 INV1S $PINS O=n5170 I=n5322
XU7668 ND2 $PINS O=n5203 I1=n5158 I2=n5157
XU7669 ND2 $PINS O=n5198 I1=n5160 I2=n5159
XU7670 OAI12HS $PINS O=n5192 A1=n5198 B1=n5197 B2=n5203
XU7671 ND2 $PINS O=n5189 I1=n5162 I2=n5161
XU7672 ND2 $PINS O=n5181 I1=n5164 I2=n5163
XU7673 OAI12HS $PINS O=n5165 A1=n5181 B1=n5180 B2=n5189
XU7674 AOI12HS $PINS O=n5176 A1=n5165 B1=n5166 B2=n5192
XU7675 ND2 $PINS O=n5174 I1=n5168 I2=n5167
XU7676 OAI12HS $PINS O=n5326 A1=n5174 B1=n5176 B2=n5173
XU7677 INV1S $PINS O=n5169 I=n5326
XU7678 OAI12HS $PINS O=n5171 A1=n5169 B1=n5329 B2=n5170
XU7679 XNR2HS $PINS O=pconv_2_w[22] I1=n5172 I2=n5171
XU7680 INV1S $PINS O=n5175 I=n5173
XU7681 ND2 $PINS O=n5179 I1=n5175 I2=n5174
XU7682 OAI12HS $PINS O=n5178 A1=n5176 B1=FE_OFN1158_n5329 B2=n5177
XU7683 XNR2HS $PINS O=pconv_2_w[21] I1=n5179 I2=n5178
XU7684 INV1S $PINS O=n5182 I=n5180
XU7685 INV1S $PINS O=n5190 I=n5183
XU7686 INV1S $PINS O=n5184 I=n5189
XU7687 AOI12HS $PINS O=n5185 A1=n5184 B1=n5192 B2=n5190
XU7688 OAI12HS $PINS O=n5187 A1=n5185 B1=FE_OFN1158_n5329 B2=n5186
XU7689 XNR2HS $PINS O=pconv_2_w[20] I1=n5188 I2=n5187
XU7690 ND2 $PINS O=n5196 I1=n5190 I2=n5189
XU7691 INV1S $PINS O=n5194 I=n5191
XU7692 INV1S $PINS O=n5193 I=n5192
XU7693 OAI12HS $PINS O=n5195 A1=n5193 B1=FE_OFN1158_n5329 B2=n5194
XU7694 XNR2HS $PINS O=pconv_2_w[19] I1=n5196 I2=n5195
XU7695 INV1S $PINS O=n5199 I=n5197
XU7696 OAI12HS $PINS O=n5200 A1=n5203 B1=FE_OFN1158_n5329 B2=n5202
XU7697 XNR2HS $PINS O=pconv_2_w[18] I1=n5201 I2=n5200
XU7698 INV1S $PINS O=n5204 I=n5202
XU7699 XOR2HS $PINS O=pconv_2_w[17] I1=n5205 I2=FE_OFN1158_n5329
XU7700 INV1S $PINS O=n5208 I=n5206
XU7701 INV1S $PINS O=n5210 I=n5222
XU7702 NR2 $PINS O=n5213 I1=n5218 I2=n5210
XU7703 INV1S $PINS O=n5231 I=n5241
XU7704 INV1S $PINS O=n5233 I=n5240
XU7705 INV1S $PINS O=n5211 I=n5221
XU7706 OAI12HS $PINS O=n5212 A1=n5219 B1=n5211 B2=n5218
XU7707 AOI12HS $PINS O=n5214 A1=n5212 B1=n5233 B2=n5213
XU7708 OAI12HS $PINS O=n5216 A1=n5214 B1=FE_OFN1134_FE_DBTN13_n5209 B2=n5215
XU7709 XNR2HS $PINS O=pconv_2_w[16] I1=n5217 I2=n5216
XU7710 INV1S $PINS O=n5220 I=n5218
XU7711 ND2 $PINS O=n5226 I1=n5220 I2=n5219
XU7712 AOI12HS $PINS O=n5223 A1=n5221 B1=n5233 B2=n5222
XU7713 XNR2HS $PINS O=pconv_2_w[15] I1=n5226 I2=n5225
XU7714 INV1S $PINS O=n5229 I=n5227
XU7715 ND2S $PINS O=n5237 I1=n5229 I2=n5228
XU7716 INV1S $PINS O=n5239 I=n5230
XU7717 INV1S $PINS O=n5232 I=n5238
XU7718 AOI12HS $PINS O=n5234 A1=n5232 B1=n5233 B2=n5239
XU7719 OAI12HS $PINS O=n5236 A1=n5234 B1=FE_OFN1134_FE_DBTN13_n5209 B2=n5235
XU7720 XNR2HS $PINS O=pconv_2_w[14] I1=n5237 I2=n5236
XU7721 OAI12HS $PINS O=n5242 A1=n5240 B1=FE_OFN1134_FE_DBTN13_n5209 B2=n5241
XU7722 XNR2HS $PINS O=pconv_2_w[13] I1=n5243 I2=n5242
XU7723 INV1S $PINS O=n5246 I=n5244
XU7724 INV1S $PINS O=n5254 I=n5247
XU7725 INV1S $PINS O=n5248 I=n5253
XU7726 AOI12HS $PINS O=n5249 A1=n5248 B1=n5256 B2=n5254
XU7727 XNR2HS $PINS O=pconv_2_w[12] I1=n5252 I2=n5251
XU7728 INV1S $PINS O=n5258 I=n5255
XU7729 INV1S $PINS O=n5257 I=n5256
XU7730 XNR2HS $PINS O=pconv_2_w[11] I1=n5260 I2=n5259
XU7731 INV1S $PINS O=n5263 I=n5261
XU7732 ND2S $PINS O=n5265 I1=n5263 I2=n5262
XU7733 OAI12HS $PINS O=n5264 A1=n5267 B1=FE_DBTN13_n5209 B2=n5266
XU7734 XNR2HS $PINS O=pconv_2_w[10] I1=n5265 I2=n5264
XU7735 INV1S $PINS O=n5268 I=n5266
XU7736 XOR2HS $PINS O=pconv_2_w[9] I1=n5270 I2=FE_DBTN13_n5209
XU7737 INV1S $PINS O=n5273 I=n5271
XU7738 INV1S $PINS O=n5297 I=n5274
XU7739 INV1S $PINS O=n5275 I=n5285
XU7740 NR2 $PINS O=n5278 I1=n5281 I2=n5275
XU7741 INV1S $PINS O=n5276 I=n5284
XU7742 OAI12HS $PINS O=n5277 A1=n5282 B1=n5276 B2=n5281
XU7743 AOI12HS $PINS O=n5279 A1=n5277 B1=n5297 B2=n5278
XU7744 XOR2HS $PINS O=pconv_2_w[8] I1=n5280 I2=n5279
XU7745 INV1S $PINS O=n5283 I=n5281
XU7746 AOI12HS $PINS O=n5286 A1=n5284 B1=n5297 B2=n5285
XU7747 XOR2HS $PINS O=pconv_2_w[7] I1=n5287 I2=n5286
XU7748 INV1S $PINS O=n5290 I=n5288
XU7749 ND2S $PINS O=n5294 I1=n5290 I2=n5289
XU7750 INV1S $PINS O=n5296 I=n5291
XU7751 INV1S $PINS O=n5292 I=n5295
XU7752 AOI12HS $PINS O=n5293 A1=n5292 B1=n5297 B2=n5296
XU7753 XOR2HS $PINS O=pconv_2_w[6] I1=n5294 I2=n5293
XU7754 XNR2HS $PINS O=pconv_2_w[5] I1=n5298 I2=n5297
XU7755 INV1S $PINS O=n5301 I=n5299
XU7756 INV1S $PINS O=n5308 I=n5302
XU7757 OAI12HS $PINS O=n5303 A1=n5306 B1=n5308 B2=n5305
XU7758 XNR2HS $PINS O=pconv_2_w[4] I1=n5304 I2=n5303
XU7759 INV1S $PINS O=n5307 I=n5305
XU7760 XOR2HS $PINS O=pconv_2_w[3] I1=n5309 I2=n5308
XU7761 INV1S $PINS O=n5312 I=n5310
XU7762 XOR2HS $PINS O=pconv_2_w[2] I1=n5314 I2=n5313
XU7763 ND2 $PINS O=n5316 I1=n5109 I2=n5315
XU7764 XNR2HS $PINS O=pconv_2_w[1] I1=n5317 I2=n5316
XU7765 INV1S $PINS O=n5320 I=n5318
XU7766 ND2 $PINS O=n5321 I1=n5320 I2=n5319
XU7767 XNR2HS $PINS O=pconv_2_w[0] I1=pConv_2/product_2_r[0] I2=n5321
XU7768 INV1S $PINS O=n5324 I=n5323
XU7769 AOI12HS $PINS O=n5327 A1=n5324 B1=n5326 B2=n5325
XU7770 OA12 $PINS O=pconv_2_w[24] A1=n5327 B1=FE_OFN1158_n5329 B2=n5328
XU8353 OR2T $PINS O=n5429 I1=layer_num[0] I2=n5384
XU8354 INV1S $PINS O=n5387 I=Buffer/counter_temp[0]
XU8355 NR2 $PINS O=n7295 I1=Buffer/counter_temp[3] I2=n5387
XU8356 ND3S $PINS O=n7296 I1=n7295 I2=Buffer/counter_temp[2]
+ I3=Buffer/counter_temp[1]
XU8357 INV1S $PINS O=n7745 I=Buffer/data_buffer[410]
XU8358 OR2T $PINS O=n5413 I1=layer_num[1] I2=n5388
XU8359 ND2T $PINS O=n5424 I1=FE_RN_3 I2=n5413
XU8360 INV1S $PINS O=n7695 I=Buffer/data_buffer[74]
XU8361 INV1S $PINS O=n7711 I=Buffer/data_buffer[186]
XU8362 OAI222S $PINS O=n1750 A1=n7745 A2=FE_OFN1495_n5424 B1=n7695
+ B2=FE_OFN1221_n5429 C1=FE_OFN1183_n5413 C2=n7711
XU8363 INV1S $PINS O=n8505 I=Buffer/data_buffer[412]
XU8364 INV1S $PINS O=n8452 I=Buffer/data_buffer[76]
XU8365 INV1S $PINS O=n8468 I=Buffer/data_buffer[188]
XU8366 OAI222S $PINS O=n1752 A1=n8505 A2=FE_OCPN9733_FE_OFN1481_n5424 B1=n8452
+ B2=FE_OFN1221_n5429 C1=FE_OFN1183_n5413 C2=n8468
XU8367 INV1S $PINS O=n7942 I=Buffer/data_buffer[411]
XU8368 INV1S $PINS O=n7892 I=Buffer/data_buffer[75]
XU8369 INV1S $PINS O=n7908 I=Buffer/data_buffer[187]
XU8370 OAI222S $PINS O=n1751 A1=n7942 A2=FE_OFN1495_n5424 B1=n7892
+ B2=FE_OFN1221_n5429 C1=FE_OFN1183_n5413 C2=n7908
XU8371 INV1S $PINS O=n8698 I=Buffer/data_buffer[408]
XU8372 INV1S $PINS O=n8647 I=Buffer/data_buffer[72]
XU8373 INV1S $PINS O=n8663 I=Buffer/data_buffer[184]
XU8375 INV1S $PINS O=n8124 I=Buffer/data_buffer[409]
XU8376 INV1S $PINS O=n8073 I=Buffer/data_buffer[73]
XU8377 INV1S $PINS O=n8091 I=Buffer/data_buffer[185]
XU8378 OAI222S $PINS O=n1749 A1=n8124 A2=FE_OFN1495_n5424 B1=n8073
+ B2=FE_OCPN9785_FE_RN_3 C1=FE_OFN1181_n5413 C2=n8091
XU8379 INV1S $PINS O=n7941 I=Buffer/data_buffer[403]
XU8380 INV1S $PINS O=n7891 I=Buffer/data_buffer[67]
XU8381 INV1S $PINS O=n7907 I=Buffer/data_buffer[179]
XU8382 OAI222S $PINS O=n1743 A1=n7941 A2=FE_OFN1491_n5424 B1=n7891
+ B2=FE_OFN1218_n5429 C1=FE_OFN1181_n5413 C2=n7907
XU8383 INV1S $PINS O=n8318 I=Buffer/data_buffer[405]
XU8384 INV1S $PINS O=n8269 I=Buffer/data_buffer[69]
XU8385 INV1S $PINS O=n8285 I=Buffer/data_buffer[181]
XU8386 OAI222S $PINS O=n1745 A1=n8318 A2=FE_OFN1501_n5424 B1=n8269
+ B2=FE_OFN1225_n5429 C1=FE_OFN1191_n5413 C2=n8285
XU8387 INV1S $PINS O=n8503 I=Buffer/data_buffer[404]
XU8388 INV1S $PINS O=n8451 I=Buffer/data_buffer[68]
XU8389 INV1S $PINS O=n8467 I=Buffer/data_buffer[180]
XU8390 OAI222S $PINS O=n1744 A1=n8503 A2=FE_OFN1501_n5424 B1=n8451
+ B2=FE_OFN1225_n5429 C1=FE_OFN1191_n5413 C2=n8467
XU8391 INV1S $PINS O=n8122 I=Buffer/data_buffer[401]
XU8392 INV1S $PINS O=n8072 I=Buffer/data_buffer[65]
XU8393 INV1S $PINS O=n8090 I=Buffer/data_buffer[177]
XU8394 OAI222S $PINS O=n1741 A1=n8122 A2=FE_OFN1491_n5424 B1=n8072
+ B2=FE_OFN1218_n5429 C1=FE_OFN1174_n5413 C2=n8090
XU8395 INV1S $PINS O=n8119 I=Buffer/data_buffer[385]
XU8396 INV1S $PINS O=n8070 I=Buffer/data_buffer[49]
XU8397 INV1S $PINS O=n8088 I=Buffer/data_buffer[161]
XU8398 OAI222S $PINS O=n1726 A1=n8119 A2=FE_OFN1508_n5424 B1=n8070
+ B2=FE_OFN1231_n5429 C1=FE_OFN1199_n5413 C2=n8088
XU8399 INV1S $PINS O=n8501 I=Buffer/data_buffer[388]
XU8400 INV1S $PINS O=n8449 I=Buffer/data_buffer[52]
XU8401 INV1S $PINS O=n8465 I=Buffer/data_buffer[164]
XU8402 OAI222S $PINS O=n1729 A1=n8501 A2=FE_OFN1508_n5424 B1=n8449
+ B2=FE_OFN1231_n5429 C1=FE_OFN1199_n5413 C2=n8465
XU8403 INV1S $PINS O=n8319 I=Buffer/data_buffer[413]
XU8405 INV1S $PINS O=n8270 I=Buffer/data_buffer[77]
XU8406 INV1S $PINS O=n8286 I=Buffer/data_buffer[189]
XU8407 OAI222S $PINS O=n1753 A1=n8319 A2=FE_OCPN9733_FE_OFN1481_n5424 B1=n8270
+ B2=FE_OFN1221_n5429 C1=FE_OFN1183_n5413 C2=n8286
XU8408 INV1S $PINS O=n7368 I=Buffer/data_buffer[414]
XU8409 INV1S $PINS O=n7318 I=Buffer/data_buffer[78]
XU8410 INV1S $PINS O=n7334 I=Buffer/data_buffer[190]
XU8411 OAI222S $PINS O=n1754 A1=n7368 A2=FE_OCPN9733_FE_OFN1481_n5424 B1=n7318
+ B2=FE_OFN1221_n5429 C1=FE_OFN1183_n5413 C2=n7334
XU8412 INV1S $PINS O=n7555 I=Buffer/data_buffer[415]
XU8413 INV1S $PINS O=n7505 I=Buffer/data_buffer[79]
XU8414 INV1S $PINS O=n7521 I=Buffer/data_buffer[191]
XU8415 OAI222S $PINS O=n1755 A1=n7555 A2=FE_OFN1495_n5424 B1=n7505
+ B2=FE_OFN1221_n5429 C1=FE_OFN1183_n5413 C2=n7521
XU8416 INV1S $PINS O=n7554 I=Buffer/data_buffer[407]
XU8417 INV1S $PINS O=n7504 I=Buffer/data_buffer[71]
XU8418 INV1S $PINS O=n7520 I=Buffer/data_buffer[183]
XU8419 OAI222S $PINS O=n1747 A1=n7554 A2=FE_OFN1491_n5424 B1=n7504
+ B2=FE_OFN1218_n5429 C1=FE_OFN1181_n5413 C2=n7520
XU8420 INV1S $PINS O=n7366 I=Buffer/data_buffer[406]
XU8421 INV1S $PINS O=n7316 I=Buffer/data_buffer[70]
XU8422 INV1S $PINS O=n7333 I=Buffer/data_buffer[182]
XU8423 OAI222S $PINS O=n1746 A1=n7366 A2=FE_OFN1501_n5424 B1=n7316
+ B2=FE_OFN1225_n5429 C1=FE_OFN1191_n5413 C2=n7333
XU8424 INV1S $PINS O=n7743 I=Buffer/data_buffer[402]
XU8425 INV1S $PINS O=n7694 I=Buffer/data_buffer[66]
XU8426 INV1S $PINS O=n7710 I=Buffer/data_buffer[178]
XU8427 OAI222S $PINS O=n1742 A1=n7743 A2=FE_OFN1491_n5424 B1=n7694
+ B2=FE_OFN1218_n5429 C1=FE_OFN1181_n5413 C2=n7710
XU8428 INV1S $PINS O=n8315 I=Buffer/data_buffer[389]
XU8429 INV1S $PINS O=n8266 I=Buffer/data_buffer[53]
XU8430 INV1S $PINS O=n8283 I=Buffer/data_buffer[165]
XU8431 OAI222S $PINS O=n1730 A1=n8315 A2=FE_OFN1505_n5424 B1=n8266
+ B2=FE_OFN1228_n5429 C1=FE_OFN1193_n5413 C2=n8283
XU8432 INV1S $PINS O=n7938 I=Buffer/data_buffer[387]
XU8433 INV1S $PINS O=n7888 I=Buffer/data_buffer[51]
XU8434 INV1S $PINS O=n7905 I=Buffer/data_buffer[163]
XU8435 OAI222S $PINS O=n1728 A1=n7938 A2=FE_OFN1508_n5424 B1=n7888
+ B2=FE_OFN1231_n5429 C1=FE_OFN1199_n5413 C2=n7905
XU8436 INV1S $PINS O=n8695 I=Buffer/data_buffer[392]
XU8437 INV1S $PINS O=n8644 I=Buffer/data_buffer[56]
XU8438 INV1S $PINS O=n8661 I=Buffer/data_buffer[168]
XU8439 OAI222S $PINS O=n1733 A1=n8695 A2=FE_OFN1495_n5424 B1=n8644
+ B2=FE_OCPN9785_FE_RN_3 C1=FE_OFN1181_n5413 C2=n8661
XU8440 INV1S $PINS O=n8502 I=Buffer/data_buffer[396]
XU8441 INV1S $PINS O=n8450 I=Buffer/data_buffer[60]
XU8442 INV1S $PINS O=n8466 I=Buffer/data_buffer[172]
XU8443 OAI222S $PINS O=n1737 A1=n8502 A2=FE_OFN1502_n5424 B1=n8450
+ B2=FE_OFN1226_n5429 C1=FE_OFN1190_n5413 C2=n8466
XU8444 INV1S $PINS O=n8316 I=Buffer/data_buffer[397]
XU8445 INV1S $PINS O=n8268 I=Buffer/data_buffer[61]
XU8446 INV1S $PINS O=n8284 I=Buffer/data_buffer[173]
XU8447 OAI222S $PINS O=n1738 A1=n8316 A2=FE_OFN1502_n5424 B1=n8268
+ B2=FE_OFN1226_n5429 C1=FE_OFN1190_n5413 C2=n8284
XU8448 INV1S $PINS O=n7364 I=Buffer/data_buffer[390]
XU8449 INV1S $PINS O=n7314 I=Buffer/data_buffer[54]
XU8450 INV1S $PINS O=n7330 I=Buffer/data_buffer[166]
XU8452 INV1S $PINS O=n7552 I=Buffer/data_buffer[391]
XU8453 INV1S $PINS O=n7502 I=Buffer/data_buffer[55]
XU8454 INV1S $PINS O=n7518 I=Buffer/data_buffer[167]
XU8455 OAI222H $PINS O=n1732 A1=n7552 A2=FE_OFN1508_n5424 B1=n7502
+ B2=FE_OFN1231_n5429 C1=FE_OFN1199_n5413 C2=n7518
XU8456 INV1S $PINS O=n7940 I=Buffer/data_buffer[395]
XU8457 INV1S $PINS O=n7890 I=Buffer/data_buffer[59]
XU8458 INV1S $PINS O=n7906 I=Buffer/data_buffer[171]
XU8459 OAI222S $PINS O=n1736 A1=n7940 A2=FE_OFN1502_n5424 B1=n7890
+ B2=FE_OFN1226_n5429 C1=FE_OFN1190_n5413 C2=n7906
XU8460 INV1S $PINS O=n7365 I=Buffer/data_buffer[398]
XU8461 INV1S $PINS O=n7315 I=Buffer/data_buffer[62]
XU8462 INV1S $PINS O=n7332 I=Buffer/data_buffer[174]
XU8463 OAI222S $PINS O=n1739 A1=n7365 A2=FE_OFN1505_n5424 B1=n7315
+ B2=FE_OFN1228_n5429 C1=FE_OFN1193_n5413 C2=n7332
XU8464 INV1S $PINS O=n7741 I=Buffer/data_buffer[394]
XU8465 INV1S $PINS O=n7692 I=Buffer/data_buffer[58]
XU8466 INV1S $PINS O=n7709 I=Buffer/data_buffer[170]
XU8467 OAI222S $PINS O=n1735 A1=n7741 A2=FE_OFN1505_n5424 B1=n7692
+ B2=FE_OFN1228_n5429 C1=FE_OFN1193_n5413 C2=n7709
XU8468 INV1S $PINS O=n7553 I=Buffer/data_buffer[399]
XU8469 INV1S $PINS O=n7503 I=Buffer/data_buffer[63]
XU8470 INV1S $PINS O=n7519 I=Buffer/data_buffer[175]
XU8471 OAI222S $PINS O=n1740 A1=n7553 A2=FE_OFN1505_n5424 B1=n7503
+ B2=FE_OFN1228_n5429 C1=FE_OFN1193_n5413 C2=n7519
XU8472 INV1S $PINS O=n7740 I=Buffer/data_buffer[386]
XU8473 INV1S $PINS O=n7691 I=Buffer/data_buffer[50]
XU8474 INV1S $PINS O=n7708 I=Buffer/data_buffer[162]
XU8475 OAI222S $PINS O=n1727 A1=n7740 A2=FE_OFN1508_n5424 B1=n7691
+ B2=FE_OFN1231_n5429 C1=FE_OFN1199_n5413 C2=n7708
XU8476 INV1S $PINS O=n7313 I=Buffer/data_buffer[46]
XU8477 OAI222S $PINS O=n1724 A1=n7363 A2=FE_OFN1512_n5424 B1=n7313
+ B2=FE_OFN1238_n5429 C1=n7329 C2=FE_OFN1196_n5413
XU8478 INV1S $PINS O=n8911 I=Buffer/data_buffer[1217]
XU8479 INV1S $PINS O=n8094 I=Buffer/data_buffer[209]
XU8480 INV1S $PINS O=n8144 I=Buffer/data_buffer[545]
XU8481 OAI222S $PINS O=n1816 A1=n8911 A2=FE_OFN1492_n5424 B1=n8094
+ B2=FE_OFN1202_n5429 C1=FE_OFN1165_n5413 C2=n8144
XU8482 INV1S $PINS O=n8913 I=Buffer/data_buffer[1220]
XU8483 INV1S $PINS O=n8473 I=Buffer/data_buffer[212]
XU8484 INV1S $PINS O=n8524 I=Buffer/data_buffer[548]
XU8485 OAI222S $PINS O=n1819 A1=n8913 A2=FE_OFN1498_n5424 B1=n8473
+ B2=FE_OFN1205_n5429 C1=FE_OFN1166_n5413 C2=n8524
XU8486 INV1S $PINS O=n8912 I=Buffer/data_buffer[1219]
XU8487 INV1S $PINS O=n7912 I=Buffer/data_buffer[211]
XU8488 INV1S $PINS O=n7963 I=Buffer/data_buffer[547]
XU8489 OAI222S $PINS O=n1818 A1=n8912 A2=FE_OFN1493_n5424 B1=n7912
+ B2=FE_OFN1205_n5429 C1=FE_OFN1171_n5413 C2=n7963
XU8490 INV1S $PINS O=n8120 I=Buffer/data_buffer[393]
XU8491 INV1S $PINS O=n8071 I=Buffer/data_buffer[57]
XU8492 INV1S $PINS O=n8089 I=Buffer/data_buffer[169]
XU8493 OAI222S $PINS O=n1734 A1=n8120 A2=FE_OFN1505_n5424 B1=n8071
+ B2=FE_OFN1228_n5429 C1=FE_OFN1193_n5413 C2=n8089
XU8494 INV1S $PINS O=n7501 I=Buffer/data_buffer[47]
XU8495 OAI222S $PINS O=n1725 A1=n7550 A2=FE_OFN1512_n5424 B1=n7501
+ B2=FE_OFN1238_n5429 C1=n7517 C2=FE_OFN1196_n5413
XU8496 INV1S $PINS O=n8265 I=Buffer/data_buffer[45]
XU8497 OAI222S $PINS O=n1723 A1=n8314 A2=FE_OCPN9736_FE_OFN1504_n5424 B1=n8265
+ B2=FE_OCPN9781_FE_OFN9714_n C1=n8282 C2=FE_OFN1186_n5413
XU8498 INV1S $PINS O=n9020 I=Buffer/data_buffer[1229]
XU8499 INV1S $PINS O=n8291 I=Buffer/data_buffer[221]
XU8500 INV1S $PINS O=n8341 I=Buffer/data_buffer[557]
XU8501 OAI222S $PINS O=n1828 A1=n9020 A2=FE_OFN1497_n5424 B1=n8291
+ B2=FE_OFN1202_n5429 C1=FE_RN_1 C2=n8341
XU8502 INV1S $PINS O=n8905 I=Buffer/data_buffer[1213]
XU8503 INV1S $PINS O=n8288 I=Buffer/data_buffer[205]
XU8504 INV1S $PINS O=n8338 I=Buffer/data_buffer[541]
XU8505 OAI222S $PINS O=n1813 A1=n8905 A2=FE_OFN1484_n5424 B1=n8288
+ B2=FE_OCPN1987_n5429 C1=FE_OFN1159_n5413 C2=n8338
XU8506 INV1S $PINS O=n9007 I=Buffer/data_buffer[1226]
XU8507 INV1S $PINS O=n7716 I=Buffer/data_buffer[218]
XU8508 INV1S $PINS O=n7766 I=Buffer/data_buffer[554]
XU8509 OAI222S $PINS O=n1825 A1=n9007 A2=FE_OFN1498_n5424 B1=n7716
+ B2=FE_OFN1210_n5429 C1=FE_OFN1172_n5413 C2=n7766
XU8510 INV1S $PINS O=n9013 I=Buffer/data_buffer[1225]
XU8511 INV1S $PINS O=n8095 I=Buffer/data_buffer[217]
XU8512 INV1S $PINS O=n8145 I=Buffer/data_buffer[553]
XU8513 OAI222S $PINS O=n1824 A1=n9013 A2=FE_OFN1492_n5424 B1=n8095
+ B2=FE_OFN1202_n5429 C1=FE_OFN1165_n5413 C2=n8145
XU8514 INV1S $PINS O=n9024 I=Buffer/data_buffer[1224]
XU8515 INV1S $PINS O=n8668 I=Buffer/data_buffer[216]
XU8516 INV1S $PINS O=n8719 I=Buffer/data_buffer[552]
XU8517 OAI222S $PINS O=n1823 A1=n9024 A2=FE_OFN1484_n5424 B1=n8668
+ B2=FE_OCPN1987_n5429 C1=FE_OFN1160_n5413 C2=n8719
XU8518 INV1S $PINS O=n8893 I=Buffer/data_buffer[1215]
XU8519 INV1S $PINS O=n7524 I=Buffer/data_buffer[207]
XU8520 INV1S $PINS O=n7574 I=Buffer/data_buffer[543]
XU8521 OAI222S $PINS O=n1815 A1=n8893 A2=FE_OFN1485_n5424 B1=n7524
+ B2=FE_OFN1208_n5429 C1=FE_OCPN9743_n5413 C2=n7574
XU8522 INV1S $PINS O=n8917 I=Buffer/data_buffer[1223]
XU8523 INV1S $PINS O=n7525 I=Buffer/data_buffer[215]
XU8524 INV1S $PINS O=n7575 I=Buffer/data_buffer[551]
XU8525 OAI222S $PINS O=n1822 A1=n8917 A2=FE_OFN1498_n5424 B1=n7525
+ B2=FE_OFN1212_n5429 C1=FE_OFN1172_n5413 C2=n7575
XU8526 INV1S $PINS O=n8915 I=Buffer/data_buffer[1221]
XU8527 INV1S $PINS O=n8290 I=Buffer/data_buffer[213]
XU8528 INV1S $PINS O=n8340 I=Buffer/data_buffer[549]
XU8529 OAI222S $PINS O=n1820 A1=n8915 A2=FE_OFN1492_n5424 B1=n8290
+ B2=FE_OFN1202_n5429 C1=FE_OFN1165_n5413 C2=n8340
XU8530 INV1S $PINS O=n9002 I=Buffer/data_buffer[1231]
XU8531 INV1S $PINS O=n7526 I=Buffer/data_buffer[223]
XU8532 INV1S $PINS O=n7576 I=Buffer/data_buffer[559]
XU8533 OAI222S $PINS O=n1830 A1=n9002 A2=FE_OFN1498_n5424 B1=n7526
+ B2=FE_OFN1210_n5429 C1=FE_OFN1166_n5413 C2=n7576
XU8534 INV1S $PINS O=n9012 I=Buffer/data_buffer[1227]
XU8535 INV1S $PINS O=n7913 I=Buffer/data_buffer[219]
XU8536 INV1S $PINS O=n7964 I=Buffer/data_buffer[555]
XU8537 OAI222S $PINS O=n1826 A1=n9012 A2=FE_OFN1498_n5424 B1=n7913
+ B2=FE_OFN1205_n5429 C1=FE_OFN1166_n5413 C2=n7964
XU8538 INV1S $PINS O=n8999 I=Buffer/data_buffer[1230]
XU8539 INV1S $PINS O=n7339 I=Buffer/data_buffer[222]
XU8540 INV1S $PINS O=n7389 I=Buffer/data_buffer[558]
XU8541 OAI222S $PINS O=n1829 A1=n8999 A2=FE_OFN1497_n5424 B1=n7339
+ B2=FE_OFN1205_n5429 C1=FE_OFN1166_n5413 C2=n7389
XU8542 INV1S $PINS O=n9021 I=Buffer/data_buffer[1228]
XU8543 INV1S $PINS O=n8474 I=Buffer/data_buffer[220]
XU8544 INV1S $PINS O=n8526 I=Buffer/data_buffer[556]
XU8545 OAI222S $PINS O=n1827 A1=n9021 A2=FE_OFN1498_n5424 B1=n8474
+ B2=FE_OFN1210_n5429 C1=FE_OFN1166_n5413 C2=n8526
XU8546 INV1S $PINS O=n9029 I=Buffer/data_buffer[1233]
XU8547 INV1S $PINS O=n8096 I=Buffer/data_buffer[225]
XU8548 INV1S $PINS O=n8146 I=Buffer/data_buffer[561]
XU8549 OAI222S $PINS O=n1831 A1=n9029 A2=FE_OFN1497_n5424 B1=n8096
+ B2=FE_OCPN1987_n5429 C1=FE_RN_1 C2=n8146
XU8550 INV1S $PINS O=n9033 I=Buffer/data_buffer[1236]
XU8551 INV1S $PINS O=n8475 I=Buffer/data_buffer[228]
XU8552 INV1S $PINS O=n8527 I=Buffer/data_buffer[564]
XU8553 OAI222S $PINS O=n1834 A1=n9033 A2=FE_OFN1503_n5424 B1=n8475
+ B2=FE_OFN1207_n5429 C1=FE_OFN1161_n5413 C2=n8527
XU8554 INV1S $PINS O=n9031 I=Buffer/data_buffer[1235]
XU8555 INV1S $PINS O=n7914 I=Buffer/data_buffer[227]
XU8556 INV1S $PINS O=n7965 I=Buffer/data_buffer[563]
XU8557 OAI222S $PINS O=n1833 A1=n9031 A2=FE_OFN1497_n5424 B1=n7914
+ B2=FE_OFN1207_n5429 C1=FE_OFN1161_n5413 C2=n7965
XU8558 INV1S $PINS O=n8817 I=Buffer/data_buffer[1201]
XU8559 INV1S $PINS O=n8092 I=Buffer/data_buffer[193]
XU8560 INV1S $PINS O=n8141 I=Buffer/data_buffer[529]
XU8561 OAI222S $PINS O=n1801 A1=n8817 A2=FE_OFN1485_n5424 B1=n8092
+ B2=FE_OCPN9747_n5429 C1=FE_OFN2027_FE_OCPN9743_n5413 C2=n8141
XU8562 INV1S $PINS O=n9041 I=Buffer/data_buffer[1239]
XU8563 INV1S $PINS O=n7527 I=Buffer/data_buffer[231]
XU8564 INV1S $PINS O=n7577 I=Buffer/data_buffer[567]
XU8565 OAI222S $PINS O=n1837 A1=n9041 A2=FE_OFN1503_n5424 B1=n7527
+ B2=FE_OFN1207_n5429 C1=FE_OFN1161_n5413 C2=n7577
XU8566 INV1S $PINS O=n9035 I=Buffer/data_buffer[1234]
XU8567 INV1S $PINS O=n7717 I=Buffer/data_buffer[226]
XU8568 INV1S $PINS O=n7767 I=Buffer/data_buffer[562]
XU8569 OAI222S $PINS O=n1832 A1=n9035 A2=FE_OFN1503_n5424 B1=n7717
+ B2=FE_OFN1207_n5429 C1=FE_OFN1161_n5413 C2=n7767
XU8570 INV1S $PINS O=n9026 I=Buffer/data_buffer[1240]
XU8571 INV1S $PINS O=n8670 I=Buffer/data_buffer[232]
XU8572 INV1S $PINS O=n8721 I=Buffer/data_buffer[568]
XU8573 OAI222S $PINS O=n1838 A1=n9026 A2=FE_OFN1484_n5424 B1=n8670
+ B2=FE_OCPN1987_n5429 C1=FE_OFN1160_n5413 C2=n8721
XU8574 INV1S $PINS O=n9028 I=Buffer/data_buffer[1241]
XU8575 INV1S $PINS O=n8097 I=Buffer/data_buffer[233]
XU8576 INV1S $PINS O=n8147 I=Buffer/data_buffer[569]
XU8577 OAI222S $PINS O=n1839 A1=n9028 A2=FE_OFN1497_n5424 B1=n8097
+ B2=FE_OCPN1987_n5429 C1=FE_RN_1 C2=n8147
XU8578 INV1S $PINS O=n7424 I=Buffer/data_buffer[790]
XU8579 INV1S $PINS O=n7323 I=Buffer/data_buffer[118]
XU8580 INV1S $PINS O=n7356 I=Buffer/data_buffer[342]
XU8581 OAI222S $PINS O=n1761 A1=n7424 A2=FE_OFN1489_n5424 B1=n7323
+ B2=FE_OFN1219_n5429 C1=FE_OFN1177_n5413 C2=n7356
XU8582 INV1S $PINS O=n7801 I=Buffer/data_buffer[786]
XU8583 INV1S $PINS O=n7701 I=Buffer/data_buffer[114]
XU8584 INV1S $PINS O=n7733 I=Buffer/data_buffer[338]
XU8585 OAI222S $PINS O=n1757 A1=n7801 A2=FE_OFN1489_n5424 B1=n7701
+ B2=FE_OFN1219_n5429 C1=FE_OFN1177_n5413 C2=n7733
XU8586 INV1S $PINS O=n7611 I=Buffer/data_buffer[791]
XU8587 INV1S $PINS O=n7511 I=Buffer/data_buffer[119]
XU8588 INV1S $PINS O=n7545 I=Buffer/data_buffer[343]
XU8589 OAI222S $PINS O=n1762 A1=n7611 A2=FE_OFN1489_n5424 B1=n7511
+ B2=FE_OFN1219_n5429 C1=FE_OFN1177_n5413 C2=n7545
XU8590 INV1S $PINS O=n9040 I=Buffer/data_buffer[1247]
XU8591 INV1S $PINS O=n7528 I=Buffer/data_buffer[239]
XU8592 INV1S $PINS O=n7578 I=Buffer/data_buffer[575]
XU8593 OAI222S $PINS O=n1845 A1=n9040 A2=FE_OFN1506_n5424 B1=n7528
+ B2=FE_OFN1206_n5429 C1=FE_OFN1162_n5413 C2=n7578
XU8594 INV1S $PINS O=n9030 I=Buffer/data_buffer[1243]
XU8595 INV1S $PINS O=n7915 I=Buffer/data_buffer[235]
XU8596 INV1S $PINS O=n7966 I=Buffer/data_buffer[571]
XU8597 OAI222S $PINS O=n1841 A1=n9030 A2=FE_OFN1506_n5424 B1=n7915
+ B2=FE_OFN1200_n5429 C1=FE_OFN1162_n5413 C2=n7966
XU8598 INV1S $PINS O=n9038 I=Buffer/data_buffer[1237]
XU8599 INV1S $PINS O=n8293 I=Buffer/data_buffer[229]
XU8600 INV1S $PINS O=n8342 I=Buffer/data_buffer[565]
XU8601 OAI222S $PINS O=n1835 A1=n9038 A2=FE_OFN1506_n5424 B1=n8293
+ B2=FE_OFN1200_n5429 C1=FE_OFN1162_n5413 C2=n8342
XU8602 INV1S $PINS O=n9043 I=Buffer/data_buffer[1246]
XU8603 INV1S $PINS O=n7341 I=Buffer/data_buffer[238]
XU8604 INV1S $PINS O=n7391 I=Buffer/data_buffer[574]
XU8605 OAI222S $PINS O=n1844 A1=n9043 A2=FE_OFN1506_n5424 B1=n7341
+ B2=FE_OFN1206_n5429 C1=FE_OFN1162_n5413 C2=n7391
XU8606 INV1S $PINS O=n9044 I=Buffer/data_buffer[1238]
XU8607 INV1S $PINS O=n7340 I=Buffer/data_buffer[230]
XU8608 INV1S $PINS O=n7390 I=Buffer/data_buffer[566]
XU8609 OAI222S $PINS O=n1836 A1=n9044 A2=FE_OFN1503_n5424 B1=n7340
+ B2=FE_OFN1200_n5429 C1=FE_OFN1161_n5413 C2=n7390
XU8610 INV1S $PINS O=n9032 I=Buffer/data_buffer[1244]
XU8611 INV1S $PINS O=n8476 I=Buffer/data_buffer[236]
XU8612 INV1S $PINS O=n8528 I=Buffer/data_buffer[572]
XU8613 OAI222S $PINS O=n1842 A1=n9032 A2=FE_OFN1506_n5424 B1=n8476
+ B2=FE_OFN1206_n5429 C1=FE_OFN1162_n5413 C2=n8528
XU8614 INV1S $PINS O=n9034 I=Buffer/data_buffer[1242]
XU8615 INV1S $PINS O=n7718 I=Buffer/data_buffer[234]
XU8616 INV1S $PINS O=n7768 I=Buffer/data_buffer[570]
XU8617 OAI222S $PINS O=n1840 A1=n9034 A2=FE_OFN1503_n5424 B1=n7718
+ B2=FE_OFN1207_n5429 C1=FE_OFN1161_n5413 C2=n7768
XU8618 INV1S $PINS O=n9037 I=Buffer/data_buffer[1245]
XU8619 INV1S $PINS O=n8294 I=Buffer/data_buffer[237]
XU8620 INV1S $PINS O=n8343 I=Buffer/data_buffer[573]
XU8621 OAI222S $PINS O=n1843 A1=n9037 A2=FE_OFN1506_n5424 B1=n8294
+ B2=FE_OFN1206_n5429 C1=FE_OFN1162_n5413 C2=n8343
XU8622 INV1S $PINS O=n8906 I=Buffer/data_buffer[1212]
XU8623 INV1S $PINS O=n8472 I=Buffer/data_buffer[204]
XU8624 INV1S $PINS O=n8523 I=Buffer/data_buffer[540]
XU8625 OAI222S $PINS O=n1812 A1=n8906 A2=FE_OFN1485_n5424 B1=n8472
+ B2=FE_OFN1208_n5429 C1=FE_OCPN9743_n5413 C2=n8523
XU8626 INV1S $PINS O=n8908 I=Buffer/data_buffer[1208]
XU8627 INV1S $PINS O=n8665 I=Buffer/data_buffer[200]
XU8628 INV1S $PINS O=n8717 I=Buffer/data_buffer[536]
XU8629 OAI222S $PINS O=n1808 A1=n8908 A2=FE_OFN1484_n5424 B1=n8665
+ B2=FE_OCPN1987_n5429 C1=FE_OFN1160_n5413 C2=n8717
XU8630 INV1S $PINS O=n7998 I=Buffer/data_buffer[787]
XU8632 INV1S $PINS O=n7898 I=Buffer/data_buffer[115]
XU8633 INV1S $PINS O=n7931 I=Buffer/data_buffer[339]
XU8634 OAI222S $PINS O=n1758 A1=n7998 A2=FE_OFN1486_n5424 B1=n7898
+ B2=FE_OFN1219_n5429 C1=FE_OFN1173_n5413 C2=n7931
XU8635 INV1S $PINS O=n8000 I=Buffer/data_buffer[803]
XU8636 INV1S $PINS O=n7900 I=Buffer/data_buffer[131]
XU8637 INV1S $PINS O=n7934 I=Buffer/data_buffer[355]
XU8638 OAI222S $PINS O=n1773 A1=n8000 A2=FE_OCPN1991_FE_OFN1499_n5424 B1=n7900
+ B2=FE_OFN9715_n C1=FE_OFN1185_n5413 C2=n7934
XU8639 INV1S $PINS O=n8563 I=Buffer/data_buffer[804]
XU8641 INV1S $PINS O=n8460 I=Buffer/data_buffer[132]
XU8642 INV1S $PINS O=n8496 I=Buffer/data_buffer[356]
XU8643 OAI222S $PINS O=n1774 A1=n8563 A2=FE_OFN1494_n5424 B1=n8460
+ B2=FE_OFN9715_n C1=FE_OFN1180_n5413 C2=n8496
XU8644 INV1S $PINS O=n8559 I=Buffer/data_buffer[788]
XU8645 INV1S $PINS O=n8458 I=Buffer/data_buffer[116]
XU8646 INV1S $PINS O=n8494 I=Buffer/data_buffer[340]
XU8647 OAI222S $PINS O=n1759 A1=n8559 A2=FE_OFN1486_n5424 B1=n8458
+ B2=FE_OFN1227_n5429 C1=FE_OFN1173_n5413 C2=n8494
XU8648 INV1S $PINS O=n8182 I=Buffer/data_buffer[801]
XU8649 INV1S $PINS O=n8082 I=Buffer/data_buffer[129]
XU8650 INV1S $PINS O=n8115 I=Buffer/data_buffer[353]
XU8651 OAI222S $PINS O=n1771 A1=n8182 A2=FE_OFN1494_n5424 B1=n8082
+ B2=FE_OFN1232_n5429 C1=FE_OFN1185_n5413 C2=n8115
XU8652 INV1S $PINS O=n8180 I=Buffer/data_buffer[785]
XU8653 INV1S $PINS O=n8080 I=Buffer/data_buffer[113]
XU8654 INV1S $PINS O=n8112 I=Buffer/data_buffer[337]
XU8655 OAI222S $PINS O=n1756 A1=n8180 A2=FE_OFN1489_n5424 B1=n8080
+ B2=FE_OFN1219_n5429 C1=FE_OFN1177_n5413 C2=n8112
XU8656 INV1S $PINS O=n8446 I=Buffer/data_buffer[36]
XU8657 OAI222S $PINS O=n1714 A1=n8499 A2=FE_OFN1507_n5424 B1=n8446
+ B2=FE_OFN1234_n5429 C1=n8463 C2=FE_OFN1189_n5413
XU8658 INV1S $PINS O=n8067 I=Buffer/data_buffer[33]
XU8659 OAI222H $PINS O=n1711 A1=n8117 A2=FE_OFN1512_n5424 B1=n8067
+ B2=FE_OFN1238_n5429 C1=n8085 C2=FE_OFN1196_n5413
XU8660 INV1S $PINS O=n7886 I=Buffer/data_buffer[35]
XU8661 OAI222S $PINS O=n1713 A1=n7936 A2=FE_OFN1510_n5424 B1=n7886
+ B2=FE_OFN1236_n5429 C1=n7902 C2=FE_OFN1195_n5413
XU8662 INV1S $PINS O=n8565 I=Buffer/data_buffer[820]
XU8663 OAI222S $PINS O=n1789 A1=n8565 A2=FE_OCPN9736_FE_OFN1504_n5424 B1=n8463
+ B2=FE_OFN1229_n5429 C1=FE_OFN1186_n5413 C2=n8499
XU8664 INV1S $PINS O=n8003 I=Buffer/data_buffer[819]
XU8665 OAI222S $PINS O=n1788 A1=n8003 A2=FE_OFN1513_n5424 B1=n7902
+ B2=FE_OFN1239_n5429 C1=FE_OFN1194_n5413 C2=n7936
XU8666 INV1S $PINS O=n8184 I=Buffer/data_buffer[817]
XU8667 OAI222S $PINS O=n1786 A1=n8184 A2=FE_OFN1513_n5424 B1=n8085
+ B2=FE_OFN1239_n5429 C1=FE_OFN1194_n5413 C2=n8117
XU8668 INV1S $PINS O=n8378 I=Buffer/data_buffer[813]
XU8669 INV1S $PINS O=n8279 I=Buffer/data_buffer[141]
XU8670 INV1S $PINS O=n8312 I=Buffer/data_buffer[365]
XU8671 OAI222S $PINS O=n1783 A1=n8378 A2=FE_OFN1499_n5424 B1=n8279
+ B2=FE_OFN9715_n C1=FE_OFN1185_n5413 C2=n8312
XU8672 INV1S $PINS O=n8564 I=Buffer/data_buffer[812]
XU8673 INV1S $PINS O=n8461 I=Buffer/data_buffer[140]
XU8674 INV1S $PINS O=n8498 I=Buffer/data_buffer[364]
XU8675 OAI222S $PINS O=n1782 A1=n8564 A2=FE_OFN1499_n5424 B1=n8461
+ B2=FE_OFN9715_n C1=FE_OFN1180_n5413 C2=n8498
XU8676 INV1S $PINS O=n8183 I=Buffer/data_buffer[809]
XU8677 INV1S $PINS O=n8083 I=Buffer/data_buffer[137]
XU8678 INV1S $PINS O=n8116 I=Buffer/data_buffer[361]
XU8679 OAI222S $PINS O=n1779 A1=n8183 A2=FE_OFN1494_n5424 B1=n8083
+ B2=FE_OFN1233_n5429 C1=FE_OFN1185_n5413 C2=n8116
XU8680 INV1S $PINS O=n8755 I=Buffer/data_buffer[792]
XU8681 INV1S $PINS O=n8654 I=Buffer/data_buffer[120]
XU8682 INV1S $PINS O=n8688 I=Buffer/data_buffer[344]
XU8684 INV1S $PINS O=n7613 I=Buffer/data_buffer[807]
XU8685 INV1S $PINS O=n7513 I=Buffer/data_buffer[135]
XU8686 INV1S $PINS O=n7547 I=Buffer/data_buffer[359]
XU8687 OAI222S $PINS O=n1777 A1=n7613 A2=FE_OFN1500_n5424 B1=n7513
+ B2=FE_OFN1232_n5429 C1=FE_OFN1188_n5413 C2=n7547
XU8688 INV1S $PINS O=n7426 I=Buffer/data_buffer[806]
XU8689 INV1S $PINS O=n7326 I=Buffer/data_buffer[134]
XU8690 INV1S $PINS O=n7358 I=Buffer/data_buffer[358]
XU8691 OAI222S $PINS O=n1776 A1=n7426 A2=FE_OFN1500_n5424 B1=n7326
+ B2=FE_OFN1232_n5429 C1=FE_OFN1188_n5413 C2=n7358
XU8692 INV1S $PINS O=n7427 I=Buffer/data_buffer[814]
XU8693 INV1S $PINS O=n7327 I=Buffer/data_buffer[142]
XU8694 INV1S $PINS O=n7360 I=Buffer/data_buffer[366]
XU8695 OAI222H $PINS O=n1784 A1=n7427 A2=FE_OFN1500_n5424 B1=n7327
+ B2=FE_OFN1233_n5429 C1=FE_OFN1188_n5413 C2=n7360
XU8696 INV1S $PINS O=n7615 I=Buffer/data_buffer[815]
XU8697 INV1S $PINS O=n7514 I=Buffer/data_buffer[143]
XU8698 INV1S $PINS O=n7548 I=Buffer/data_buffer[367]
XU8699 OAI222S $PINS O=n1785 A1=n7615 A2=FE_OFN1500_n5424 B1=n7514
+ B2=FE_OFN1233_n5429 C1=FE_OFN1188_n5413 C2=n7548
XU8700 INV1S $PINS O=n7803 I=Buffer/data_buffer[802]
XU8701 INV1S $PINS O=n7703 I=Buffer/data_buffer[130]
XU8702 INV1S $PINS O=n7736 I=Buffer/data_buffer[354]
XU8703 OAI222S $PINS O=n1772 A1=n7803 A2=FE_OFN1500_n5424 B1=n7703
+ B2=FE_OFN1232_n5429 C1=FE_OFN1188_n5413 C2=n7736
XU8704 INV1S $PINS O=n7612 I=Buffer/data_buffer[799]
XU8705 INV1S $PINS O=n7512 I=Buffer/data_buffer[127]
XU8706 INV1S $PINS O=n7546 I=Buffer/data_buffer[351]
XU8707 OAI222S $PINS O=n1770 A1=n7612 A2=FE_OFN1489_n5424 B1=n7512
+ B2=FE_OFN1224_n5429 C1=FE_OFN1177_n5413 C2=n7546
XU8708 INV1S $PINS O=n7425 I=Buffer/data_buffer[798]
XU8709 INV1S $PINS O=n7325 I=Buffer/data_buffer[126]
XU8710 INV1S $PINS O=n7357 I=Buffer/data_buffer[350]
XU8711 OAI222S $PINS O=n1769 A1=n7425 A2=FE_OFN1490_n5424 B1=n7325
+ B2=FE_OFN1224_n5429 C1=FE_OFN1176_n5413 C2=n7357
XU8712 INV1S $PINS O=n7804 I=Buffer/data_buffer[810]
XU8713 INV1S $PINS O=n7704 I=Buffer/data_buffer[138]
XU8714 INV1S $PINS O=n7737 I=Buffer/data_buffer[362]
XU8715 OAI222S $PINS O=n1780 A1=n7804 A2=FE_OFN1500_n5424 B1=n7704
+ B2=FE_OFN1233_n5429 C1=FE_OFN1188_n5413 C2=n7737
XU8716 INV1S $PINS O=n8376 I=Buffer/data_buffer[797]
XU8717 INV1S $PINS O=n8277 I=Buffer/data_buffer[125]
XU8718 INV1S $PINS O=n8309 I=Buffer/data_buffer[349]
XU8719 OAI222S $PINS O=n1768 A1=n8376 A2=FE_OFN1490_n5424 B1=n8277
+ B2=FE_OFN1227_n5429 C1=FE_OFN1176_n5413 C2=n8309
XU8720 INV1S $PINS O=n8001 I=Buffer/data_buffer[811]
XU8721 INV1S $PINS O=n7901 I=Buffer/data_buffer[139]
XU8722 INV1S $PINS O=n7935 I=Buffer/data_buffer[363]
XU8723 OAI222S $PINS O=n1781 A1=n8001 A2=FE_OCPN1991_FE_OFN1499_n5424 B1=n7901
+ B2=FE_OFN9715_n C1=FE_OFN1185_n5413 C2=n7935
XU8724 INV1S $PINS O=n8375 I=Buffer/data_buffer[789]
XU8725 INV1S $PINS O=n8276 I=Buffer/data_buffer[117]
XU8726 INV1S $PINS O=n8308 I=Buffer/data_buffer[341]
XU8727 OAI222S $PINS O=n1760 A1=n8375 A2=FE_OFN1486_n5424 B1=n8276
+ B2=FE_OCPN9781_FE_OFN9714_n C1=FE_OFN1173_n5413 C2=n8308
XU8728 INV1S $PINS O=n7999 I=Buffer/data_buffer[795]
XU8729 INV1S $PINS O=n7899 I=Buffer/data_buffer[123]
XU8730 INV1S $PINS O=n7933 I=Buffer/data_buffer[347]
XU8731 OAI222S $PINS O=n1766 A1=n7999 A2=FE_OFN1490_n5424 B1=n7899
+ B2=FE_OFN1224_n5429 C1=FE_OFN1176_n5413 C2=n7933
XU8732 INV1S $PINS O=n8757 I=Buffer/data_buffer[808]
XU8733 INV1S $PINS O=n8656 I=Buffer/data_buffer[136]
XU8734 INV1S $PINS O=n8690 I=Buffer/data_buffer[360]
XU8735 OAI222S $PINS O=n1778 A1=n8757 A2=FE_OFN1487_n5424 B1=n8656
+ B2=FE_OCPN9783_FE_OFN1215_n5429 C1=FE_OFN1174_n5413 C2=n8690
XU8736 INV1S $PINS O=n7802 I=Buffer/data_buffer[794]
XU8737 INV1S $PINS O=n7702 I=Buffer/data_buffer[122]
XU8738 INV1S $PINS O=n7734 I=Buffer/data_buffer[346]
XU8739 OAI222S $PINS O=n1765 A1=n7802 A2=FE_OFN1489_n5424 B1=n7702
+ B2=FE_OFN1224_n5429 C1=FE_OFN1177_n5413 C2=n7734
XU8740 INV1S $PINS O=n8181 I=Buffer/data_buffer[793]
XU8741 INV1S $PINS O=n8081 I=Buffer/data_buffer[121]
XU8742 INV1S $PINS O=n8113 I=Buffer/data_buffer[345]
XU8743 OAI222S $PINS O=n1764 A1=n8181 A2=FE_OFN1490_n5424 B1=n8081
+ B2=FE_OFN1224_n5429 C1=FE_OFN1176_n5413 C2=n8113
XU8744 INV1S $PINS O=n8377 I=Buffer/data_buffer[805]
XU8745 INV1S $PINS O=n8278 I=Buffer/data_buffer[133]
XU8746 INV1S $PINS O=n8311 I=Buffer/data_buffer[357]
XU8747 OAI222S $PINS O=n1775 A1=n8377 A2=FE_OFN1494_n5424 B1=n8278
+ B2=FE_OFN9715_n C1=FE_OFN1180_n5413 C2=n8311
XU8748 INV1S $PINS O=n8561 I=Buffer/data_buffer[796]
XU8749 INV1S $PINS O=n8459 I=Buffer/data_buffer[124]
XU8750 INV1S $PINS O=n8495 I=Buffer/data_buffer[348]
XU8751 OAI222S $PINS O=n1767 A1=n8561 A2=FE_OFN1490_n5424 B1=n8459
+ B2=FE_OFN1227_n5429 C1=FE_OFN1176_n5413 C2=n8495
XU8752 INV1S $PINS O=n7500 I=Buffer/data_buffer[39]
XU8753 OAI222S $PINS O=n1717 A1=n7549 A2=FE_OFN1512_n5424 B1=n7500
+ B2=FE_OFN1238_n5429 C1=n7516 C2=FE_OFN1196_n5413
XU8754 INV1S $PINS O=n8642 I=Buffer/data_buffer[40]
XU8755 OAI222S $PINS O=n1718 A1=n8692 A2=FE_OFN1487_n5424 B1=n8642
+ B2=FE_OCPN9783_FE_OFN1215_n5429 C1=n8658 C2=FE_OFN1174_n5413
XU8756 INV1S $PINS O=n8264 I=Buffer/data_buffer[37]
XU8757 OAI222S $PINS O=n1715 A1=n8313 A2=FE_OFN1507_n5424 B1=n8264
+ B2=FE_OFN1234_n5429 C1=n8280 C2=FE_OFN1189_n5413
XU8758 INV1S $PINS O=n7688 I=Buffer/data_buffer[34]
XU8760 INV1S $PINS O=n7312 I=Buffer/data_buffer[38]
XU8761 OAI222S $PINS O=n1716 A1=n7362 A2=FE_OFN1512_n5424 B1=n7312
+ B2=FE_OFN1238_n5429 C1=n7328 C2=FE_OFN1196_n5413
XU8762 INV1S $PINS O=n7887 I=Buffer/data_buffer[43]
XU8763 OAI222S $PINS O=n1721 A1=n7937 A2=FE_OFN1507_n5424 B1=n7887
+ B2=FE_OFN1234_n5429 C1=n7904 C2=FE_OFN1189_n5413
XU8764 INV1S $PINS O=n8068 I=Buffer/data_buffer[41]
XU8766 INV1S $PINS O=n7690 I=Buffer/data_buffer[42]
XU8767 OAI222S $PINS O=n1720 A1=n7739 A2=FE_OFN1510_n5424 B1=n7690
+ B2=FE_OFN1236_n5429 C1=n7706 C2=FE_OFN1195_n5413
XU8768 INV1S $PINS O=n8447 I=Buffer/data_buffer[44]
XU8769 OAI222S $PINS O=n1722 A1=n8500 A2=FE_OCPN9736_FE_OFN1504_n5424 B1=n8447
+ B2=FE_OCPN9781_FE_OFN9714_n C1=n8464 C2=FE_OFN1186_n5413
XU8770 INV1S $PINS O=n7805 I=Buffer/data_buffer[818]
XU8772 INV1S $PINS O=n7807 I=Buffer/data_buffer[826]
XU8773 OAI222S $PINS O=n1795 A1=n7807 A2=FE_OFN1511_n5424 B1=n7706
+ B2=FE_OFN1237_n5429 C1=FE_OFN1195_n5413 C2=n7739
XU8774 INV1S $PINS O=n7616 I=Buffer/data_buffer[823]
XU8775 OAI222S $PINS O=n1792 A1=n7616 A2=FE_OFN1513_n5424 B1=n7516
+ B2=FE_OFN1239_n5429 C1=FE_OFN1198_n5413 C2=n7549
XU8776 INV1S $PINS O=n8760 I=Buffer/data_buffer[824]
XU8777 OAI222S $PINS O=n1793 A1=n8760 A2=FE_OFN1487_n5424 B1=n8658
+ B2=FE_OCPN9783_FE_OFN1215_n5429 C1=FE_OFN1174_n5413 C2=n8692
XU8778 INV1S $PINS O=n8382 I=Buffer/data_buffer[829]
XU8779 OAI222S $PINS O=n1798 A1=n8382 A2=FE_OCPN9736_FE_OFN1504_n5424 B1=n8282
+ B2=FE_OCPN9781_FE_OFN9714_n C1=FE_OFN1186_n5413 C2=n8314
XU8780 INV1S $PINS O=n7429 I=Buffer/data_buffer[830]
XU8782 INV1S $PINS O=n8186 I=Buffer/data_buffer[825]
XU8783 OAI222S $PINS O=n1794 A1=n8186 A2=FE_OFN1507_n5424 B1=n8087
+ B2=FE_OFN1234_n5429 C1=FE_OFN1189_n5413 C2=n8118
XU8784 INV1S $PINS O=n8005 I=Buffer/data_buffer[827]
XU8785 OAI222S $PINS O=n1796 A1=n8005 A2=FE_OFN1507_n5424 B1=n7904
+ B2=FE_OFN1234_n5429 C1=FE_OFN1189_n5413 C2=n7937
XU8786 INV1S $PINS O=n8380 I=Buffer/data_buffer[821]
XU8787 OAI222S $PINS O=n1790 A1=n8380 A2=FE_OFN1499_n5424 B1=n8280
+ B2=FE_OFN1229_n5429 C1=FE_OFN1180_n5413 C2=n8313
XU8788 INV1S $PINS O=n7428 I=Buffer/data_buffer[822]
XU8789 OAI222S $PINS O=n1791 A1=n7428 A2=FE_OFN1513_n5424 B1=n7328
+ B2=FE_OFN1239_n5429 C1=FE_OFN1198_n5413 C2=n7362
XU8790 INV1S $PINS O=n7617 I=Buffer/data_buffer[831]
XU8792 INV1S $PINS O=n8566 I=Buffer/data_buffer[828]
XU8793 OAI222S $PINS O=n1797 A1=n8566 A2=FE_OCPN9736_FE_OFN1504_n5424 B1=n8464
+ B2=FE_OCPN9781_FE_OFN9714_n C1=FE_OFN1186_n5413 C2=n8500
XU8795 XOR2HS $PINS O=n6213 I1=FE_OFN1308_weight_1_r_21 I2=data_1_r[34]
XU8796 ND2S $PINS O=n5467 I1=FE_OFN1548_n9433 I2=weight_1_r[21]
XU8797 XOR2HS $PINS O=n5469 I1=FE_OFN1311_weight_1_r_19 I2=data_1_r[36]
XU8798 XNR2HS $PINS O=n5478 I1=weight_1_r[19] I2=FE_OFN1358_data_1_r_33
XU8799 NR2 $PINS O=n5482 I1=FE_OFN1358_data_1_r_33 I2=n6191
XU8800 NR2 $PINS O=n5486 I1=FE_OFN1548_n9433 I2=n6338
XU8801 XOR2HS $PINS O=n10396 I1=n5489 I2=n6217
XU8802 ND2 $PINS O=n5490 I1=n9093 I2=n9092
XU8803 XOR2HS $PINS O=n10399 I1=n9095 I2=n5490
XU8804 XOR2HS $PINS O=n5507 I1=FE_OFN1256_weight_0_r_19 I2=data_0_r[34]
XU8805 XOR2HS $PINS O=n5894 I1=FE_OFN1254_weight_0_r_21 I2=data_0_r[34]
XU8806 INV1S $PINS O=n5498 I=n5894
XU8807 XOR2HS $PINS O=n5497 I1=FE_OFN1254_weight_0_r_21 I2=data_0_r[33]
XU8808 XOR2HS $PINS O=n5501 I1=FE_OFN1256_weight_0_r_19 I2=data_0_r[36]
XU8809 ND2 $PINS O=n5529 I1=n9794 I2=n9795
XU8810 OA12 $PINS O=n5517 A1=n5505 B1=n1873 B2=n5494
XU8811 XOR2HS $PINS O=n5512 I1=weight_0_r[17] I2=data_0_r[35]
XU8812 ND2S $PINS O=n5508 I1=FE_DBTN25_n6937 I2=n5507
XU8813 NR2 $PINS O=n9815 I1=n5510 I2=FE_OFN1697_n5491
XU8814 XOR2HS $PINS O=n5511 I1=FE_OFN1261_weight_0_r_17 I2=data_0_r[34]
XU8815 AOI22S $PINS O=n9816 A1=weight_0_r[16] A2=n5511 B1=FE_OFN1697_n5491
+ B2=FE_OFN1131_FE_DBTN29_data_0_r_33
XU8816 NR2 $PINS O=n5515 I1=FE_OFN1131_FE_DBTN29_data_0_r_33 I2=n6937
XU8817 NR2 $PINS O=n9811 I1=n5515 I2=n5516
XU8818 XOR2HS $PINS O=n10393 I1=n9796 I2=n5529
XU8819 INV1S $PINS O=n8823 I=Buffer/data_buffer[1207]
XU8820 INV1S $PINS O=n7523 I=Buffer/data_buffer[199]
XU8822 INV1S $PINS O=n7573 I=Buffer/data_buffer[535]
XU8824 INV1S $PINS O=n8820 I=Buffer/data_buffer[1202]
XU8825 INV1S $PINS O=n7712 I=Buffer/data_buffer[194]
XU8826 INV1S $PINS O=n7762 I=Buffer/data_buffer[530]
XU8827 OAI222S $PINS O=n1802 A1=n8820 A2=FE_OFN1482_n5424 B1=n7712
+ B2=FE_OCPN9747_n5429 C1=FE_OFN2028_FE_OCPN9743_n5413 C2=n7762
XU8828 INV1S $PINS O=n8824 I=Buffer/data_buffer[1206]
XU8829 INV1S $PINS O=n7335 I=Buffer/data_buffer[198]
XU8830 INV1S $PINS O=n7385 I=Buffer/data_buffer[534]
XU8831 OAI222S $PINS O=n1806 A1=n8824 A2=FE_OFN1482_n5424 B1=n7335
+ B2=FE_OCPN9738_n5429 C1=FE_OFN1159_n5413 C2=n7385
XU8832 INV1S $PINS O=n8901 I=Buffer/data_buffer[1209]
XU8833 INV1S $PINS O=n8093 I=Buffer/data_buffer[201]
XU8834 INV1S $PINS O=n8142 I=Buffer/data_buffer[537]
XU8835 OAI222S $PINS O=n1809 A1=n8901 A2=FE_OCPN2022_FE_OFN1492_n5424 B1=n8093
+ B2=FE_OFN1208_n5429 C1=FE_OCPN9743_n5413 C2=n8142
XU8836 INV1S $PINS O=n8897 I=Buffer/data_buffer[1210]
XU8837 INV1S $PINS O=n7713 I=Buffer/data_buffer[202]
XU8838 INV1S $PINS O=n7763 I=Buffer/data_buffer[538]
XU8839 OAI222S $PINS O=n1810 A1=n8897 A2=FE_OFN1485_n5424 B1=n7713
+ B2=FE_OFN1208_n5429 C1=FE_OCPN9743_n5413 C2=n7763
XU8840 INV1S $PINS O=n8900 I=Buffer/data_buffer[1211]
XU8841 INV1S $PINS O=n7911 I=Buffer/data_buffer[203]
XU8842 INV1S $PINS O=n7961 I=Buffer/data_buffer[539]
XU8843 OAI222S $PINS O=n1811 A1=n8900 A2=FE_OFN1485_n5424 B1=n7911
+ B2=FE_OFN1208_n5429 C1=FE_OCPN9743_n5413 C2=n7961
XU8844 INV1S $PINS O=n8914 I=Buffer/data_buffer[1218]
XU8845 INV1S $PINS O=n7715 I=Buffer/data_buffer[210]
XU8846 INV1S $PINS O=n7765 I=Buffer/data_buffer[546]
XU8847 OAI222S $PINS O=n1817 A1=n8914 A2=FE_OFN1493_n5424 B1=n7715
+ B2=FE_OFN1205_n5429 C1=FE_OFN1171_n5413 C2=n7765
XU8848 INV1S $PINS O=n8821 I=Buffer/data_buffer[1205]
XU8849 INV1S $PINS O=n8287 I=Buffer/data_buffer[197]
XU8850 INV1S $PINS O=n8336 I=Buffer/data_buffer[533]
XU8851 OAI222S $PINS O=n1805 A1=n8821 A2=FE_OFN1484_n5424 B1=n8287
+ B2=FE_OCPN9738_n5429 C1=FE_OFN1159_n5413 C2=n8336
XU8852 INV1S $PINS O=n8918 I=Buffer/data_buffer[1222]
XU8853 INV1S $PINS O=n7337 I=Buffer/data_buffer[214]
XU8854 INV1S $PINS O=n7387 I=Buffer/data_buffer[550]
XU8855 OAI222S $PINS O=n1821 A1=n8918 A2=FE_OFN1492_n5424 B1=n7337
+ B2=FE_OFN1202_n5429 C1=FE_OFN1165_n5413 C2=n7387
XU8856 INV1S $PINS O=n8891 I=Buffer/data_buffer[1214]
XU8857 INV1S $PINS O=n7336 I=Buffer/data_buffer[206]
XU8858 INV1S $PINS O=n7386 I=Buffer/data_buffer[542]
XU8859 OAI222S $PINS O=n1814 A1=n8891 A2=FE_OFN1484_n5424 B1=n7336
+ B2=FE_OCPN9738_n5429 C1=FE_OFN1159_n5413 C2=n7386
XU8860 INV1S $PINS O=n8818 I=Buffer/data_buffer[1203]
XU8861 INV1S $PINS O=n7909 I=Buffer/data_buffer[195]
XU8862 INV1S $PINS O=n7959 I=Buffer/data_buffer[531]
XU8863 OAI222S $PINS O=n1803 A1=n8818 A2=FE_OCPN9782_n5424 B1=n7909
+ B2=FE_OCPN9747_n5429 C1=FE_OFN2028_FE_OCPN9743_n5413 C2=n7959
XU8864 INV1S $PINS O=n8819 I=Buffer/data_buffer[1204]
XU8865 INV1S $PINS O=n8470 I=Buffer/data_buffer[196]
XU8866 INV1S $PINS O=n8522 I=Buffer/data_buffer[532]
XU8867 OAI222S $PINS O=n1804 A1=n8819 A2=FE_OFN1482_n5424 B1=n8470
+ B2=FE_OCPN9747_n5429 C1=FE_OFN2027_FE_OCPN9743_n5413 C2=n8522
XU8868 XOR2HS $PINS O=n10395 I1=n5540 I2=n2573
XU8869 INV1S $PINS O=n5542 I=n5555
XU8871 XOR2HS $PINS O=n5543 I1=FE_OFN1272_weight_0_r_13
+ I2=FE_OFN1301_data_0_r_17
XU8872 ND2S $PINS O=n5545 I1=FE_OFN1456_n2771 I2=FE_OFN1272_weight_0_r_13
XU8873 XOR2HS $PINS O=n5562 I1=weight_0_r[9] I2=data_0_r[19]
XU8874 XNR2HS $PINS O=n5557 I1=weight_0_r[11] I2=data_0_r[17]
XU8875 ND2S $PINS O=n5556 I1=FE_OFN1632_n7069 I2=n5555
XU8876 OR2T $PINS O=n9682 I1=n5566 I2=n5567
XU8877 NR2 $PINS O=n5560 I1=FE_OFN1301_data_0_r_17 I2=n7046
XU8878 XOR2HS $PINS O=n5561 I1=weight_0_r[9] I2=data_0_r[18]
XU8879 INV1S $PINS O=n5563 I=n5561
XU8880 OA12 $PINS O=n9686 A1=n9688 B1=n9687 B2=n9693
XU8881 XOR2HS $PINS O=n10392 I1=n9671 I2=n5569
XU8882 INV1S $PINS O=n8888 I=data_2_r[1]
XU8883 XOR2HS $PINS O=n6407 I1=FE_OFN1404_weight_2_r_3 I2=weight_2_r[4]
XU8884 INV2 $PINS O=n8889 I=FE_OFN1412_weight_2_r_0
XU8886 XNR2HS $PINS O=n5575 I1=FE_OFN1403_weight_2_r_5 I2=data_2_r[1]
XU8887 AOI22S $PINS O=n5942 A1=n5933 A2=FE_OFN1413_weight_2_r_0 B1=n5578
+ B2=FE_OFN1458_n3162
XU8888 XOR2HS $PINS O=n5579 I1=FE_OFN1406_weight_2_r_3 I2=data_2_r[4]
XU8889 XNR2HS $PINS O=n5586 I1=FE_OFN1406_weight_2_r_3 I2=data_2_r[1]
XU8891 OR2 $PINS O=n8874 I1=n5601 I2=n5602
XU8892 NR2 $PINS O=n8883 I1=n5595 I2=n3285
XU8893 AOI22S $PINS O=n8884 A1=n5596 A2=FE_OFN1413_weight_2_r_0
+ B1=FE_OFN1458_n3162 B2=FE_OFN1246_n8888
XU8894 MOAI1S $PINS O=n5600 A1=FE_OFN1652_n3162 A2=n5598 B1=n5597
+ B2=FE_OFN1413_weight_2_r_0
XU8895 NR2 $PINS O=n8879 I1=n5599 I2=n5600
XU8896 XOR2HS $PINS O=n10397 I1=n8865 I2=n5607
XU8898 AN2 $PINS O=n5636 I1=n7135 I2=FE_OFN1425_FE_DBTN49_data_1_r_1
XU8899 XOR2HS $PINS O=n5620 I1=FE_OFN1351_weight_1_r_1 I2=data_1_r[4]
XU8900 INV1S $PINS O=n5609 I=n5621
XU8901 XOR2HS $PINS O=n5853 I1=weight_1_r[2] I2=FE_OFN1351_weight_1_r_1
XU8902 XOR2HS $PINS O=n5714 I1=FE_OCPN9750_weight_1_r_5 I2=data_1_r[2]
XU8903 NR2P $PINS O=n5726 I1=n5729 I2=FE_OFN1343_weight_1_r_5
XU8904 XOR2HS $PINS O=n5716 I1=weight_1_r[1] I2=data_1_r[6]
XU8905 AOI22S $PINS O=n5713 A1=n5716 A2=FE_OFN1356_weight_1_r_0 B1=n5615
+ B2=FE_OFN1520_n5608
XU8906 XOR2HS $PINS O=n5616 I1=n5725 I2=data_1_r[4]
XU8907 XNR2HS $PINS O=n5704 I1=n5713 I2=n5711
XU8908 ND2 $PINS O=n5639 I1=n9179 I2=n9178
XU8909 XNR2HS $PINS O=n5623 I1=n5725 I2=FE_OFN1425_FE_DBTN49_data_1_r_1
XU8910 ND2S $PINS O=n5622 I1=FE_DBTN37_n5853 I2=n5621
XU8911 NR2 $PINS O=n9201 I1=n5624 I2=FE_OFN1520_n5608
XU8912 XOR2HS $PINS O=n5625 I1=weight_1_r[1] I2=data_1_r[2]
XU8913 AOI22S $PINS O=n9202 A1=n5625 A2=weight_1_r[0] B1=FE_OFN1520_n5608
+ B2=FE_DBTN49_data_1_r_1
XU8914 NR2 $PINS O=n5629 I1=FE_DBTN49_data_1_r_1 I2=FE_OFN1562_FE_DBTN37_n5853
XU8915 INV1S $PINS O=n5627 I=n5625
XU8916 NR2 $PINS O=n9197 I1=n5629 I2=n5630
XU8917 INV1S $PINS O=n5633 I=n5632
XU8918 XOR2HS $PINS O=n10394 I1=n9181 I2=n5639
XU8919 INV1S $PINS O=n7179 I=data_0_r[1]
XU8920 INV1S $PINS O=n7180 I=weight_0_r[0]
XU8921 NR2 $PINS O=n5640 I1=weight_0_r[0] I2=FE_DBTN47_weight_0_r_1
XU8922 INV1S $PINS O=n5642 I=n5656
XU8923 INV1S $PINS O=n5646 I=n6684
XU8924 ND2S $PINS O=n5647 I1=FE_OFN1241_n7179 I2=FE_OFN1291_weight_0_r_5
XU8925 XOR2HS $PINS O=n6682 I1=FE_OFN1297_weight_0_r_1 I2=data_0_r[6]
XU8926 AOI22S $PINS O=n6690 A1=n6682 A2=FE_OFN1299_weight_0_r_0
+ B1=FE_OFN1523_n5640 B2=n5648
XU8927 XOR2HS $PINS O=n5649 I1=n6702 I2=data_0_r[4]
XU8928 ND2 $PINS O=n5677 I1=n9562 I2=n9563
XU8929 XNR2HS $PINS O=n5658 I1=weight_0_r[3] I2=data_0_r[1]
XU8930 ND2S $PINS O=n5657 I1=n9465 I2=n5656
XU8931 OR2 $PINS O=n9575 I1=n5666 I2=n5667
XU8932 NR2 $PINS O=n5659 I1=data_0_r[1] I2=FE_DBTN47_weight_0_r_1
XU8933 NR2 $PINS O=n9580 I1=n5664 I2=n5665
XU8934 FA1 $PINS S=n5669 CO=n5652 A=n5674 B=n5673 CI=n5672
XU8935 OR2 $PINS O=n9570 I1=n5676 I2=n5675
XU8936 XOR2HS $PINS O=n10391 I1=n9565 I2=n5677
XU8937 XOR2HS $PINS O=n5683 I1=FE_OFN1346_weight_1_r_5 I2=data_1_r[13]
XU8938 XNR2HS $PINS O=n5851 I1=FE_OFN1346_weight_1_r_5 I2=data_1_r[12]
XU8939 INV1S $PINS O=n5681 I=n5851
XU8940 MOAI1 $PINS O=n5862 A1=FE_OFN1583_FE_DBTN6_n7135 A2=n5682 B1=n5681
+ B2=FE_DBTN16_n5612
XU8941 XOR2HS $PINS O=n5696 I1=FE_OFN1346_weight_1_r_5 I2=data_1_r[14]
XU8942 XOR2HS $PINS O=n5689 I1=FE_OCPN9762_FE_OFN9133_weight_1_r_3
+ I2=data_1_r[15]
XU8943 XOR2HS $PINS O=n5852 I1=FE_OFN1350_weight_1_r_3 I2=data_1_r[14]
XU8944 INV1S $PINS O=n5690 I=n5852
XU8945 XNR2HS $PINS O=n5693 I1=FE_OFN1342_weight_1_r_7 I2=data_1_r[10]
XU8946 MOAI1 $PINS O=n5866 A1=FE_OFN1613_n5691 A2=n5693 B1=FE_OFN1547_n9120
+ B2=n5692
XU8947 XOR2HS $PINS O=n5834 I1=FE_OFN1355_weight_1_r_1 I2=data_1_r[15]
XU8948 XOR2HS $PINS O=n5835 I1=FE_OFN1342_weight_1_r_7 I2=data_1_r[9]
XU8949 XNR2HS $PINS O=n7140 I1=FE_OFN1342_weight_1_r_7 I2=data_1_r[13]
XU8950 OAI22S $PINS O=n7144 A1=n5695 A2=FE_OFN1612_n5691
+ B1=FE_OFN1578_FE_DBTN10_n9120 B2=n7140
XU8951 ND2S $PINS O=n7151 I1=n5697 I2=FE_OFN1350_weight_1_r_3
XU8952 INV1S $PINS O=n5703 I=n7164
XU8953 NR2P $PINS O=n5723 I1=n5713 I2=n5712
XU8954 XOR2HS $PINS O=n5739 I1=FE_OFN1354_weight_1_r_1 I2=data_1_r[8]
XU8955 XNR2HS $PINS O=n5722 I1=weight_1_r[7] I2=FE_OFN1425_FE_DBTN49_data_1_r_1
XU8956 XNR2HS $PINS O=n5752 I1=n5747 I2=n5749
XU8957 AOI12HS $PINS O=n5731 A1=FE_OFN9135_weight_1_r_3 B1=n5726 B2=data_1_r[3]
XU8958 ND2S $PINS O=n5737 I1=n5732 I2=n5734
XU8959 ND2S $PINS O=n5736 I1=n5732 I2=n5733
XU8960 XOR2HS $PINS O=n5773 I1=FE_OFN1354_weight_1_r_1 I2=data_1_r[9]
XU8961 INV1S $PINS O=n5745 I=n5779
XU8962 NR2 $PINS O=n5795 I1=n5749 I2=n5748
XU8963 XNR2HS $PINS O=n5771 I1=FE_OFN1348_weight_1_r_3 I2=data_1_r[9]
XU8964 XOR2HS $PINS O=n5761 I1=FE_OFN1354_weight_1_r_1 I2=data_1_r[11]
XU8965 XOR2HS $PINS O=n5774 I1=FE_OFN1354_weight_1_r_1 I2=data_1_r[10]
XU8966 XNR2HS $PINS O=n5822 I1=FE_OFN1346_weight_1_r_5 I2=data_1_r[9]
XU8967 XOR2HS $PINS O=n5824 I1=FE_OFN1348_weight_1_r_3 I2=data_1_r[11]
XU8968 MOAI1S $PINS O=n5819 A1=FE_OFN1669_n5855 A2=n5760 B1=n5824
+ B2=FE_OFN1526_n5853
XU8969 INV1S $PINS O=n5765 I=n5766
XU8970 XNR2HS $PINS O=n5790 I1=n5766 I2=n5767
XU8971 INV1S $PINS O=n5770 I=n5768
XU8972 XNR2HS $PINS O=n5780 I1=FE_OFN1345_weight_1_r_5 I2=data_1_r[6]
XU8973 INV1S $PINS O=n5769 I=n5780
XU8974 XOR2HS $PINS O=n5781 I1=FE_OFN1348_weight_1_r_3 I2=data_1_r[8]
XU8975 AOI22S $PINS O=n5794 A1=n5774 A2=FE_OFN1357_weight_1_r_0 B1=n5628
+ B2=n5773
XU8976 NR2P $PINS O=n6389 I1=n5810 I2=n5811
XU8977 ND2 $PINS O=n6387 I1=n5811 I2=n5810
XU8978 XNR2HS $PINS O=n5831 I1=n5844 I2=n5842
XU8979 FA1 $PINS S=n5812 CO=n5830 A=n5820 B=n5819 CI=n5818
XU8980 INV1S $PINS O=n5826 I=n5824
XU8981 MOAI1H $PINS O=n5856 A1=FE_OFN1613_n5691 A2=n5836 B1=n5835
+ B2=FE_OFN1547_n9120
XU8982 XNR2HS $PINS O=n5861 I1=n5858 I2=n5856
XU8983 FA1 $PINS S=n5870 CO=n5865 A=n5847 B=n5846 CI=n5845
XU8984 FA1 $PINS S=n5871 CO=n5874 A=n5866 B=n5867 CI=n5865
XU8985 FA1 $PINS S=n5885 CO=n5877 A=n5873 B=n5872 CI=n5871
XU8986 FA1 $PINS S=n5878 CO=n5702 A=n5876 B=n5875 CI=n5874
XU8987 XNR2HS $PINS O=n5917 I1=FE_OCPN9764_weight_0_r_19 I2=data_0_r[37]
XU8988 NR2 $PINS O=n5897 I1=n6893 I2=n5895
XU8989 XOR2HS $PINS O=n6457 I1=FE_OFN1263_weight_0_r_17 I2=data_0_r[40]
XU8991 XNR2HS $PINS O=n5909 I1=FE_OCPN9751_weight_0_r_23 I2=data_0_r[33]
XU8992 XOR2HS $PINS O=n6459 I1=FE_OCPN9751_weight_0_r_23 I2=data_0_r[34]
XU8993 XNR2HS $PINS O=n6485 I1=n6452 I2=n6454
XU8994 AOI12HS $PINS O=n5916 A1=FE_OFN1516_n5494 B1=n5913 B2=data_0_r[35]
XU8996 NR2 $PINS O=n5918 I1=data_0_r[33] I2=FE_DBTN23_weight_0_r_23
XU8997 INV1S $PINS O=n5921 I=n9791
XU8998 NR2 $PINS O=n5922 I1=n5921 I2=n9790
XU8999 INV1S $PINS O=n5925 I=n5923
XU9000 ND3P $PINS O=n5929 I1=n5928 I2=n5927 I3=n7242
XU9002 XNR2HS $PINS O=n5936 I1=FE_OFN1403_weight_2_r_5 I2=data_2_r[3]
XU9003 INV1S $PINS O=n5947 I=n5946
XU9004 XNR2HS $PINS O=n5954 I1=FE_OFN1400_weight_2_r_7 I2=data_2_r[1]
XU9005 XOR2HS $PINS O=n5962 I1=FE_OFN1400_weight_2_r_7 I2=data_2_r[2]
XU9006 INV1S $PINS O=n6063 I=data_2_r[3]
XU9007 XOR2HS $PINS O=n5966 I1=FE_OFN1401_weight_2_r_5 I2=data_2_r[4]
XU9008 NR2 $PINS O=n5961 I1=data_2_r[1] I2=FE_OFN1440_FE_DBTN12_weight_2_r_7
XU9009 XOR2HS $PINS O=n5984 I1=weight_2_r[5] I2=data_2_r[5]
XU9010 MOAI1 $PINS O=n5983 A1=n5967 A2=FE_OFN1435_FE_DBTN18_n6407 B1=n2890
+ B2=n5966
XU9011 ND2 $PINS O=n8859 I1=n5977 I2=n5976
XU9012 INV1S $PINS O=n5997 I=n5996
XU9013 XNR2HS $PINS O=n6008 I1=FE_OFN1405_weight_2_r_3 I2=data_2_r[9]
XU9014 XNR2HS $PINS O=n6027 I1=n6020 I2=n6022
XU9015 INV1S $PINS O=n6019 I=n6018
XU9016 XOR2HS $PINS O=n6048 I1=FE_OFN1405_weight_2_r_3 I2=data_2_r[11]
XU9017 INV1S $PINS O=n6042 I=n6041
XU9018 XNR2HS $PINS O=n6111 I1=n6106 I2=n6108
XU9019 INV1S $PINS O=n6047 I=n6100
XU9020 XOR2HS $PINS O=n6060 I1=FE_OFN1402_weight_2_r_5 I2=data_2_r[13]
XU9021 INV1S $PINS O=n6058 I=n6084
XU9022 INV1S $PINS O=n6062 I=n6065
XU9023 XOR2HS $PINS O=n6067 I1=FE_OFN1399_weight_2_r_7 I2=data_2_r[11]
XU9024 XNR2HS $PINS O=n6072 I1=FE_OFN1399_weight_2_r_7 I2=data_2_r[12]
XU9025 XOR2HS $PINS O=n6085 I1=weight_2_r[3] I2=data_2_r[14]
XU9026 INV1S $PINS O=n6066 I=n6085
XU9027 XNR2HS $PINS O=n6069 I1=FE_OFN1399_weight_2_r_7 I2=data_2_r[10]
XU9028 NR2 $PINS O=n6117 I1=FE_OFN1440_FE_DBTN12_weight_2_r_7 I2=n8888
XU9029 INV1S $PINS O=n6070 I=n6090
XU9030 NR2 $PINS O=n6423 I1=n6071 I2=FE_OFN1440_FE_DBTN12_weight_2_r_7
XU9031 OAI22S $PINS O=n6422 A1=n6072 A2=FE_OFN1662_n5980 B1=FE_OFN1619_n6414
+ B2=n6416
XU9032 INV1S $PINS O=n6081 I=n6443
XU9033 XOR2HS $PINS O=n6099 I1=FE_OFN1402_weight_2_r_5 I2=data_2_r[11]
XU9034 XNR2HS $PINS O=n6102 I1=FE_OFN1405_weight_2_r_3 I2=data_2_r[13]
XU9035 INV1S $PINS O=n6101 I=n6099
XU9036 FA1 $PINS S=n6131 CO=n6132 A=n6124 B=n6123 CI=n6122
XU9038 ND2 $PINS O=n6140 I1=FE_OFN1306_weight_1_r_23 I2=data_1_r[39]
XU9039 XNR2HS $PINS O=n6142 I1=FE_OFN1306_weight_1_r_23 I2=data_1_r[47]
XU9040 MOAI1S $PINS O=n6139 A1=FE_OFN1617_n6138 A2=n6142 B1=FE_OFN1656_n6322
+ B2=FE_OFN1306_weight_1_r_23
XU9041 XNR2HS $PINS O=n6144 I1=n6140 I2=n6139
XU9042 ND2S $PINS O=n6158 I1=FE_OFN1304_weight_1_r_23 I2=data_1_r[37]
XU9043 INV1S $PINS O=n6141 I=data_1_r[38]
XU9044 NR2 $PINS O=n6146 I1=FE_OFN1303_weight_1_r_23 I2=n6141
XU9045 XNR2HS $PINS O=n6150 I1=n6144 I2=n6143
XU9046 OAI12HS $PINS O=n6153 A1=FE_OFN1310_weight_1_r_21 B1=n6225
+ B2=FE_OFN9125_n3656
XU9047 XOR2HS $PINS O=n6159 I1=FE_OFN1310_weight_1_r_21 I2=data_1_r[47]
XU9048 NR2 $PINS O=n6166 I1=n6208 I2=FE_OFN1302_weight_1_r_23
XU9049 XNR2HS $PINS O=n6163 I1=FE_OFN1307_weight_1_r_23 I2=data_1_r[44]
XU9050 INV1S $PINS O=n6161 I=n6159
XU9051 XOR2HS $PINS O=n6170 I1=FE_OFN1310_weight_1_r_21 I2=data_1_r[46]
XU9052 XOR2HS $PINS O=n6186 I1=FE_OFN1307_weight_1_r_23 I2=data_1_r[43]
XU9053 INV1S $PINS O=n6164 I=n6186
XU9054 FA1 $PINS S=n6204 CO=n6174 A=n6169 B=n6168 CI=n6167
XU9055 INV1S $PINS O=n6172 I=n6184
XU9056 INV1S $PINS O=n6180 I=n6177
XU9057 XOR2HS $PINS O=n6313 I1=FE_OFN1310_weight_1_r_21 I2=data_1_r[43]
XU9058 INV1S $PINS O=n6185 I=n6183
XU9059 XNR2HS $PINS O=n6189 I1=FE_OFN1307_weight_1_r_23 I2=data_1_r[42]
XU9060 NR2 $PINS O=n6312 I1=FE_OFN1302_weight_1_r_23 I2=n9433
XU9061 INV1S $PINS O=n6190 I=n6188
XU9062 XNR2HS $PINS O=n6214 I1=FE_OFN1308_weight_1_r_21 I2=data_1_r[35]
XU9063 XNR2HS $PINS O=n6220 I1=weight_1_r[23] I2=FE_OFN1358_data_1_r_33
XU9064 XOR2HS $PINS O=n6236 I1=FE_OFN1304_weight_1_r_23 I2=data_1_r[34]
XU9065 AOI12HS $PINS O=n6227 A1=FE_OFN1448_n2033 B1=n6222 B2=data_1_r[35]
XU9066 NR2 $PINS O=n6228 I1=FE_OFN1358_data_1_r_33 I2=FE_OFN1302_weight_1_r_23
XU9067 ND2S $PINS O=n6234 I1=n6230 I2=n6231
XU9068 XOR2HS $PINS O=n6271 I1=FE_OFN1313_weight_1_r_17 I2=data_1_r[43]
XU9069 INV1S $PINS O=n6267 I=n6266
XU9070 XNR2HS $PINS O=n6276 I1=FE_OFN1312_weight_1_r_19 I2=data_1_r[41]
XU9071 XNR2HS $PINS O=n6284 I1=FE_OFN1304_weight_1_r_23 I2=data_1_r[38]
XU9072 XOR2HS $PINS O=n6289 I1=FE_OFN1312_weight_1_r_19 I2=data_1_r[42]
XU9073 XOR2HS $PINS O=n6320 I1=FE_OFN1307_weight_1_r_23 I2=data_1_r[39]
XU9074 XOR2HS $PINS O=n6336 I1=FE_OFN1312_weight_1_r_19 I2=data_1_r[43]
XU9075 FA1 $PINS S=n6346 CO=n6197 A=n6312 B=n6311 CI=n6310
XU9076 INV1S $PINS O=n6324 I=n6320
XU9077 FA1 $PINS S=n6345 CO=n6329 A=n6327 B=n6326 CI=n6325
XU9078 INV1S $PINS O=n6339 I=n6336
XU9079 XNR2HS $PINS O=n6360 I1=n6350 I2=n6351
XU9080 FA1 $PINS S=n6358 CO=n6362 A=n6357 B=n6356 CI=n6355
XU9081 ND2S $PINS O=n6870 I1=n6377 I2=n6376
XU9082 OAI12HS $PINS O=n6384 A1=n6870 B1=n6869 B2=n6873
XU9083 INV1S $PINS O=n6388 I=n6387
XU9084 NR2 $PINS O=n6394 I1=n6388 I2=n6389
XU9086 INV1S $PINS O=n6392 I=n7279
XU9087 XNR2HS $PINS O=pConv_1/product_0_w[10] I1=n6394 I2=n6393
XU9088 XOR2HS $PINS O=pConv_1/product_0_w[11] I1=n6397 I2=n6396
XU9089 XNR2HS $PINS O=n6403 I1=weight_2_r[7] I2=data_2_r[15]
XU9090 XNR2HS $PINS O=n6405 I1=n6400 I2=n6399
XU9091 ND2S $PINS O=n6426 I1=FE_OFN1398_weight_2_r_7 I2=data_2_r[5]
XU9092 INV1S $PINS O=n6401 I=data_2_r[6]
XU9093 NR2 $PINS O=n6409 I1=FE_DBTN12_weight_2_r_7 I2=n6401
XU9094 XNR2HS $PINS O=n6413 I1=weight_2_r[7] I2=data_2_r[14]
XU9095 XNR2HS $PINS O=n6418 I1=n6405 I2=n6404
XU9096 OAI12HS $PINS O=n6421 A1=FE_OFN1402_weight_2_r_5 B1=n2890
+ B2=FE_OCPN9772_n6407
XU9097 XOR2HS $PINS O=n6445 I1=n6418 I2=n6417
XU9098 INV1S $PINS O=n6446 I=n6781
XU9099 NR2 $PINS O=n6447 I1=n6446 I2=n6780
XU9100 XOR2HS $PINS O=n6463 I1=FE_OFN1263_weight_0_r_17 I2=data_0_r[42]
XU9101 XNR2HS $PINS O=n6460 I1=FE_OCPN9751_weight_0_r_23 I2=data_0_r[35]
XU9102 XNR2HS $PINS O=n6495 I1=n6471 I2=n6473
XU9103 XOR2HS $PINS O=n6455 I1=FE_OFN1253_weight_0_r_21 I2=data_0_r[37]
XU9104 XOR2HS $PINS O=n6501 I1=FE_OFN1264_weight_0_r_17 I2=data_0_r[43]
XU9105 XOR2HS $PINS O=n6505 I1=FE_OFN1255_weight_0_r_21 I2=data_0_r[39]
XU9106 INV1S $PINS O=n6470 I=n6469
XU9107 INV1S $PINS O=n6476 I=n6514
XU9108 NR2 $PINS O=n6500 I1=n6476 I2=n6515
XU9109 ND2P $PINS O=n6488 I1=n9789 I2=n9790
XU9111 FA1 $PINS S=n6497 CO=n6474 A=n6495 B=n6494 CI=n6493
XU9112 INV1S $PINS O=n6498 I=n7270
XU9113 XNR2HS $PINS O=pConv_0/product_2_w[10] I1=n6500 I2=n6499
XU9114 XNR2HS $PINS O=n6984 I1=n6960 I2=n6958
XU9115 XOR2HS $PINS O=n6954 I1=FE_OFN1257_weight_0_r_19 I2=data_0_r[42]
XU9116 XOR2HS $PINS O=pConv_0/product_2_w[11] I1=n6517 I2=n6516
XU9117 INV1S $PINS O=n6519 I=n6518
XU9118 NR2 $PINS O=n6525 I1=n6519 I2=n6520
XU9119 INV1S $PINS O=n7257 I=n6522
XU9120 INV1S $PINS O=n6523 I=n7256
XU9121 XNR2HS $PINS O=pConv_2/product_1_w[10] I1=n6525 I2=n6524
XU9122 ND2S $PINS O=n6528 I1=n8954 I2=n8958
XU9123 XOR2HS $PINS O=pConv_2/product_1_w[11] I1=n6528 I2=n6527
XU9124 XOR2HS $PINS O=n6542 I1=FE_OFN1279_weight_0_r_9 I2=data_0_r[29]
XU9125 XNR2HS $PINS O=n6633 I1=n6553 I2=n6555
XU9126 XNR2HS $PINS O=n6622 I1=data_0_r[25] I2=FE_OFN1275_weight_0_r_11
XU9127 XOR2HS $PINS O=n6537 I1=FE_OFN1279_weight_0_r_9 I2=data_0_r[27]
XU9128 XOR2HS $PINS O=n6604 I1=FE_OFN1279_weight_0_r_9 I2=data_0_r[26]
XU9129 XNR2HS $PINS O=n6540 I1=FE_OFN1269_weight_0_r_15 I2=data_0_r[21]
XU9130 INV1S $PINS O=n6533 I=n6616
XU9131 XOR2HS $PINS O=n6551 I1=FE_OFN1276_weight_0_r_11 I2=data_0_r[27]
XU9132 XOR2HS $PINS O=n7032 I1=FE_OFN1279_weight_0_r_9 I2=data_0_r[30]
XU9134 XOR2HS $PINS O=n7064 I1=FE_OFN1273_weight_0_r_13 I2=data_0_r[26]
XU9135 INV1S $PINS O=n6550 I=n7064
XU9136 XNR2HS $PINS O=n7071 I1=FE_OFN1276_weight_0_r_11 I2=data_0_r[28]
XU9137 OAI22S $PINS O=n7061 A1=n6552 A2=FE_OFN1634_n7070 B1=FE_OFN1678_n7036
+ B2=n7071
XU9138 INV1S $PINS O=n9650 I=n7075
XU9139 XOR2HS $PINS O=n6583 I1=FE_OFN1278_weight_0_r_9 I2=data_0_r[23]
XU9140 INV1S $PINS O=n6562 I=n6583
XU9141 XNR2HS $PINS O=n6563 I1=FE_OFN1272_weight_0_r_13 I2=data_0_r[19]
XU9142 NR2 $PINS O=n6568 I1=n6998 I2=n6564
XU9143 ND2S $PINS O=n6567 I1=n6566 I2=n6998
XU9144 XOR2HS $PINS O=n6584 I1=FE_OFN1278_weight_0_r_9 I2=data_0_r[24]
XU9145 INV1S $PINS O=n6573 I=n6585
XU9146 AOI12HS $PINS O=n6577 A1=FE_DBTN34_weight_0_r_11 B1=n6575
+ B2=data_0_r[19]
XU9147 XOR2HS $PINS O=n6580 I1=FE_OFN9748_weight_0_r_13 I2=data_0_r[20]
XU9148 NR2 $PINS O=n6579 I1=FE_OFN1301_data_0_r_17 I2=FE_DBTN28_weight_0_r_15
XU9149 XOR2HS $PINS O=n6609 I1=FE_OFN1271_weight_0_r_13 I2=data_0_r[21]
XU9150 MOAI1S $PINS O=n6608 A1=n7067 A2=n6581 B1=FE_DBTN22_n3850 B2=n6580
XU9151 ND2 $PINS O=n9663 I1=n6599 I2=n6600
XU9152 XNR2HS $PINS O=n6615 I1=n6626 I2=n6624
XU9153 FA1 $PINS S=n6641 CO=n6642 A=n6615 B=n6613 CI=n6614
XU9154 XOR2HS $PINS O=n7189 I1=data_0_r[14] I2=FE_OFN1298_weight_0_r_1
XU9155 XOR2HS $PINS O=n6667 I1=FE_OFN1284_weight_0_r_7 I2=data_0_r[7]
XU9157 XNR2HS $PINS O=n7194 I1=FE_OFN1284_weight_0_r_7 I2=data_0_r[8]
XU9158 XNR2HS $PINS O=n7203 I1=n7213 I2=n7211
XU9159 XOR2HS $PINS O=n6663 I1=FE_OFN1295_weight_0_r_3 I2=data_0_r[11]
XU9160 MOAI1 $PINS O=n6676 A1=FE_OFN1647_n9466 A2=n6657 B1=FE_OFN1545_n7188
+ B2=n6663
XU9161 XOR2HS $PINS O=n6665 I1=FE_OFN1298_weight_0_r_1 I2=data_0_r[12]
XU9162 OAI22S $PINS O=n6752 A1=n6674 A2=FE_OFN1630_n6658 B1=FE_OFN1550_n9457
+ B2=n6668
XU9163 MOAI1 $PINS O=n7207 A1=FE_OFN1704_n9443 A2=n6662 B1=FE_OFN9122_n2908
+ B2=n6661
XU9164 INV1S $PINS O=n6664 I=n6663
XU9165 XNR2HS $PINS O=n7210 I1=FE_OFN1295_weight_0_r_3 I2=data_0_r[12]
XU9166 XNR2HS $PINS O=n6759 I1=n6670 I2=n6671
XU9167 XNR2HS $PINS O=n6748 I1=FE_OFN1294_weight_0_r_3 I2=data_0_r[9]
XU9168 NR2 $PINS O=n6701 I1=FE_OFN1241_n7179 I2=FE_OFN1550_n9457
XU9169 NR2 $PINS O=n6689 I1=n9455 I2=n6686
XU9170 ND2S $PINS O=n6688 I1=n6687 I2=n9455
XU9171 XOR2HS $PINS O=n6709 I1=weight_0_r[7] I2=data_0_r[2]
XU9172 AOI12HS $PINS O=n6705 A1=FE_OFN9130_weight_0_r_3 B1=n6703 B2=data_0_r[3]
XU9173 AOI13HS $PINS O=n6704 A1=FE_OFN9128_weight_0_r_3 B1=n2399 B2=n7174
+ B3=FE_OCPN9755_FE_OFN1289_weight_0_r_5
XU9174 NR2 $PINS O=n6707 I1=data_0_r[1] I2=FE_OFN1446_FE_DBTN0_weight_0_r_7
XU9175 ND2 $PINS O=n9556 I1=n6725 I2=n6724
XU9176 FA1 $PINS S=n6726 CO=n6739 A=n6734 B=n6733 CI=n6732
XU9177 INV1S $PINS O=n6746 I=n6743
XU9178 MOAI1 $PINS O=n6755 A1=FE_OFN1704_n9443 A2=n6746
+ B1=FE_OFN1574_FE_DBTN20_n2908 B2=n6745
XU9179 INV1S $PINS O=n6749 I=n6747
XU9180 XNR2HS $PINS O=n6764 I1=n6753 I2=n6752
XU9181 ND3HT $PINS O=n6777 I1=n6776 I2=n6774 I3=n6775
XU9182 XNR2HS $PINS O=pConv_0/product_0_w[13] I1=n2751 I2=n6778
XU9183 XOR2HS $PINS O=pConv_1/product_2_w[8] I1=n6783 I2=n6782
XU9184 INV1S $PINS O=n9406 I=n6784
XU9185 XNR2HS $PINS O=pConv_1/product_2_w[9] I1=n6786 I2=FE_OCPN9754_n6785
XU9186 INV1S $PINS O=n6795 I=n6787
XU9188 XNR2HS $PINS O=pConv_2/product_2_w[9] I1=n6789 I2=FE_OCPN9766_n6788
XU9189 INV1S $PINS O=n6791 I=n6790
XU9190 NR2 $PINS O=n6797 I1=n6791 I2=n6792
XU9191 INV1S $PINS O=n6794 I=n6793
XU9192 XNR2HS $PINS O=pConv_2/product_2_w[10] I1=n6797 I2=n6796
XU9193 INV1S $PINS O=n9083 I=n6798
XU9194 XOR2HS $PINS O=pConv_2/product_2_w[11] I1=n6800 I2=n6799
XU9195 INV1S $PINS O=n6802 I=n6801
XU9196 NR2 $PINS O=n6808 I1=n6802 I2=n6803
XU9197 INV1S $PINS O=n7263 I=n6805
XU9198 INV1S $PINS O=n6806 I=n7262
XU9199 XNR2HS $PINS O=pConv_2/product_0_w[10] I1=n6808 I2=n6807
XU9200 INV1S $PINS O=n8852 I=n6809
XU9201 XOR2HS $PINS O=pConv_2/product_0_w[11] I1=n6811 I2=n6810
XU9202 INV1S $PINS O=n6814 I=n6812
XU9203 XNR2HS $PINS O=pConv_2/product_2_w[16] I1=n6818 I2=n6817
XU9204 INV1S $PINS O=n9050 I=n6827
XU9205 INV1S $PINS O=n6820 I=data_2_r[38]
XU9206 NR2 $PINS O=n9049 I1=n6821 I2=n6820
XU9207 OAI22S $PINS O=n9048 A1=n6824 A2=FE_OFN1602_n4195 B1=FE_OFN1701_n6822
+ B2=n9045
XU9208 INV1S $PINS O=n6833 I=n9061
XU9209 ND3P $PINS O=n6840 I1=n6838 I2=n6839 I3=n6837
XU9210 INV1S $PINS O=n6848 I=n6841
XU9212 XNR2HS $PINS O=pConv_0/product_1_w[9] I1=n6843 I2=n6842
XU9213 INV1S $PINS O=n6845 I=n6844
XU9214 NR2 $PINS O=n6850 I1=n6845 I2=n6846
XU9215 AOI12HS $PINS O=n6849 A1=n6847 B1=FE_OCPN9756_n6842 B2=n6848
XU9216 XNR2HS $PINS O=pConv_0/product_1_w[10] I1=n6850 I2=n6849
XU9217 INV1S $PINS O=n9656 I=n6851
XU9218 XOR2HS $PINS O=pConv_0/product_1_w[11] I1=n6853 I2=n6852
XU9219 INV1S $PINS O=n6854 I=n8861
XU9220 NR2 $PINS O=n6855 I1=n6854 I2=n8860
XU9221 INV1S $PINS O=n6863 I=n6856
XU9223 XNR2HS $PINS O=pConv_0/product_0_w[9] I1=n6858 I2=FE_OCPN9720_n6857
XU9224 INV1S $PINS O=n6860 I=n6859
XU9225 NR2 $PINS O=n6865 I1=n6860 I2=n6861
XU9226 XNR2HS $PINS O=pConv_0/product_0_w[10] I1=n6865 I2=n6864
XU9227 INV1S $PINS O=n9548 I=n6866
XU9228 ND2S $PINS O=n6868 I1=n9548 I2=n9552
XU9229 XOR2HS $PINS O=pConv_0/product_0_w[11] I1=n6868 I2=n6867
XU9230 INV1S $PINS O=n6871 I=n6869
XU9231 ND3 $PINS O=n6877 I1=FE_OFN1240_n6309 I2=n6872 I3=n9362
XU9232 INV1S $PINS O=n9350 I=n6873
XU9233 ND3P $PINS O=n6878 I1=n6877 I2=n6876 I3=n6875
XU9234 NR2 $PINS O=pConv_0/product_2_w[0] I1=n6890
+ I2=FE_OFN1131_FE_DBTN29_data_0_r_33
XU9235 XOR2HS $PINS O=n6882 I1=FE_OFN1255_weight_0_r_21 I2=data_0_r[45]
XU9236 INV1S $PINS O=n6881 I=n6882
XU9237 XOR2HS $PINS O=n6888 I1=FE_OFN1251_weight_0_r_23 I2=data_0_r[43]
XU9238 INV1S $PINS O=n6885 I=n6888
XU9239 XNR2HS $PINS O=n6894 I1=FE_OFN1251_weight_0_r_23 I2=data_0_r[44]
XU9240 XNR2HS $PINS O=n6891 I1=FE_OFN1249_weight_0_r_23 I2=data_0_r[42]
XU9241 MOAI1 $PINS O=n6927 A1=FE_OFN1620_n6448 A2=n6891 B1=n9697 B2=n6888
XU9242 NR2 $PINS O=n6907 I1=FE_DBTN23_weight_0_r_23 I2=FE_DBTN29_data_0_r_33
XU9243 XOR2HS $PINS O=n6918 I1=FE_OFN1264_weight_0_r_17 I2=data_0_r[47]
XU9244 XOR2HS $PINS O=n6919 I1=FE_OFN1249_weight_0_r_23 I2=data_0_r[41]
XU9245 NR2 $PINS O=n9722 I1=n6893 I2=FE_OFN1432_FE_DBTN23_weight_0_r_23
XU9246 XNR2HS $PINS O=n9715 I1=FE_OFN1251_weight_0_r_23 I2=data_0_r[45]
XU9247 FA1 $PINS S=n6981 CO=n9730 A=n6897 B=n6896 CI=n6895
XU9248 FA1 $PINS S=n6895 CO=n9726 A=n6901 B=n6922 CI=n6900
XU9249 ND2S $PINS O=n6994 I1=n9738 I2=n6904
XU9250 OAI22S $PINS O=n6944 A1=n6936 A2=FE_OFN1587_n1873 B1=FE_OFN1539_n6937
+ B2=n6916
XU9251 XOR2HS $PINS O=n6917 I1=FE_OFN1264_weight_0_r_17 I2=data_0_r[46]
XU9252 XOR2HS $PINS O=n6942 I1=FE_OFN1248_weight_0_r_23 I2=data_0_r[39]
XU9253 XNR2HS $PINS O=n6920 I1=FE_OFN1252_weight_0_r_23 I2=data_0_r[40]
XU9254 OAI22S $PINS O=n6950 A1=n6911 A2=FE_OFN1620_n6448 B1=FE_OFN1553_n9713
+ B2=n6920
XU9255 MOAI1 $PINS O=n6924 A1=FE_OFN1587_n1873 A2=n6916
+ B1=FE_OFN1569_FE_DBTN25_n6937 B2=n6915
XU9256 NR2 $PINS O=n6923 I1=n6933 I2=n6921
XU9257 FA1 $PINS S=n6929 CO=n6979 A=n6925 B=n6924 CI=n6923
XU9258 FA1 $PINS S=n6978 CO=n6980 A=n6928 B=n6927 CI=n6926
XU9259 XNR2HS $PINS O=n6975 I1=n6933 I2=n6932
XU9260 INV1S $PINS O=n6938 I=n6955
XU9261 XNR2HS $PINS O=n6972 I1=n6950 I2=n6951
XU9263 NR2 $PINS O=pConv_0/product_0_w[0] I1=n7180 I2=n7179
XU9264 ND2 $PINS O=n6995 I1=n8968 I2=n8969
XU9265 XOR2HS $PINS O=n10398 I1=n8971 I2=n6995
XU9266 OAI12HS $PINS O=n9602 A1=FE_OFN1271_weight_0_r_13
+ B1=FE_OFN1570_FE_DBTN22_n3850 B2=n6996
XU9267 INV1S $PINS O=n9597 I=n7002
XU9268 NR2 $PINS O=n9596 I1=FE_OFN1430_FE_DBTN28_weight_0_r_15 I2=n3287
XU9269 XNR2HS $PINS O=n6997 I1=FE_OFN1268_weight_0_r_15 I2=data_0_r[30]
XU9270 XNR2HS $PINS O=n9591 I1=FE_OFN1267_weight_0_r_15 I2=data_0_r[31]
XU9271 XOR2HS $PINS O=n7003 I1=FE_OFN1273_weight_0_r_13 I2=data_0_r[31]
XU9272 XNR2HS $PINS O=n6999 I1=FE_OFN1268_weight_0_r_15 I2=data_0_r[29]
XU9273 OAI22S $PINS O=n7000 A1=n6999 A2=FE_OFN1626_n6531 B1=FE_OFN1455_n2727
+ B2=n6997
XU9274 NR2 $PINS O=n7013 I1=n6998 I2=FE_OFN1430_FE_DBTN28_weight_0_r_15
XU9275 XNR2HS $PINS O=n7007 I1=FE_OFN1268_weight_0_r_15 I2=data_0_r[28]
XU9276 OAI22S $PINS O=n7012 A1=n7007 A2=FE_OFN1626_n6531 B1=FE_OFN1455_n2727
+ B2=n6999
XU9277 INV1S $PINS O=n7004 I=n7003
XU9278 MOAI1H $PINS O=n7017 A1=FE_OFN1544_n7067 A2=n7004
+ B1=FE_OFN1571_FE_DBTN22_n3850 B2=n7018
XU9279 NR2 $PINS O=n7022 I1=FE_OFN1430_FE_DBTN28_weight_0_r_15 I2=n7006
XU9280 INV1S $PINS O=n7011 I=n9607
XU9281 XOR2HS $PINS O=n7026 I1=FE_OFN1273_weight_0_r_13 I2=data_0_r[29]
XU9282 MOAI1 $PINS O=n7050 A1=FE_OFN1544_n7067 A2=n7019
+ B1=FE_OFN1571_FE_DBTN22_n3850 B2=n7026
XU9283 FA1 $PINS S=n7049 CO=n7015 A=n7022 B=n7048 CI=n7021
XU9284 INV1S $PINS O=n7028 I=n7026
XU9285 XNR2HS $PINS O=n7030 I1=FE_OFN1273_weight_0_r_13 I2=data_0_r[28]
XU9286 INV1S $PINS O=n7027 I=n7030
XU9287 XOR2HS $PINS O=n7063 I1=FE_OFN1273_weight_0_r_13 I2=data_0_r[27]
XU9288 XNR2HS $PINS O=n7068 I1=data_0_r[29] I2=FE_OFN1276_weight_0_r_11
XU9289 XOR2HS $PINS O=n7044 I1=FE_OFN1279_weight_0_r_9 I2=data_0_r[31]
XU9290 AOI22S $PINS O=n7060 A1=n7044 A2=FE_OFN1283_weight_0_r_8 B1=n7032
+ B2=n2791
XU9291 INV1S $PINS O=n7037 I=n7034
XU9292 NR2 $PINS O=n7080 I1=FE_DBTN28_weight_0_r_15 I2=FE_OFN1456_n2771
XU9293 MOAI1 $PINS O=n7079 A1=n7046 A2=n9696 B1=n2791 B2=n7044
XU9294 MOAI1S $PINS O=n7082 A1=FE_OFN1544_n7067 A2=n7066
+ B1=FE_OFN1570_FE_DBTN22_n3850 B2=n7064
XU9295 INV1S $PINS O=n7073 I=n7072
XU9297 NR2 $PINS O=n7109 I1=n3616 I2=n9664
XU9298 XOR2HS $PINS O=n10401 I1=n9666 I2=n7109
XU9299 INV1S $PINS O=n7110 I=n9174
XU9300 XOR2HS $PINS O=n10403 I1=n9175 I2=n7111
XU9301 INV1S $PINS O=n7112 I=n8965
XU9302 NR2 $PINS O=n7113 I1=n7112 I2=n8964
XU9303 NR2 $PINS O=pConv_2/product_2_w[0] I1=n7115 I2=FE_DBTN30_data_2_r_33
XU9304 AOI12H $PINS O=n7118 A1=n3449 B1=FE_OFN1156_n2894 B2=n3408
XU9305 XOR2HS $PINS O=pConv_2/product_0_w[17] I1=n7119 I2=n7118
XU9306 XOR2HS $PINS O=pConv_1/product_0_w[17] I1=n7122 I2=n7121
XU9307 XOR2HS $PINS O=pConv_1/product_1_w[17] I1=n7125 I2=n7124
XU9308 INV1S $PINS O=n7132 I=n9321
XU9309 NR2 $PINS O=n7133 I1=n7132 I2=n9320
XU9310 XOR2HS $PINS O=n10404 I1=n3188 I2=n7133
XU9311 INV1S $PINS O=n9127 I=n7149
XU9312 INV1S $PINS O=n7136 I=data_1_r[6]
XU9313 XNR2HS $PINS O=n7137 I1=FE_OFN1340_weight_1_r_7 I2=data_1_r[14]
XU9314 XNR2HS $PINS O=n9121 I1=FE_OFN1340_weight_1_r_7 I2=data_1_r[15]
XU9315 OAI22S $PINS O=n9125 A1=n7137 A2=FE_OFN1612_n5691
+ B1=FE_OFN1578_FE_DBTN10_n9120 B2=n9121
XU9316 INV1S $PINS O=n7154 I=n9137
XU9317 INV1S $PINS O=n7167 I=n9559
XU9318 NR2 $PINS O=n7168 I1=n9558 I2=n7167
XU9319 XOR2HS $PINS O=n10400 I1=n2911 I2=n7168
XU9320 MOAI1 $PINS O=n9477 A1=FE_OFN1579_FE_DBTN8_n9443 A2=n7172
+ B1=FE_OFN1573_FE_DBTN20_n2908 B2=n7171
XU9321 XOR2HS $PINS O=n7178 I1=FE_OFN1285_weight_0_r_7 I2=data_0_r[11]
XU9322 INV1S $PINS O=n7177 I=n7187
XU9323 XNR2HS $PINS O=n7181 I1=FE_OFN1286_weight_0_r_7 I2=data_0_r[10]
XU9324 NR2 $PINS O=n7219 I1=FE_DBTN0_weight_0_r_7 I2=n7179
XU9325 XOR2HS $PINS O=n7193 I1=FE_OFN1285_weight_0_r_7 I2=data_0_r[9]
XU9326 INV1S $PINS O=n7182 I=n7193
XU9327 FA1 $PINS S=n7230 CO=n9483 A=n9469 B=FE_DBTN47_weight_0_r_1 CI=n7183
XU9328 XNR2HS $PINS O=n7209 I1=FE_OFN1295_weight_0_r_3 I2=data_0_r[13]
XU9329 XNR2HS $PINS O=n7217 I1=n7205 I2=n7204
XU9330 OAI22S $PINS O=n7221 A1=n7210 A2=FE_OFN1648_n9466 B1=FE_OFN1641_n9465
+ B2=n7209
XU9331 FA1 $PINS S=n7215 CO=n7226 A=n7222 B=n7221 CI=n7220
XU9332 XOR2H $PINS O=pConv_1/product_2_w[17] I1=n7241 I2=n7240
XU9333 ND2S $PINS O=n7245 I1=n7243 I2=n7242
XU9334 XOR2HS $PINS O=pConv_2/product_2_w[17] I1=n7245 I2=n7244
XU9335 ND2S $PINS O=n7248 I1=FE_DBTN5_n7246 I2=n9629
XU9337 XOR2HS $PINS O=pConv_0/product_1_w[17] I1=n7248 I2=n7247
XU9338 ND2S $PINS O=n7255 I1=n7250 I2=n7251
XU9339 XNR2HS $PINS O=pConv_2/product_1_w[9] I1=n7258 I2=FE_OCPN9753_n6521
XU9340 ND2S $PINS O=n7261 I1=n2070 I2=n7260
XU9341 ND2S $PINS O=n7264 I1=n7262 I2=n7263
XU9342 XNR2HS $PINS O=pConv_2/product_0_w[9] I1=n7264 I2=FE_OCPN9763_n6804
XU9343 INV1S $PINS O=n7267 I=n7265
XU9344 INV1S $PINS O=n9765 I=n7268
XU9345 ND2S $PINS O=n7272 I1=n7270 I2=n7271
XU9346 XNR2HS $PINS O=pConv_0/product_2_w[9] I1=n7272 I2=FE_OCPN9765_n6986
XU9347 ND2S $PINS O=n7278 I1=n7274 I2=n7275
XU9348 ND2S $PINS O=n7281 I1=n7279 I2=n7280
XU9349 XNR2HS $PINS O=pConv_1/product_0_w[9] I1=n7281 I2=n6390
XU9350 INV1S $PINS O=n7284 I=n7282
XU9351 ND2S $PINS O=n7291 I1=n9312 I2=n9314
XU9353 XNR2HS $PINS O=pConv_1/product_1_w[9] I1=n7291 I2=n7290
XU9355 XOR2HS $PINS O=n388 I1=Buffer/counter_temp[1] I2=n7295
XU9356 MOAI1S $PINS O=n387 A1=n1710 A2=n7297 B1=Buffer/counter_temp[2] B2=n7296
XU9358 INV1S $PINS O=n7300 I=weight_0_w[1]
XU9360 ND2 $PINS O=n7299 I1=i_data[1] I2=FE_OFN183_FE_DBTN1_n7298
XU9361 OAI12HS $PINS O=n408 A1=n7299 B1=FE_OFN183_FE_DBTN1_n7298 B2=n7300
XU9362 INV1S $PINS O=n7301 I=weight_0_w[9]
XU9363 MXL2HS $PINS OB=n407 S=FE_OFN184_FE_DBTN1_n7298 A=n7301 B=n7300
XU9364 INV1S $PINS O=n7302 I=weight_0_w[17]
XU9365 MXL2HS $PINS OB=n406 S=FE_OFN185_FE_DBTN1_n7298 A=n7302 B=n7301
XU9366 INV1S $PINS O=n7303 I=weight_1_w[1]
XU9367 MXL2HS $PINS OB=n405 S=FE_OFN113_FE_DBTN1_n7298 A=n7303 B=n7302
XU9368 INV1S $PINS O=n7304 I=weight_1_w[9]
XU9369 MXL2HS $PINS OB=n404 S=FE_OFN166_FE_DBTN1_n7298 A=n7304 B=n7303
XU9370 INV1S $PINS O=n7305 I=weight_1_w[17]
XU9371 MXL2HS $PINS OB=n403 S=FE_OFN228_FE_DBTN1_n7298 A=n7305 B=n7304
XU9372 INV1S $PINS O=n8890 I=weight_2_w[1]
XU9373 MXL2HS $PINS OB=n402 S=FE_OFN227_FE_DBTN1_n7298 A=n8890 B=n7305
XU9374 INV1S $PINS O=n7307 I=Buffer/data_buffer[6]
XU9375 ND2 $PINS O=n7306 I1=i_data[6] I2=FE_OFN1243_n7298
XU9376 OAI12HS $PINS O=n1703 A1=n7306 B1=FE_OFN1243_n7298 B2=n7307
XU9377 INV1S $PINS O=n7308 I=Buffer/data_buffer[14]
XU9378 MXL2HS $PINS OB=n1695 S=FE_OFN125_FE_DBTN1_n7298 A=n7307 B=n7308
XU9379 INV1S $PINS O=n7309 I=Buffer/data_buffer[22]
XU9380 MXL2HS $PINS OB=n1687 S=FE_OFN76_FE_DBTN1_n7298 A=n7308 B=n7309
XU9381 INV1S $PINS O=n7311 I=Buffer/data_buffer[30]
XU9382 MXL2HS $PINS OB=n1679 S=FE_OFN38_FE_DBTN1_n7298 A=n7309 B=n7311
XU9383 MXL2HS $PINS OB=n1671 S=FE_OFN19_FE_DBTN1_n7298 A=n7311 B=n7312
XU9384 MXL2HS $PINS OB=n1663 S=FE_OFN7_FE_DBTN1_n7298 A=n7312 B=n7313
XU9385 MXL2HS $PINS OB=n1655 S=FE_OFN78_FE_DBTN1_n7298 A=n7313 B=n7314
XU9386 MXL2HS $PINS OB=n1647 S=FE_OFN246_FE_DBTN1_n7298 A=n7314 B=n7315
XU9387 MXL2HS $PINS OB=n1639 S=FE_OFN192_FE_DBTN1_n7298 A=n7315 B=n7316
XU9388 MXL2HS $PINS OB=n1631 S=FE_OFN131_FE_DBTN1_n7298 A=n7316 B=n7318
XU9389 INV1S $PINS O=n7319 I=Buffer/data_buffer[86]
XU9390 MXL2HS $PINS OB=n1623 S=FE_OFN133_FE_DBTN1_n7298 A=n7318 B=n7319
XU9391 INV1S $PINS O=n7320 I=Buffer/data_buffer[94]
XU9392 MXL2HS $PINS OB=n1615 S=FE_OFN315_FE_DBTN1_n7298 A=n7319 B=n7320
XU9393 INV1S $PINS O=n7321 I=Buffer/data_buffer[102]
XU9394 MXL2HS $PINS OB=n1607 S=FE_OFN29_FE_DBTN1_n7298 A=n7320 B=n7321
XU9395 INV1S $PINS O=n7322 I=Buffer/data_buffer[110]
XU9396 MXL2HS $PINS OB=n1599 S=FE_OFN29_FE_DBTN1_n7298 A=n7321 B=n7322
XU9397 MXL2HS $PINS OB=n1591 S=FE_OFN242_FE_DBTN1_n7298 A=n7322 B=n7323
XU9398 MXL2HS $PINS OB=n1583 S=FE_OFN245_FE_DBTN1_n7298 A=n7323 B=n7325
XU9399 MXL2HS $PINS OB=n1575 S=FE_OFN187_FE_DBTN1_n7298 A=n7325 B=n7326
XU9400 MXL2HS $PINS OB=n1567 S=FE_OFN32_FE_DBTN1_n7298 A=n7326 B=n7327
XU9401 MXL2HS $PINS OB=n1559 S=FE_OFN4_FE_DBTN1_n7298 A=n7327 B=n7328
XU9402 MXL2HS $PINS OB=n1551 S=FE_OFN7_FE_DBTN1_n7298 A=n7328 B=n7329
XU9403 MXL2HS $PINS OB=n1543 S=FE_OFN10_FE_DBTN1_n7298 A=n7329 B=n7330
XU9404 MXL2HS $PINS OB=n1535 S=FE_OFN246_FE_DBTN1_n7298 A=n7330 B=n7332
XU9405 MXL2HS $PINS OB=n1527 S=FE_OFN249_FE_DBTN1_n7298 A=n7332 B=n7333
XU9406 MXL2HS $PINS OB=n1519 S=FE_OFN25_FE_DBTN1_n7298 A=n7333 B=n7334
XU9407 MXL2HS $PINS OB=n1511 S=FE_OFN271_FE_DBTN1_n7298 A=n7334 B=n7335
XU9408 MXL2HS $PINS OB=n1503 S=FE_OFN305_FE_DBTN1_n7298 A=n7335 B=n7336
XU9409 MXL2HS $PINS OB=n1495 S=FE_OFN304_FE_DBTN1_n7298 A=n7336 B=n7337
XU9410 MXL2HS $PINS OB=n1487 S=FE_OFN291_FE_DBTN1_n7298 A=n7337 B=n7339
XU9411 MXL2HS $PINS OB=n1479 S=FE_OFN174_FE_DBTN1_n7298 A=n7339 B=n7340
XU9412 MXL2HS $PINS OB=n1471 S=FE_OFN122_FE_DBTN1_n7298 A=n7340 B=n7341
XU9413 INV1S $PINS O=n7342 I=Buffer/data_buffer[246]
XU9414 MXL2HS $PINS OB=n1463 S=FE_OFN73_FE_DBTN1_n7298 A=n7341 B=n7342
XU9415 INV1S $PINS O=n7343 I=Buffer/data_buffer[254]
XU9416 MXL2HS $PINS OB=n1455 S=FE_OFN73_FE_DBTN1_n7298 A=n7342 B=n7343
XU9417 INV1S $PINS O=n7344 I=Buffer/data_buffer[262]
XU9418 MXL2HS $PINS OB=n1447 S=FE_OFN36_FE_DBTN1_n7298 A=n7343 B=n7344
XU9419 INV1S $PINS O=n7346 I=Buffer/data_buffer[270]
XU9420 MXL2HS $PINS OB=n1439 S=FE_OFN219_FE_DBTN1_n7298 A=n7344 B=n7346
XU9421 INV1S $PINS O=n7347 I=Buffer/data_buffer[278]
XU9422 MXL2HS $PINS OB=n1431 S=FE_OFN223_FE_DBTN1_n7298 A=n7346 B=n7347
XU9423 INV1S $PINS O=n7348 I=Buffer/data_buffer[286]
XU9424 MXL2HS $PINS OB=n1423 S=FE_OFN161_FE_DBTN1_n7298 A=n7347 B=n7348
XU9425 INV1S $PINS O=n7349 I=Buffer/data_buffer[294]
XU9426 MXL2HS $PINS OB=n1415 S=FE_OFN107_FE_DBTN1_n7298 A=n7348 B=n7349
XU9427 INV1S $PINS O=n7350 I=Buffer/data_buffer[302]
XU9428 MXL2HS $PINS OB=n1407 S=FE_OFN323_FE_DBTN1_n7298 A=n7349 B=n7350
XU9429 INV1S $PINS O=n7351 I=Buffer/data_buffer[310]
XU9430 MXL2HS $PINS OB=n1399 S=FE_OFN98_FE_DBTN1_n7298 A=n7350 B=n7351
XU9431 INV1S $PINS O=n7353 I=Buffer/data_buffer[318]
XU9432 MXL2HS $PINS OB=n1391 S=FE_OFN98_FE_DBTN1_n7298 A=n7351 B=n7353
XU9433 INV1S $PINS O=n7354 I=Buffer/data_buffer[326]
XU9434 MXL2HS $PINS OB=n1383 S=FE_OFN314_FE_DBTN1_n7298 A=n7353 B=n7354
XU9435 INV1S $PINS O=n7355 I=Buffer/data_buffer[334]
XU9436 MXL2HS $PINS OB=n1375 S=FE_OFN226_FE_DBTN1_n7298 A=n7354 B=n7355
XU9437 MXL2HS $PINS OB=n1367 S=FE_OFN164_FE_DBTN1_n7298 A=n7355 B=n7356
XU9438 MXL2HS $PINS OB=n1359 S=FE_OFN245_FE_DBTN1_n7298 A=n7356 B=n7357
XU9439 MXL2HS $PINS OB=n1351 S=FE_OFN244_FE_DBTN1_n7298 A=n7357 B=n7358
XU9440 MXL2HS $PINS OB=n1343 S=FE_OFN64_FE_DBTN1_n7298 A=n7358 B=n7360
XU9441 MXL2HS $PINS OB=n1335 S=FE_OFN4_FE_DBTN1_n7298 A=n7360 B=n7362
XU9442 MXL2HS $PINS OB=n1327 S=FE_OFN7_FE_DBTN1_n7298 A=n7362 B=n7363
XU9443 MXL2HS $PINS OB=n1319 S=FE_OFN78_FE_DBTN1_n7298 A=n7363 B=n7364
XU9444 MXL2HS $PINS OB=n1311 S=FE_OFN246_FE_DBTN1_n7298 A=n7364 B=n7365
XU9445 MXL2HS $PINS OB=n1303 S=FE_OFN192_FE_DBTN1_n7298 A=n7365 B=n7366
XU9446 MXL2HS $PINS OB=n1295 S=FE_OFN46_FE_DBTN1_n7298 A=n7366 B=n7368
XU9447 INV1S $PINS O=n7369 I=Buffer/data_buffer[422]
XU9448 MXL2HS $PINS OB=n1287 S=FE_OFN327_FE_DBTN1_n7298 A=n7368 B=n7369
XU9449 INV1S $PINS O=n7370 I=Buffer/data_buffer[430]
XU9450 MXL2HS $PINS OB=n1279 S=FE_OFN318_FE_DBTN1_n7298 A=n7369 B=n7370
XU9451 INV1S $PINS O=n7371 I=Buffer/data_buffer[438]
XU9452 MXL2HS $PINS OB=n1271 S=FE_OFN317_FE_DBTN1_n7298 A=n7370 B=n7371
XU9453 INV1S $PINS O=n7372 I=Buffer/data_buffer[446]
XU9454 MXL2HS $PINS OB=n1263 S=FE_OFN325_FE_DBTN1_n7298 A=n7371 B=n7372
XU9455 INV1S $PINS O=n7373 I=Buffer/data_buffer[454]
XU9456 MXL2HS $PINS OB=n1255 S=FE_OFN329_FE_DBTN1_n7298 A=n7372 B=n7373
XU9457 INV1S $PINS O=n7375 I=Buffer/data_buffer[462]
XU9458 MXL2HS $PINS OB=n1247 S=FE_OFN329_FE_DBTN1_n7298 A=n7373 B=n7375
XU9459 INV1S $PINS O=n7376 I=Buffer/data_buffer[470]
XU9460 MXL2HS $PINS OB=n1239 S=FE_OFN296_FE_DBTN1_n7298 A=n7375 B=n7376
XU9461 INV1S $PINS O=n7377 I=Buffer/data_buffer[478]
XU9462 MXL2HS $PINS OB=n1231 S=FE_OFN296_FE_DBTN1_n7298 A=n7376 B=n7377
XU9463 INV1S $PINS O=n7378 I=Buffer/data_buffer[486]
XU9464 MXL2HS $PINS OB=n1223 S=FE_OFN255_FE_DBTN1_n7298 A=n7377 B=n7378
XU9465 INV1S $PINS O=n7379 I=Buffer/data_buffer[494]
XU9466 MXL2HS $PINS OB=n1215 S=FE_OFN196_FE_DBTN1_n7298 A=n7378 B=n7379
XU9467 INV1S $PINS O=n7380 I=Buffer/data_buffer[502]
XU9468 MXL2HS $PINS OB=n1207 S=FE_OFN254_FE_DBTN1_n7298 A=n7379 B=n7380
XU9469 INV1S $PINS O=n7382 I=Buffer/data_buffer[510]
XU9470 MXL2HS $PINS OB=n1199 S=FE_OFN59_FE_DBTN1_n7298 A=n7380 B=n7382
XU9471 INV1S $PINS O=n7383 I=Buffer/data_buffer[518]
XU9472 MXL2HS $PINS OB=n1191 S=FE_OFN59_FE_DBTN1_n7298 A=n7382 B=n7383
XU9473 INV1S $PINS O=n7384 I=Buffer/data_buffer[526]
XU9474 MXL2HS $PINS OB=n1183 S=FE_OFN310_FE_DBTN1_n7298 A=n7383 B=n7384
XU9475 MXL2HS $PINS OB=n1175 S=FE_OFN310_FE_DBTN1_n7298 A=n7384 B=n7385
XU9476 MXL2HS $PINS OB=n1167 S=FE_OFN305_FE_DBTN1_n7298 A=n7385 B=n7386
XU9477 MXL2HS $PINS OB=n1159 S=FE_OFN304_FE_DBTN1_n7298 A=n7386 B=n7387
XU9478 MXL2HS $PINS OB=n1151 S=FE_OFN291_FE_DBTN1_n7298 A=n7387 B=n7389
XU9479 MXL2HS $PINS OB=n1143 S=FE_OFN174_FE_DBTN1_n7298 A=n7389 B=n7390
XU9480 MXL2HS $PINS OB=n1135 S=FE_OFN124_FE_DBTN1_n7298 A=n7390 B=n7391
XU9481 INV1S $PINS O=n7392 I=Buffer/data_buffer[582]
XU9482 MXL2HS $PINS OB=n1127 S=FE_OFN181_FE_DBTN1_n7298 A=n7391 B=n7392
XU9483 INV1S $PINS O=n7393 I=Buffer/data_buffer[590]
XU9484 MXL2HS $PINS OB=n1119 S=FE_OFN238_FE_DBTN1_n7298 A=n7392 B=n7393
XU9485 INV1S $PINS O=n7394 I=Buffer/data_buffer[598]
XU9486 MXL2HS $PINS OB=n1111 S=FE_OFN236_FE_DBTN1_n7298 A=n7393 B=n7394
XU9487 INV1S $PINS O=n7396 I=Buffer/data_buffer[606]
XU9488 MXL2HS $PINS OB=n1103 S=FE_OFN236_FE_DBTN1_n7298 A=n7394 B=n7396
XU9489 INV1S $PINS O=n7397 I=Buffer/data_buffer[614]
XU9490 MXL2HS $PINS OB=n1095 S=FE_OFN178_FE_DBTN1_n7298 A=n7396 B=n7397
XU9491 INV1S $PINS O=n7398 I=Buffer/data_buffer[622]
XU9492 MXL2HS $PINS OB=n1087 S=FE_OFN178_FE_DBTN1_n7298 A=n7397 B=n7398
XU9493 INV1S $PINS O=n7399 I=Buffer/data_buffer[630]
XU9494 MXL2HS $PINS OB=n1079 S=FE_OFN176_FE_DBTN1_n7298 A=n7398 B=n7399
XU9495 INV1S $PINS O=n7400 I=Buffer/data_buffer[638]
XU9496 MXL2HS $PINS OB=n1071 S=FE_OFN175_FE_DBTN1_n7298 A=n7399 B=n7400
XU9497 INV1S $PINS O=n7402 I=Buffer/data_buffer[646]
XU9498 MXL2HS $PINS OB=n1063 S=FE_OFN234_FE_DBTN1_n7298 A=n7400 B=n7402
XU9499 INV1S $PINS O=n7404 I=Buffer/data_buffer[654]
XU9500 MXL2HS $PINS OB=n1055 S=FE_OFN229_FE_DBTN1_n7298 A=n7402 B=n7404
XU9501 INV1S $PINS O=n7405 I=Buffer/data_buffer[662]
XU9502 MXL2HS $PINS OB=n1047 S=FE_OFN229_FE_DBTN1_n7298 A=n7404 B=n7405
XU9503 INV1S $PINS O=n7406 I=Buffer/data_buffer[670]
XU9504 MXL2HS $PINS OB=n1039 S=FE_OFN229_FE_DBTN1_n7298 A=n7405 B=n7406
XU9505 INV1S $PINS O=n7407 I=Buffer/data_buffer[678]
XU9506 MXL2HS $PINS OB=n1031 S=FE_OFN169_FE_DBTN1_n7298 A=n7406 B=n7407
XU9507 INV1S $PINS O=n7408 I=Buffer/data_buffer[686]
XU9508 MXL2HS $PINS OB=n1023 S=FE_OFN169_FE_DBTN1_n7298 A=n7407 B=n7408
XU9509 INV1S $PINS O=n7410 I=Buffer/data_buffer[694]
XU9510 MXL2HS $PINS OB=n1015 S=FE_OFN67_FE_DBTN1_n7298 A=n7408 B=n7410
XU9511 INV1S $PINS O=n7411 I=Buffer/data_buffer[702]
XU9512 MXL2HS $PINS OB=n1007 S=FE_OFN114_FE_DBTN1_n7298 A=n7410 B=n7411
XU9513 INV1S $PINS O=n7412 I=Buffer/data_buffer[710]
XU9514 MXL2HS $PINS OB=n999 S=FE_OFN114_FE_DBTN1_n7298 A=n7411 B=n7412
XU9515 INV1S $PINS O=n7413 I=Buffer/data_buffer[718]
XU9516 MXL2HS $PINS OB=n991 S=FE_OFN278_FE_DBTN1_n7298 A=n7412 B=n7413
XU9517 INV1S $PINS O=n7414 I=Buffer/data_buffer[726]
XU9518 MXL2HS $PINS OB=n983 S=FE_OFN277_FE_DBTN1_n7298 A=n7413 B=n7414
XU9519 INV1S $PINS O=n7415 I=Buffer/data_buffer[734]
XU9520 MXL2HS $PINS OB=n975 S=FE_OFN276_FE_DBTN1_n7298 A=n7414 B=n7415
XU9521 INV1S $PINS O=n7417 I=Buffer/data_buffer[742]
XU9522 MXL2HS $PINS OB=n967 S=FE_OFN312_FE_DBTN1_n7298 A=n7415 B=n7417
XU9523 INV1S $PINS O=n7418 I=Buffer/data_buffer[750]
XU9524 MXL2HS $PINS OB=n959 S=FE_OFN275_FE_DBTN1_n7298 A=n7417 B=n7418
XU9525 INV1S $PINS O=n7419 I=Buffer/data_buffer[758]
XU9526 MXL2HS $PINS OB=n951 S=FE_OFN310_FE_DBTN1_n7298 A=n7418 B=n7419
XU9527 INV1S $PINS O=n7420 I=Buffer/data_buffer[766]
XU9528 MXL2HS $PINS OB=n943 S=FE_OFN272_FE_DBTN1_n7298 A=n7419 B=n7420
XU9529 INV1S $PINS O=n7421 I=Buffer/data_buffer[774]
XU9530 MXL2HS $PINS OB=n935 S=FE_OFN153_FE_DBTN1_n7298 A=n7420 B=n7421
XU9531 INV1S $PINS O=n7422 I=Buffer/data_buffer[782]
XU9532 MXL2HS $PINS OB=n927 S=FE_OFN289_FE_DBTN1_n7298 A=n7421 B=n7422
XU9533 MXL2HS $PINS OB=n919 S=FE_OFN165_FE_DBTN1_n7298 A=n7422 B=n7424
XU9534 MXL2HS $PINS OB=n911 S=FE_OFN224_FE_DBTN1_n7298 A=n7424 B=n7425
XU9535 MXL2HS $PINS OB=n903 S=FE_OFN187_FE_DBTN1_n7298 A=n7425 B=n7426
XU9536 MXL2HS $PINS OB=n895 S=FE_OFN64_FE_DBTN1_n7298 A=n7426 B=n7427
XU9537 MXL2HS $PINS OB=n887 S=FE_OFN14_FE_DBTN1_n7298 A=n7427 B=n7428
XU9538 MXL2HS $PINS OB=n879 S=FE_OFN4_FE_DBTN1_n7298 A=n7428 B=n7429
XU9539 INV1S $PINS O=n7431 I=Buffer/data_buffer[838]
XU9540 MXL2HS $PINS OB=n871 S=FE_OFN43_FE_DBTN1_n7298 A=n7429 B=n7431
XU9541 INV1S $PINS O=n7432 I=Buffer/data_buffer[846]
XU9542 MXL2HS $PINS OB=n863 S=FE_OFN191_FE_DBTN1_n7298 A=n7431 B=n7432
XU9543 INV1S $PINS O=n7433 I=Buffer/data_buffer[854]
XU9544 MXL2HS $PINS OB=n855 S=FE_OFN46_FE_DBTN1_n7298 A=n7432 B=n7433
XU9545 INV1S $PINS O=n7434 I=Buffer/data_buffer[862]
XU9546 MXL2HS $PINS OB=n847 S=FE_OFN87_FE_DBTN1_n7298 A=n7433 B=n7434
XU9547 INV1S $PINS O=n7435 I=Buffer/data_buffer[870]
XU9548 MXL2HS $PINS OB=n839 S=FE_OFN194_FE_DBTN1_n7298 A=n7434 B=n7435
XU9549 INV1S $PINS O=n7436 I=Buffer/data_buffer[878]
XU9550 MXL2HS $PINS OB=n831 S=FE_OFN252_FE_DBTN1_n7298 A=n7435 B=n7436
XU9551 INV1S $PINS O=n7438 I=Buffer/data_buffer[886]
XU9552 MXL2HS $PINS OB=n823 S=FE_OFN252_FE_DBTN1_n7298 A=n7436 B=n7438
XU9553 INV1S $PINS O=n7439 I=Buffer/data_buffer[894]
XU9554 MXL2HS $PINS OB=n815 S=FE_OFN261_FE_DBTN1_n7298 A=n7438 B=n7439
XU9555 INV1S $PINS O=n7440 I=Buffer/data_buffer[902]
XU9556 MXL2HS $PINS OB=n807 S=FE_OFN199_FE_DBTN1_n7298 A=n7439 B=n7440
XU9557 INV1S $PINS O=n7441 I=Buffer/data_buffer[910]
XU9558 MXL2HS $PINS OB=n799 S=FE_OFN199_FE_DBTN1_n7298 A=n7440 B=n7441
XU9559 INV1S $PINS O=n7442 I=Buffer/data_buffer[918]
XU9560 MXL2HS $PINS OB=n791 S=FE_OFN140_FE_DBTN1_n7298 A=n7441 B=n7442
XU9561 INV1S $PINS O=n7443 I=Buffer/data_buffer[926]
XU9562 MXL2HS $PINS OB=n783 S=FE_OFN259_FE_DBTN1_n7298 A=n7442 B=n7443
XU9563 INV1S $PINS O=n7445 I=Buffer/data_buffer[934]
XU9564 MXL2HS $PINS OB=n775 S=FE_OFN259_FE_DBTN1_n7298 A=n7443 B=n7445
XU9565 INV1S $PINS O=n7447 I=Buffer/data_buffer[942]
XU9566 MXL2HS $PINS OB=n767 S=FE_OFN259_FE_DBTN1_n7298 A=n7445 B=n7447
XU9567 INV1S $PINS O=n7448 I=Buffer/data_buffer[950]
XU9568 MXL2HS $PINS OB=n759 S=FE_OFN259_FE_DBTN1_n7298 A=n7447 B=n7448
XU9569 INV1S $PINS O=n7449 I=Buffer/data_buffer[958]
XU9570 MXL2HS $PINS OB=n751 S=FE_OFN258_FE_DBTN1_n7298 A=n7448 B=n7449
XU9571 INV1S $PINS O=n7450 I=Buffer/data_buffer[966]
XU9572 MXL2HS $PINS OB=n743 S=FE_OFN265_FE_DBTN1_n7298 A=n7449 B=n7450
XU9573 INV1S $PINS O=n7451 I=Buffer/data_buffer[974]
XU9574 MXL2HS $PINS OB=n735 S=FE_OFN265_FE_DBTN1_n7298 A=n7450 B=n7451
XU9575 INV1S $PINS O=n7453 I=Buffer/data_buffer[982]
XU9576 MXL2HS $PINS OB=n727 S=FE_OFN264_FE_DBTN1_n7298 A=n7451 B=n7453
XU9577 INV1S $PINS O=n7454 I=Buffer/data_buffer[990]
XU9578 MXL2HS $PINS OB=n719 S=FE_OFN264_FE_DBTN1_n7298 A=n7453 B=n7454
XU9579 INV1S $PINS O=n7455 I=Buffer/data_buffer[998]
XU9580 MXL2HS $PINS OB=n711 S=FE_OFN207_FE_DBTN1_n7298 A=n7454 B=n7455
XU9581 INV1S $PINS O=n7456 I=Buffer/data_buffer[1006]
XU9582 MXL2HS $PINS OB=n703 S=FE_OFN147_FE_DBTN1_n7298 A=n7455 B=n7456
XU9583 INV1S $PINS O=n7457 I=Buffer/data_buffer[1014]
XU9584 MXL2HS $PINS OB=n695 S=FE_OFN266_FE_DBTN1_n7298 A=n7456 B=n7457
XU9585 INV1S $PINS O=n7458 I=Buffer/data_buffer[1022]
XU9586 MXL2HS $PINS OB=n687 S=FE_OFN266_FE_DBTN1_n7298 A=n7457 B=n7458
XU9587 INV1S $PINS O=n7460 I=Buffer/data_buffer[1030]
XU9588 MXL2HS $PINS OB=n679 S=FE_OFN266_FE_DBTN1_n7298 A=n7458 B=n7460
XU9589 INV1S $PINS O=n7461 I=Buffer/data_buffer[1038]
XU9590 MXL2HS $PINS OB=n671 S=FE_OFN143_FE_DBTN1_n7298 A=n7460 B=n7461
XU9591 INV1S $PINS O=n7462 I=Buffer/data_buffer[1046]
XU9592 MXL2HS $PINS OB=n663 S=FE_OFN143_FE_DBTN1_n7298 A=n7461 B=n7462
XU9593 INV1S $PINS O=n7463 I=Buffer/data_buffer[1054]
XU9594 MXL2HS $PINS OB=n655 S=FE_OFN339_FE_DBTN1_n7298 A=n7462 B=n7463
XU9595 INV1S $PINS O=n7464 I=Buffer/data_buffer[1062]
XU9596 MXL2HS $PINS OB=n647 S=FE_OFN339_FE_DBTN1_n7298 A=n7463 B=n7464
XU9597 INV1S $PINS O=n7465 I=Buffer/data_buffer[1070]
XU9598 MXL2HS $PINS OB=n639 S=FE_OFN339_FE_DBTN1_n7298 A=n7464 B=n7465
XU9599 INV1S $PINS O=n7467 I=Buffer/data_buffer[1078]
XU9600 MXL2HS $PINS OB=n631 S=FE_OFN334_FE_DBTN1_n7298 A=n7465 B=n7467
XU9601 INV1S $PINS O=n7468 I=Buffer/data_buffer[1086]
XU9602 MXL2HS $PINS OB=n623 S=FE_OFN320_FE_DBTN1_n7298 A=n7467 B=n7468
XU9603 INV1S $PINS O=n7469 I=Buffer/data_buffer[1094]
XU9604 MXL2HS $PINS OB=n615 S=FE_OFN320_FE_DBTN1_n7298 A=n7468 B=n7469
XU9605 INV1S $PINS O=n7470 I=Buffer/data_buffer[1102]
XU9606 MXL2HS $PINS OB=n607 S=FE_OFN320_FE_DBTN1_n7298 A=n7469 B=n7470
XU9607 INV1S $PINS O=n7471 I=Buffer/data_buffer[1110]
XU9608 MXL2HS $PINS OB=n599 S=FE_OFN297_FE_DBTN1_n7298 A=n7470 B=n7471
XU9609 INV1S $PINS O=n7472 I=Buffer/data_buffer[1118]
XU9610 MXL2HS $PINS OB=n591 S=FE_OFN297_FE_DBTN1_n7298 A=n7471 B=n7472
XU9611 INV1S $PINS O=n7474 I=Buffer/data_buffer[1126]
XU9612 MXL2HS $PINS OB=n583 S=FE_OFN297_FE_DBTN1_n7298 A=n7472 B=n7474
XU9613 INV1S $PINS O=n7475 I=Buffer/data_buffer[1134]
XU9614 MXL2HS $PINS OB=n575 S=FE_OFN101_FE_DBTN1_n7298 A=n7474 B=n7475
XU9615 INV1S $PINS O=n7476 I=Buffer/data_buffer[1142]
XU9616 MXL2HS $PINS OB=n567 S=FE_OFN101_FE_DBTN1_n7298 A=n7475 B=n7476
XU9617 INV1S $PINS O=n7477 I=Buffer/data_buffer[1150]
XU9618 MXL2HS $PINS OB=n559 S=FE_OFN60_FE_DBTN1_n7298 A=n7476 B=n7477
XU9619 INV1S $PINS O=n7478 I=Buffer/data_buffer[1158]
XU9620 MXL2HS $PINS OB=n551 S=FE_OFN200_FE_DBTN1_n7298 A=n7477 B=n7478
XU9621 INV1S $PINS O=n7479 I=Buffer/data_buffer[1166]
XU9622 MXL2HS $PINS OB=n543 S=FE_OFN60_FE_DBTN1_n7298 A=n7478 B=n7479
XU9623 INV1S $PINS O=n7481 I=Buffer/data_buffer[1174]
XU9624 MXL2HS $PINS OB=n535 S=FE_OFN324_FE_DBTN1_n7298 A=n7479 B=n7481
XU9625 INV1S $PINS O=n7483 I=Buffer/data_buffer[1182]
XU9626 MXL2HS $PINS OB=n527 S=FE_OFN324_FE_DBTN1_n7298 A=n7481 B=n7483
XU9627 INV1S $PINS O=n7484 I=Buffer/data_buffer[1190]
XU9628 MXL2HS $PINS OB=n519 S=FE_OFN312_FE_DBTN1_n7298 A=n7483 B=n7484
XU9629 INV1S $PINS O=n7485 I=Buffer/data_buffer[1198]
XU9630 MXL2HS $PINS OB=n511 S=FE_OFN284_FE_DBTN1_n7298 A=n7484 B=n7485
XU9631 MXL2HS $PINS OB=n503 S=FE_OFN106_FE_DBTN1_n7298 A=n7485 B=n8824
XU9632 INV1S $PINS O=n7487 I=weight_0_w[0]
XU9633 ND2 $PINS O=n7486 I1=i_data[0] I2=FE_OFN42_FE_DBTN1_n7298
XU9634 OAI12HS $PINS O=n399 A1=n7486 B1=FE_OFN246_FE_DBTN1_n7298 B2=n7487
XU9635 INV1S $PINS O=n7488 I=weight_0_w[8]
XU9636 MXL2HS $PINS OB=n398 S=FE_OFN246_FE_DBTN1_n7298 A=n7488 B=n7487
XU9637 INV1S $PINS O=n7490 I=weight_0_w[16]
XU9638 MXL2HS $PINS OB=n397 S=FE_OFN246_FE_DBTN1_n7298 A=n7490 B=n7488
XU9639 INV1S $PINS O=n7492 I=weight_1_w[0]
XU9640 MXL2HS $PINS OB=n396 S=FE_OFN65_FE_DBTN1_n7298 A=n7492 B=n7490
XU9641 INV1S $PINS O=n7493 I=weight_1_w[8]
XU9642 MXL2HS $PINS OB=n395 S=FE_OFN166_FE_DBTN1_n7298 A=n7493 B=n7492
XU9643 INV1S $PINS O=n7494 I=weight_1_w[16]
XU9644 MXL2HS $PINS OB=n394 S=FE_OFN166_FE_DBTN1_n7298 A=n7494 B=n7493
XU9645 INV1S $PINS O=n8892 I=weight_2_w[0]
XU9646 MXL2HS $PINS OB=n393 S=FE_OFN227_FE_DBTN1_n7298 A=n8892 B=n7494
XU9647 INV1S $PINS O=n7496 I=Buffer/data_buffer[7]
XU9648 ND2 $PINS O=n7495 I1=i_data[7] I2=FE_OFN1243_n7298
XU9649 OAI12HS $PINS O=n1702 A1=n7495 B1=FE_OFN1243_n7298 B2=n7496
XU9650 INV1S $PINS O=n7497 I=Buffer/data_buffer[15]
XU9651 MXL2HS $PINS OB=n1694 S=FE_OFN76_FE_DBTN1_n7298 A=n7496 B=n7497
XU9652 INV1S $PINS O=n7498 I=Buffer/data_buffer[23]
XU9653 MXL2HS $PINS OB=n1686 S=FE_OFN76_FE_DBTN1_n7298 A=n7497 B=n7498
XU9654 INV1S $PINS O=n7499 I=Buffer/data_buffer[31]
XU9655 MXL2HS $PINS OB=n1678 S=FE_OFN38_FE_DBTN1_n7298 A=n7498 B=n7499
XU9656 MXL2HS $PINS OB=n1670 S=FE_OFN19_FE_DBTN1_n7298 A=n7499 B=n7500
XU9657 MXL2HS $PINS OB=n1662 S=FE_OFN7_FE_DBTN1_n7298 A=n7500 B=n7501
XU9658 MXL2HS $PINS OB=n1654 S=FE_OFN77_FE_DBTN1_n7298 A=n7501 B=n7502
XU9659 MXL2HS $PINS OB=n1646 S=FE_OFN82_FE_DBTN1_n7298 A=n7502 B=n7503
XU9660 MXL2HS $PINS OB=n1638 S=FE_OFN191_FE_DBTN1_n7298 A=n7503 B=n7504
XU9661 MXL2HS $PINS OB=n1630 S=FE_OFN85_FE_DBTN1_n7298 A=n7504 B=n7505
XU9662 INV1S $PINS O=n7506 I=Buffer/data_buffer[87]
XU9663 MXL2HS $PINS OB=n1622 S=FE_OFN85_FE_DBTN1_n7298 A=n7505 B=n7506
XU9664 INV1S $PINS O=n7507 I=Buffer/data_buffer[95]
XU9665 MXL2HS $PINS OB=n1614 S=FE_OFN248_FE_DBTN1_n7298 A=n7506 B=n7507
XU9666 INV1S $PINS O=n7509 I=Buffer/data_buffer[103]
XU9667 MXL2HS $PINS OB=n1606 S=FE_OFN129_FE_DBTN1_n7298 A=n7507 B=n7509
XU9668 INV1S $PINS O=n7510 I=Buffer/data_buffer[111]
XU9669 MXL2HS $PINS OB=n1598 S=FE_OFN81_FE_DBTN1_n7298 A=n7509 B=n7510
XU9670 MXL2HS $PINS OB=n1590 S=FE_OFN81_FE_DBTN1_n7298 A=n7510 B=n7511
XU9671 MXL2HS $PINS OB=n1582 S=FE_OFN245_FE_DBTN1_n7298 A=n7511 B=n7512
XU9672 MXL2HS $PINS OB=n1574 S=FE_OFN187_FE_DBTN1_n7298 A=n7512 B=n7513
XU9673 MXL2HS $PINS OB=n1566 S=FE_OFN111_FE_DBTN1_n7298 A=n7513 B=n7514
XU9674 MXL2HS $PINS OB=n1558 S=FE_OFN4_FE_DBTN1_n7298 A=n7514 B=n7516
XU9675 MXL2HS $PINS OB=n1550 S=FE_OFN20_FE_DBTN1_n7298 A=n7516 B=n7517
XU9676 MXL2HS $PINS OB=n1542 S=FE_OFN9_FE_DBTN1_n7298 A=n7517 B=n7518
XU9677 MXL2HS $PINS OB=n1534 S=FE_OFN23_FE_DBTN1_n7298 A=n7518 B=n7519
XU9678 MXL2HS $PINS OB=n1526 S=FE_OFN24_FE_DBTN1_n7298 A=n7519 B=n7520
XU9679 MXL2HS $PINS OB=n1518 S=FE_OFN45_FE_DBTN1_n7298 A=n7520 B=n7521
XU9680 MXL2HS $PINS OB=n1510 S=FE_OFN316_FE_DBTN1_n7298 A=n7521 B=n7523
XU9681 MXL2HS $PINS OB=n1502 S=FE_OFN210_FE_DBTN1_n7298 A=n7523 B=n7524
XU9682 MXL2HS $PINS OB=n1494 S=FE_OFN16_FE_DBTN1_n7298 A=n7524 B=n7525
XU9683 MXL2HS $PINS OB=n1486 S=FE_OFN34_FE_DBTN1_n7298 A=n7525 B=n7526
XU9684 MXL2HS $PINS OB=n1478 S=FE_OFN173_FE_DBTN1_n7298 A=n7526 B=n7527
XU9685 MXL2HS $PINS OB=n1470 S=FE_OFN75_FE_DBTN1_n7298 A=n7527 B=n7528
XU9686 INV1S $PINS O=n7530 I=Buffer/data_buffer[247]
XU9687 MXL2HS $PINS OB=n1462 S=FE_OFN36_FE_DBTN1_n7298 A=n7528 B=n7530
XU9688 INV1S $PINS O=n7531 I=Buffer/data_buffer[255]
XU9689 MXL2HS $PINS OB=n1454 S=FE_OFN36_FE_DBTN1_n7298 A=n7530 B=n7531
XU9690 INV1S $PINS O=n7532 I=Buffer/data_buffer[263]
XU9691 MXL2HS $PINS OB=n1446 S=FE_OFN18_FE_DBTN1_n7298 A=n7531 B=n7532
XU9692 INV1S $PINS O=n7533 I=Buffer/data_buffer[271]
XU9693 MXL2HS $PINS OB=n1438 S=FE_OFN286_FE_DBTN1_n7298 A=n7532 B=n7533
XU9694 INV1S $PINS O=n7534 I=Buffer/data_buffer[279]
XU9695 MXL2HS $PINS OB=n1430 S=FE_OFN161_FE_DBTN1_n7298 A=n7533 B=n7534
XU9696 INV1S $PINS O=n7535 I=Buffer/data_buffer[287]
XU9697 MXL2HS $PINS OB=n1422 S=FE_OFN161_FE_DBTN1_n7298 A=n7534 B=n7535
XU9698 INV1S $PINS O=n7537 I=Buffer/data_buffer[295]
XU9699 MXL2HS $PINS OB=n1414 S=FE_OFN107_FE_DBTN1_n7298 A=n7535 B=n7537
XU9700 INV1S $PINS O=n7539 I=Buffer/data_buffer[303]
XU9701 MXL2HS $PINS OB=n1406 S=FE_OFN323_FE_DBTN1_n7298 A=n7537 B=n7539
XU9702 INV1S $PINS O=n7540 I=Buffer/data_buffer[311]
XU9703 MXL2HS $PINS OB=n1398 S=FE_OFN98_FE_DBTN1_n7298 A=n7539 B=n7540
XU9704 INV1S $PINS O=n7541 I=Buffer/data_buffer[319]
XU9705 MXL2HS $PINS OB=n1390 S=FE_OFN98_FE_DBTN1_n7298 A=n7540 B=n7541
XU9706 INV1S $PINS O=n7542 I=Buffer/data_buffer[327]
XU9707 MXL2HS $PINS OB=n1382 S=FE_OFN314_FE_DBTN1_n7298 A=n7541 B=n7542
XU9708 INV1S $PINS O=n7543 I=Buffer/data_buffer[335]
XU9709 MXL2HS $PINS OB=n1374 S=FE_OFN289_FE_DBTN1_n7298 A=n7542 B=n7543
XU9710 MXL2HS $PINS OB=n1366 S=FE_OFN164_FE_DBTN1_n7298 A=n7543 B=n7545
XU9711 MXL2HS $PINS OB=n1358 S=FE_OFN227_FE_DBTN1_n7298 A=n7545 B=n7546
XU9712 MXL2HS $PINS OB=n1350 S=FE_OFN187_FE_DBTN1_n7298 A=n7546 B=n7547
XU9713 MXL2HS $PINS OB=n1342 S=FE_OFN111_FE_DBTN1_n7298 A=n7547 B=n7548
XU9714 MXL2HS $PINS OB=n1334 S=FE_OFN4_FE_DBTN1_n7298 A=n7548 B=n7549
XU9715 MXL2HS $PINS OB=n1326 S=FE_OFN20_FE_DBTN1_n7298 A=n7549 B=n7550
XU9716 MXL2HS $PINS OB=n1318 S=FE_OFN9_FE_DBTN1_n7298 A=n7550 B=n7552
XU9717 MXL2HS $PINS OB=n1310 S=FE_OFN83_FE_DBTN1_n7298 A=n7552 B=n7553
XU9718 MXL2HS $PINS OB=n1302 S=FE_OFN247_FE_DBTN1_n7298 A=n7553 B=n7554
XU9719 MXL2HS $PINS OB=n1294 S=FE_OFN45_FE_DBTN1_n7298 A=n7554 B=n7555
XU9720 INV1S $PINS O=n7556 I=Buffer/data_buffer[423]
XU9721 MXL2HS $PINS OB=n1286 S=FE_OFN132_FE_DBTN1_n7298 A=n7555 B=n7556
XU9722 INV1S $PINS O=n7557 I=Buffer/data_buffer[431]
XU9723 MXL2HS $PINS OB=n1278 S=FE_OFN132_FE_DBTN1_n7298 A=n7556 B=n7557
XU9724 INV1S $PINS O=n7559 I=Buffer/data_buffer[439]
XU9725 MXL2HS $PINS OB=n1270 S=FE_OFN25_FE_DBTN1_n7298 A=n7557 B=n7559
XU9726 INV1S $PINS O=n7560 I=Buffer/data_buffer[447]
XU9727 MXL2HS $PINS OB=n1262 S=FE_OFN48_FE_DBTN1_n7298 A=n7559 B=n7560
XU9728 INV1S $PINS O=n7561 I=Buffer/data_buffer[455]
XU9729 MXL2HS $PINS OB=n1254 S=FE_OFN136_FE_DBTN1_n7298 A=n7560 B=n7561
XU9730 INV1S $PINS O=n7562 I=Buffer/data_buffer[463]
XU9731 MXL2HS $PINS OB=n1246 S=FE_OFN89_FE_DBTN1_n7298 A=n7561 B=n7562
XU9732 INV1S $PINS O=n7563 I=Buffer/data_buffer[471]
XU9733 MXL2HS $PINS OB=n1238 S=FE_OFN89_FE_DBTN1_n7298 A=n7562 B=n7563
XU9734 INV1S $PINS O=n7564 I=Buffer/data_buffer[479]
XU9735 MXL2HS $PINS OB=n1230 S=FE_OFN138_FE_DBTN1_n7298 A=n7563 B=n7564
XU9736 INV1S $PINS O=n7566 I=Buffer/data_buffer[487]
XU9737 MXL2HS $PINS OB=n1222 S=FE_OFN197_FE_DBTN1_n7298 A=n7564 B=n7566
XU9738 INV1S $PINS O=n7567 I=Buffer/data_buffer[495]
XU9739 MXL2HS $PINS OB=n1214 S=FE_OFN197_FE_DBTN1_n7298 A=n7566 B=n7567
XU9740 INV1S $PINS O=n7568 I=Buffer/data_buffer[503]
XU9741 MXL2HS $PINS OB=n1206 S=FE_OFN197_FE_DBTN1_n7298 A=n7567 B=n7568
XU9742 INV1S $PINS O=n7569 I=Buffer/data_buffer[511]
XU9743 MXL2HS $PINS OB=n1198 S=FE_OFN309_FE_DBTN1_n7298 A=n7568 B=n7569
XU9744 INV1S $PINS O=n7570 I=Buffer/data_buffer[519]
XU9745 MXL2HS $PINS OB=n1190 S=FE_OFN309_FE_DBTN1_n7298 A=n7569 B=n7570
XU9746 INV1S $PINS O=n7571 I=Buffer/data_buffer[527]
XU9747 MXL2HS $PINS OB=n1182 S=FE_OFN307_FE_DBTN1_n7298 A=n7570 B=n7571
XU9748 MXL2HS $PINS OB=n1174 S=FE_OFN209_FE_DBTN1_n7298 A=n7571 B=n7573
XU9749 MXL2HS $PINS OB=n1166 S=FE_OFN151_FE_DBTN1_n7298 A=n7573 B=n7574
XU9750 MXL2HS $PINS OB=n1158 S=FE_OFN116_FE_DBTN1_n7298 A=n7574 B=n7575
XU9751 MXL2HS $PINS OB=n1150 S=FE_OFN34_FE_DBTN1_n7298 A=n7575 B=n7576
XU9752 MXL2HS $PINS OB=n1142 S=FE_OFN173_FE_DBTN1_n7298 A=n7576 B=n7577
XU9753 MXL2HS $PINS OB=n1134 S=FE_OFN180_FE_DBTN1_n7298 A=n7577 B=n7578
XU9754 INV1S $PINS O=n7580 I=Buffer/data_buffer[583]
XU9755 MXL2HS $PINS OB=n1126 S=FE_OFN181_FE_DBTN1_n7298 A=n7578 B=n7580
XU9756 INV1S $PINS O=n7582 I=Buffer/data_buffer[591]
XU9757 MXL2HS $PINS OB=n1118 S=FE_OFN238_FE_DBTN1_n7298 A=n7580 B=n7582
XU9758 INV1S $PINS O=n7583 I=Buffer/data_buffer[599]
XU9759 MXL2HS $PINS OB=n1110 S=FE_OFN236_FE_DBTN1_n7298 A=n7582 B=n7583
XU9760 INV1S $PINS O=n7584 I=Buffer/data_buffer[607]
XU9761 MXL2HS $PINS OB=n1102 S=FE_OFN236_FE_DBTN1_n7298 A=n7583 B=n7584
XU9762 INV1S $PINS O=n7585 I=Buffer/data_buffer[615]
XU9763 MXL2HS $PINS OB=n1094 S=FE_OFN175_FE_DBTN1_n7298 A=n7584 B=n7585
XU9764 INV1S $PINS O=n7586 I=Buffer/data_buffer[623]
XU9765 MXL2HS $PINS OB=n1086 S=FE_OFN175_FE_DBTN1_n7298 A=n7585 B=n7586
XU9766 INV1S $PINS O=n7588 I=Buffer/data_buffer[631]
XU9767 MXL2HS $PINS OB=n1078 S=FE_OFN119_FE_DBTN1_n7298 A=n7586 B=n7588
XU9768 INV1S $PINS O=n7589 I=Buffer/data_buffer[639]
XU9769 MXL2HS $PINS OB=n1070 S=FE_OFN71_FE_DBTN1_n7298 A=n7588 B=n7589
XU9770 INV1S $PINS O=n7590 I=Buffer/data_buffer[647]
XU9771 MXL2HS $PINS OB=n1062 S=FE_OFN35_FE_DBTN1_n7298 A=n7589 B=n7590
XU9772 INV1S $PINS O=n7591 I=Buffer/data_buffer[655]
XU9773 MXL2HS $PINS OB=n1054 S=FE_OFN15_FE_DBTN1_n7298 A=n7590 B=n7591
XU9774 INV1S $PINS O=n7592 I=Buffer/data_buffer[663]
XU9775 MXL2HS $PINS OB=n1046 S=FE_OFN282_FE_DBTN1_n7298 A=n7591 B=n7592
XU9776 INV1S $PINS O=n7594 I=Buffer/data_buffer[671]
XU9777 MXL2HS $PINS OB=n1038 S=FE_OFN282_FE_DBTN1_n7298 A=n7592 B=n7594
XU9778 INV1S $PINS O=n7595 I=Buffer/data_buffer[679]
XU9779 MXL2HS $PINS OB=n1030 S=FE_OFN230_FE_DBTN1_n7298 A=n7594 B=n7595
XU9780 INV1S $PINS O=n7596 I=Buffer/data_buffer[687]
XU9781 MXL2HS $PINS OB=n1022 S=FE_OFN281_FE_DBTN1_n7298 A=n7595 B=n7596
XU9782 INV1S $PINS O=n7597 I=Buffer/data_buffer[695]
XU9783 MXL2HS $PINS OB=n1014 S=FE_OFN281_FE_DBTN1_n7298 A=n7596 B=n7597
XU9784 INV1S $PINS O=n7598 I=Buffer/data_buffer[703]
XU9785 MXL2HS $PINS OB=n1006 S=FE_OFN281_FE_DBTN1_n7298 A=n7597 B=n7598
XU9786 INV1S $PINS O=n7599 I=Buffer/data_buffer[711]
XU9787 MXL2HS $PINS OB=n998 S=FE_OFN281_FE_DBTN1_n7298 A=n7598 B=n7599
XU9788 INV1S $PINS O=n7601 I=Buffer/data_buffer[719]
XU9789 MXL2HS $PINS OB=n990 S=FE_OFN277_FE_DBTN1_n7298 A=n7599 B=n7601
XU9790 INV1S $PINS O=n7602 I=Buffer/data_buffer[727]
XU9791 MXL2HS $PINS OB=n982 S=FE_OFN277_FE_DBTN1_n7298 A=n7601 B=n7602
XU9792 INV1S $PINS O=n7603 I=Buffer/data_buffer[735]
XU9793 MXL2HS $PINS OB=n974 S=FE_OFN276_FE_DBTN1_n7298 A=n7602 B=n7603
XU9794 INV1S $PINS O=n7604 I=Buffer/data_buffer[743]
XU9795 MXL2HS $PINS OB=n966 S=FE_OFN216_FE_DBTN1_n7298 A=n7603 B=n7604
XU9796 INV1S $PINS O=n7605 I=Buffer/data_buffer[751]
XU9797 MXL2HS $PINS OB=n958 S=FE_OFN312_FE_DBTN1_n7298 A=n7604 B=n7605
XU9798 INV1S $PINS O=n7606 I=Buffer/data_buffer[759]
XU9799 MXL2HS $PINS OB=n950 S=FE_OFN310_FE_DBTN1_n7298 A=n7605 B=n7606
XU9800 INV1S $PINS O=n7608 I=Buffer/data_buffer[767]
XU9801 MXL2HS $PINS OB=n942 S=FE_OFN308_FE_DBTN1_n7298 A=n7606 B=n7608
XU9802 INV1S $PINS O=n7609 I=Buffer/data_buffer[775]
XU9803 MXL2HS $PINS OB=n934 S=FE_OFN153_FE_DBTN1_n7298 A=n7608 B=n7609
XU9804 INV1S $PINS O=n7610 I=Buffer/data_buffer[783]
XU9805 MXL2HS $PINS OB=n926 S=FE_OFN289_FE_DBTN1_n7298 A=n7609 B=n7610
XU9806 MXL2HS $PINS OB=n918 S=FE_OFN164_FE_DBTN1_n7298 A=n7610 B=n7611
XU9807 MXL2HS $PINS OB=n910 S=FE_OFN245_FE_DBTN1_n7298 A=n7611 B=n7612
XU9808 MXL2HS $PINS OB=n902 S=FE_OFN244_FE_DBTN1_n7298 A=n7612 B=n7613
XU9809 MXL2HS $PINS OB=n894 S=FE_OFN65_FE_DBTN1_n7298 A=n7613 B=n7615
XU9810 MXL2HS $PINS OB=n886 S=FE_OFN30_FE_DBTN1_n7298 A=n7615 B=n7616
XU9811 MXL2HS $PINS OB=n878 S=FE_OFN30_FE_DBTN1_n7298 A=n7616 B=n7617
XU9812 INV1S $PINS O=n7618 I=Buffer/data_buffer[839]
XU9813 MXL2HS $PINS OB=n870 S=FE_OFN42_FE_DBTN1_n7298 A=n7617 B=n7618
XU9814 INV1S $PINS O=n7619 I=Buffer/data_buffer[847]
XU9815 MXL2HS $PINS OB=n862 S=FE_OFN83_FE_DBTN1_n7298 A=n7618 B=n7619
XU9816 INV1S $PINS O=n7620 I=Buffer/data_buffer[855]
XU9817 MXL2HS $PINS OB=n854 S=FE_OFN132_FE_DBTN1_n7298 A=n7619 B=n7620
XU9818 INV1S $PINS O=n7622 I=Buffer/data_buffer[863]
XU9819 MXL2HS $PINS OB=n846 S=FE_OFN333_FE_DBTN1_n7298 A=n7620 B=n7622
XU9820 INV1S $PINS O=n7624 I=Buffer/data_buffer[871]
XU9821 MXL2HS $PINS OB=n838 S=FE_OFN327_FE_DBTN1_n7298 A=n7622 B=n7624
XU9822 INV1S $PINS O=n7625 I=Buffer/data_buffer[879]
XU9823 MXL2HS $PINS OB=n830 S=FE_OFN318_FE_DBTN1_n7298 A=n7624 B=n7625
XU9824 INV1S $PINS O=n7626 I=Buffer/data_buffer[887]
XU9825 MXL2HS $PINS OB=n822 S=FE_OFN318_FE_DBTN1_n7298 A=n7625 B=n7626
XU9826 INV1S $PINS O=n7627 I=Buffer/data_buffer[895]
XU9827 MXL2HS $PINS OB=n814 S=FE_OFN317_FE_DBTN1_n7298 A=n7626 B=n7627
XU9828 INV1S $PINS O=n7628 I=Buffer/data_buffer[903]
XU9829 MXL2HS $PINS OB=n806 S=FE_OFN317_FE_DBTN1_n7298 A=n7627 B=n7628
XU9830 INV1S $PINS O=n7630 I=Buffer/data_buffer[911]
XU9831 MXL2HS $PINS OB=n798 S=FE_OFN317_FE_DBTN1_n7298 A=n7628 B=n7630
XU9832 INV1S $PINS O=n7631 I=Buffer/data_buffer[919]
XU9833 MXL2HS $PINS OB=n790 S=FE_OFN26_FE_DBTN1_n7298 A=n7630 B=n7631
XU9834 INV1S $PINS O=n7632 I=Buffer/data_buffer[927]
XU9835 MXL2HS $PINS OB=n782 S=FE_OFN50_FE_DBTN1_n7298 A=n7631 B=n7632
XU9836 INV1S $PINS O=n7633 I=Buffer/data_buffer[935]
XU9837 MXL2HS $PINS OB=n774 S=FE_OFN50_FE_DBTN1_n7298 A=n7632 B=n7633
XU9838 INV1S $PINS O=n7634 I=Buffer/data_buffer[943]
XU9839 MXL2HS $PINS OB=n766 S=FE_OFN90_FE_DBTN1_n7298 A=n7633 B=n7634
XU9840 INV1S $PINS O=n7635 I=Buffer/data_buffer[951]
XU9841 MXL2HS $PINS OB=n758 S=FE_OFN51_FE_DBTN1_n7298 A=n7634 B=n7635
XU9842 INV1S $PINS O=n7637 I=Buffer/data_buffer[959]
XU9843 MXL2HS $PINS OB=n750 S=FE_OFN90_FE_DBTN1_n7298 A=n7635 B=n7637
XU9844 INV1S $PINS O=n7638 I=Buffer/data_buffer[967]
XU9845 MXL2HS $PINS OB=n742 S=FE_OFN90_FE_DBTN1_n7298 A=n7637 B=n7638
XU9846 INV1S $PINS O=n7639 I=Buffer/data_buffer[975]
XU9847 MXL2HS $PINS OB=n734 S=FE_OFN95_FE_DBTN1_n7298 A=n7638 B=n7639
XU9848 INV1S $PINS O=n7640 I=Buffer/data_buffer[983]
XU9849 MXL2HS $PINS OB=n726 S=FE_OFN95_FE_DBTN1_n7298 A=n7639 B=n7640
XU9850 INV1S $PINS O=n7641 I=Buffer/data_buffer[991]
XU9851 MXL2HS $PINS OB=n718 S=FE_OFN96_FE_DBTN1_n7298 A=n7640 B=n7641
XU9852 INV1S $PINS O=n7642 I=Buffer/data_buffer[999]
XU9853 MXL2HS $PINS OB=n710 S=FE_OFN96_FE_DBTN1_n7298 A=n7641 B=n7642
XU9854 INV1S $PINS O=n7644 I=Buffer/data_buffer[1007]
XU9855 MXL2HS $PINS OB=n702 S=FE_OFN146_FE_DBTN1_n7298 A=n7642 B=n7644
XU9856 INV1S $PINS O=n7645 I=Buffer/data_buffer[1015]
XU9857 MXL2HS $PINS OB=n694 S=FE_OFN146_FE_DBTN1_n7298 A=n7644 B=n7645
XU9858 INV1S $PINS O=n7646 I=Buffer/data_buffer[1023]
XU9859 MXL2HS $PINS OB=n686 S=FE_OFN146_FE_DBTN1_n7298 A=n7645 B=n7646
XU9860 INV1S $PINS O=n7647 I=Buffer/data_buffer[1031]
XU9861 MXL2HS $PINS OB=n678 S=FE_OFN146_FE_DBTN1_n7298 A=n7646 B=n7647
XU9862 INV1S $PINS O=n7648 I=Buffer/data_buffer[1039]
XU9863 MXL2HS $PINS OB=n670 S=FE_OFN146_FE_DBTN1_n7298 A=n7647 B=n7648
XU9864 INV1S $PINS O=n7649 I=Buffer/data_buffer[1047]
XU9865 MXL2HS $PINS OB=n662 S=FE_OFN143_FE_DBTN1_n7298 A=n7648 B=n7649
XU9866 INV1S $PINS O=n7651 I=Buffer/data_buffer[1055]
XU9867 MXL2HS $PINS OB=n654 S=FE_OFN339_FE_DBTN1_n7298 A=n7649 B=n7651
XU9868 INV1S $PINS O=n7652 I=Buffer/data_buffer[1063]
XU9869 MXL2HS $PINS OB=n646 S=FE_OFN339_FE_DBTN1_n7298 A=n7651 B=n7652
XU9870 INV1S $PINS O=n7653 I=Buffer/data_buffer[1071]
XU9871 MXL2HS $PINS OB=n638 S=FE_OFN339_FE_DBTN1_n7298 A=n7652 B=n7653
XU9872 INV1S $PINS O=n7654 I=Buffer/data_buffer[1079]
XU9873 MXL2HS $PINS OB=n630 S=FE_OFN334_FE_DBTN1_n7298 A=n7653 B=n7654
XU9874 INV1S $PINS O=n7655 I=Buffer/data_buffer[1087]
XU9875 MXL2HS $PINS OB=n622 S=FE_OFN334_FE_DBTN1_n7298 A=n7654 B=n7655
XU9876 INV1S $PINS O=n7656 I=Buffer/data_buffer[1095]
XU9877 MXL2HS $PINS OB=n614 S=FE_OFN335_FE_DBTN1_n7298 A=n7655 B=n7656
XU9878 INV1S $PINS O=n7658 I=Buffer/data_buffer[1103]
XU9879 MXL2HS $PINS OB=n606 S=FE_OFN335_FE_DBTN1_n7298 A=n7656 B=n7658
XU9880 INV1S $PINS O=n7659 I=Buffer/data_buffer[1111]
XU9881 MXL2HS $PINS OB=n598 S=FE_OFN320_FE_DBTN1_n7298 A=n7658 B=n7659
XU9882 INV1S $PINS O=n7660 I=Buffer/data_buffer[1119]
XU9883 MXL2HS $PINS OB=n590 S=FE_OFN201_FE_DBTN1_n7298 A=n7659 B=n7660
XU9884 INV1S $PINS O=n7661 I=Buffer/data_buffer[1127]
XU9885 MXL2HS $PINS OB=n582 S=FE_OFN201_FE_DBTN1_n7298 A=n7660 B=n7661
XU9886 INV1S $PINS O=n7662 I=Buffer/data_buffer[1135]
XU9887 MXL2HS $PINS OB=n574 S=FE_OFN201_FE_DBTN1_n7298 A=n7661 B=n7662
XU9888 INV1S $PINS O=n7663 I=Buffer/data_buffer[1143]
XU9889 MXL2HS $PINS OB=n566 S=FE_OFN141_FE_DBTN1_n7298 A=n7662 B=n7663
XU9890 INV1S $PINS O=n7665 I=Buffer/data_buffer[1151]
XU9891 MXL2HS $PINS OB=n558 S=FE_OFN141_FE_DBTN1_n7298 A=n7663 B=n7665
XU9892 INV1S $PINS O=n7667 I=Buffer/data_buffer[1159]
XU9893 MXL2HS $PINS OB=n550 S=FE_OFN200_FE_DBTN1_n7298 A=n7665 B=n7667
XU9894 INV1S $PINS O=n7668 I=Buffer/data_buffer[1167]
XU9895 MXL2HS $PINS OB=n542 S=FE_OFN200_FE_DBTN1_n7298 A=n7667 B=n7668
XU9896 INV1S $PINS O=n7669 I=Buffer/data_buffer[1175]
XU9897 MXL2HS $PINS OB=n534 S=FE_OFN338_FE_DBTN1_n7298 A=n7668 B=n7669
XU9898 INV1S $PINS O=n7670 I=Buffer/data_buffer[1183]
XU9899 MXL2HS $PINS OB=n526 S=FE_OFN337_FE_DBTN1_n7298 A=n7669 B=n7670
XU9900 INV1S $PINS O=n7671 I=Buffer/data_buffer[1191]
XU9901 MXL2HS $PINS OB=n518 S=FE_OFN215_FE_DBTN1_n7298 A=n7670 B=n7671
XU9902 INV1S $PINS O=n7673 I=Buffer/data_buffer[1199]
XU9903 MXL2HS $PINS OB=n510 S=FE_OFN311_FE_DBTN1_n7298 A=n7671 B=n7673
XU9904 MXL2HS $PINS OB=n502 S=FE_OFN106_FE_DBTN1_n7298 A=n7673 B=n8823
XU9905 INV1S $PINS O=n7675 I=weight_0_w[5]
XU9906 ND2 $PINS O=n7674 I1=i_data[5] I2=FE_OFN241_FE_DBTN1_n7298
XU9907 OAI12HS $PINS O=n444 A1=n7674 B1=FE_OFN241_FE_DBTN1_n7298 B2=n7675
XU9908 INV1S $PINS O=n7676 I=weight_0_w[13]
XU9909 MXL2HS $PINS OB=n443 S=FE_OFN240_FE_DBTN1_n7298 A=n7676 B=n7675
XU9910 INV1S $PINS O=n7677 I=weight_0_w[21]
XU9911 MXL2HS $PINS OB=n442 S=FE_OFN240_FE_DBTN1_n7298 A=n7677 B=n7676
XU9912 INV1S $PINS O=n7678 I=weight_1_w[5]
XU9913 MXL2HS $PINS OB=n441 S=FE_OFN113_FE_DBTN1_n7298 A=n7678 B=n7677
XU9914 INV1S $PINS O=n7679 I=weight_1_w[13]
XU9915 MXL2HS $PINS OB=n440 S=FE_OFN166_FE_DBTN1_n7298 A=n7679 B=n7678
XU9916 INV1S $PINS O=n7681 I=weight_1_w[21]
XU9917 MXL2HS $PINS OB=n439 S=FE_OFN166_FE_DBTN1_n7298 A=n7681 B=n7679
XU9918 INV1S $PINS O=n8895 I=weight_2_w[5]
XU9919 MXL2HS $PINS OB=n438 S=FE_OFN226_FE_DBTN1_n7298 A=n8895 B=n7681
XU9920 INV1S $PINS O=n7684 I=Buffer/data_buffer[2]
XU9921 ND2 $PINS O=n7682 I1=i_data[2] I2=FE_OFN1243_n7298
XU9922 OAI12HS $PINS O=n1707 A1=n7682 B1=n7298 B2=n7684
XU9923 INV1S $PINS O=n7685 I=Buffer/data_buffer[10]
XU9924 MXL2HS $PINS OB=n1699 S=FE_OFN76_FE_DBTN1_n7298 A=n7684 B=n7685
XU9925 INV1S $PINS O=n7686 I=Buffer/data_buffer[18]
XU9926 MXL2HS $PINS OB=n1691 S=FE_OFN38_FE_DBTN1_n7298 A=n7685 B=n7686
XU9927 INV1S $PINS O=n7687 I=Buffer/data_buffer[26]
XU9928 MXL2HS $PINS OB=n1683 S=FE_OFN38_FE_DBTN1_n7298 A=n7686 B=n7687
XU9929 MXL2HS $PINS OB=n1675 S=FE_OFN19_FE_DBTN1_n7298 A=n7687 B=n7688
XU9930 MXL2HS $PINS OB=n1667 S=FE_OFN7_FE_DBTN1_n7298 A=n7688 B=n7690
XU9931 MXL2HS $PINS OB=n1659 S=FE_OFN78_FE_DBTN1_n7298 A=n7690 B=n7691
XU9932 MXL2HS $PINS OB=n1651 S=FE_OFN83_FE_DBTN1_n7298 A=n7691 B=n7692
XU9933 MXL2HS $PINS OB=n1643 S=FE_OFN191_FE_DBTN1_n7298 A=n7692 B=n7694
XU9934 MXL2HS $PINS OB=n1635 S=FE_OFN24_FE_DBTN1_n7298 A=n7694 B=n7695
XU9935 INV1S $PINS O=n7697 I=Buffer/data_buffer[82]
XU9936 MXL2HS $PINS OB=n1627 S=FE_OFN85_FE_DBTN1_n7298 A=n7695 B=n7697
XU9937 INV1S $PINS O=n7698 I=Buffer/data_buffer[90]
XU9938 MXL2HS $PINS OB=n1619 S=FE_OFN248_FE_DBTN1_n7298 A=n7697 B=n7698
XU9939 INV1S $PINS O=n7699 I=Buffer/data_buffer[98]
XU9940 MXL2HS $PINS OB=n1611 S=FE_OFN129_FE_DBTN1_n7298 A=n7698 B=n7699
XU9941 INV1S $PINS O=n7700 I=Buffer/data_buffer[106]
XU9942 MXL2HS $PINS OB=n1603 S=FE_OFN129_FE_DBTN1_n7298 A=n7699 B=n7700
XU9943 MXL2HS $PINS OB=n1595 S=FE_OFN242_FE_DBTN1_n7298 A=n7700 B=n7701
XU9944 MXL2HS $PINS OB=n1587 S=FE_OFN245_FE_DBTN1_n7298 A=n7701 B=n7702
XU9945 MXL2HS $PINS OB=n1579 S=FE_OFN244_FE_DBTN1_n7298 A=n7702 B=n7703
XU9946 MXL2HS $PINS OB=n1571 S=FE_OFN32_FE_DBTN1_n7298 A=n7703 B=n7704
XU9947 MXL2HS $PINS OB=n1563 S=FE_OFN14_FE_DBTN1_n7298 A=n7704 B=n7705
XU9948 MXL2HS $PINS OB=n1555 S=FE_OFN20_FE_DBTN1_n7298 A=n7705 B=n7706
XU9949 MXL2HS $PINS OB=n1547 S=FE_OFN23_FE_DBTN1_n7298 A=n7706 B=n7708
XU9950 MXL2HS $PINS OB=n1539 S=FE_OFN82_FE_DBTN1_n7298 A=n7708 B=n7709
XU9951 MXL2HS $PINS OB=n1531 S=FE_OFN24_FE_DBTN1_n7298 A=n7709 B=n7710
XU9952 MXL2HS $PINS OB=n1523 S=FE_OFN45_FE_DBTN1_n7298 A=n7710 B=n7711
XU9953 MXL2HS $PINS OB=n1515 S=FE_OFN316_FE_DBTN1_n7298 A=n7711 B=n7712
XU9954 MXL2HS $PINS OB=n1507 S=FE_OFN210_FE_DBTN1_n7298 A=n7712 B=n7713
XU9955 MXL2HS $PINS OB=n1499 S=FE_OFN16_FE_DBTN1_n7298 A=n7713 B=n7715
XU9956 MXL2HS $PINS OB=n1491 S=FE_OFN16_FE_DBTN1_n7298 A=n7715 B=n7716
XU9957 MXL2HS $PINS OB=n1483 S=FE_OFN118_FE_DBTN1_n7298 A=n7716 B=n7717
XU9958 MXL2HS $PINS OB=n1475 S=FE_OFN37_FE_DBTN1_n7298 A=n7717 B=n7718
XU9959 INV1S $PINS O=n7719 I=Buffer/data_buffer[242]
XU9960 MXL2HS $PINS OB=n1467 S=FE_OFN18_FE_DBTN1_n7298 A=n7718 B=n7719
XU9961 INV1S $PINS O=n7720 I=Buffer/data_buffer[250]
XU9962 MXL2HS $PINS OB=n1459 S=FE_OFN18_FE_DBTN1_n7298 A=n7719 B=n7720
XU9963 INV1S $PINS O=n7722 I=Buffer/data_buffer[258]
XU9964 MXL2HS $PINS OB=n1451 S=FE_OFN286_FE_DBTN1_n7298 A=n7720 B=n7722
XU9965 INV1S $PINS O=n7723 I=Buffer/data_buffer[266]
XU9966 MXL2HS $PINS OB=n1443 S=FE_OFN223_FE_DBTN1_n7298 A=n7722 B=n7723
XU9967 INV1S $PINS O=n7724 I=Buffer/data_buffer[274]
XU9968 MXL2HS $PINS OB=n1435 S=FE_OFN223_FE_DBTN1_n7298 A=n7723 B=n7724
XU9969 INV1S $PINS O=n7725 I=Buffer/data_buffer[282]
XU9970 MXL2HS $PINS OB=n1427 S=FE_OFN161_FE_DBTN1_n7298 A=n7724 B=n7725
XU9971 INV1S $PINS O=n7726 I=Buffer/data_buffer[290]
XU9972 MXL2HS $PINS OB=n1419 S=FE_OFN107_FE_DBTN1_n7298 A=n7725 B=n7726
XU9973 INV1S $PINS O=n7727 I=Buffer/data_buffer[298]
XU9974 MXL2HS $PINS OB=n1411 S=FE_OFN323_FE_DBTN1_n7298 A=n7726 B=n7727
XU9975 INV1S $PINS O=n7729 I=Buffer/data_buffer[306]
XU9976 MXL2HS $PINS OB=n1403 S=FE_OFN209_FE_DBTN1_n7298 A=n7727 B=n7729
XU9977 INV1S $PINS O=n7730 I=Buffer/data_buffer[314]
XU9978 MXL2HS $PINS OB=n1395 S=FE_OFN98_FE_DBTN1_n7298 A=n7729 B=n7730
XU9979 INV1S $PINS O=n7731 I=Buffer/data_buffer[322]
XU9980 MXL2HS $PINS OB=n1387 S=FE_OFN57_FE_DBTN1_n7298 A=n7730 B=n7731
XU9981 INV1S $PINS O=n7732 I=Buffer/data_buffer[330]
XU9982 MXL2HS $PINS OB=n1379 S=FE_OFN314_FE_DBTN1_n7298 A=n7731 B=n7732
XU9983 MXL2HS $PINS OB=n1371 S=FE_OFN164_FE_DBTN1_n7298 A=n7732 B=n7733
XU9984 MXL2HS $PINS OB=n1363 S=FE_OFN227_FE_DBTN1_n7298 A=n7733 B=n7734
XU9985 MXL2HS $PINS OB=n1355 S=FE_OFN244_FE_DBTN1_n7298 A=n7734 B=n7736
XU9986 MXL2HS $PINS OB=n1347 S=FE_OFN112_FE_DBTN1_n7298 A=n7736 B=n7737
XU9987 MXL2HS $PINS OB=n1339 S=FE_OFN14_FE_DBTN1_n7298 A=n7737 B=n7738
XU9988 MXL2HS $PINS OB=n1331 S=FE_OFN20_FE_DBTN1_n7298 A=n7738 B=n7739
XU9989 MXL2HS $PINS OB=n1323 S=FE_OFN9_FE_DBTN1_n7298 A=n7739 B=n7740
XU9990 MXL2HS $PINS OB=n1315 S=FE_OFN83_FE_DBTN1_n7298 A=n7740 B=n7741
XU9991 MXL2HS $PINS OB=n1307 S=FE_OFN247_FE_DBTN1_n7298 A=n7741 B=n7743
XU9992 MXL2HS $PINS OB=n1299 S=FE_OFN45_FE_DBTN1_n7298 A=n7743 B=n7745
XU9993 INV1S $PINS O=n7746 I=Buffer/data_buffer[418]
XU9994 MXL2HS $PINS OB=n1291 S=FE_OFN25_FE_DBTN1_n7298 A=n7745 B=n7746
XU9995 INV1S $PINS O=n7747 I=Buffer/data_buffer[426]
XU9996 MXL2HS $PINS OB=n1283 S=FE_OFN25_FE_DBTN1_n7298 A=n7746 B=n7747
XU9997 INV1S $PINS O=n7748 I=Buffer/data_buffer[434]
XU9998 MXL2HS $PINS OB=n1275 S=FE_OFN136_FE_DBTN1_n7298 A=n7747 B=n7748
XU9999 INV1S $PINS O=n7749 I=Buffer/data_buffer[442]
XU10000 MXL2HS $PINS OB=n1267 S=FE_OFN136_FE_DBTN1_n7298 A=n7748 B=n7749
XU10001 INV1S $PINS O=n7751 I=Buffer/data_buffer[450]
XU10002 MXL2HS $PINS OB=n1259 S=FE_OFN136_FE_DBTN1_n7298 A=n7749 B=n7751
XU10003 INV1S $PINS O=n7752 I=Buffer/data_buffer[458]
XU10004 MXL2HS $PINS OB=n1251 S=FE_OFN137_FE_DBTN1_n7298 A=n7751 B=n7752
XU10005 INV1S $PINS O=n7753 I=Buffer/data_buffer[466]
XU10006 MXL2HS $PINS OB=n1243 S=FE_OFN137_FE_DBTN1_n7298 A=n7752 B=n7753
XU10007 INV1S $PINS O=n7754 I=Buffer/data_buffer[474]
XU10008 MXL2HS $PINS OB=n1235 S=FE_OFN137_FE_DBTN1_n7298 A=n7753 B=n7754
XU10009 INV1S $PINS O=n7755 I=Buffer/data_buffer[482]
XU10010 MXL2HS $PINS OB=n1227 S=FE_OFN196_FE_DBTN1_n7298 A=n7754 B=n7755
XU10011 INV1S $PINS O=n7756 I=Buffer/data_buffer[490]
XU10012 MXL2HS $PINS OB=n1219 S=FE_OFN196_FE_DBTN1_n7298 A=n7755 B=n7756
XU10013 INV1S $PINS O=n7758 I=Buffer/data_buffer[498]
XU10014 MXL2HS $PINS OB=n1211 S=FE_OFN254_FE_DBTN1_n7298 A=n7756 B=n7758
XU10015 INV1S $PINS O=n7759 I=Buffer/data_buffer[506]
XU10016 MXL2HS $PINS OB=n1203 S=FE_OFN59_FE_DBTN1_n7298 A=n7758 B=n7759
XU10017 INV1S $PINS O=n7760 I=Buffer/data_buffer[514]
XU10018 MXL2HS $PINS OB=n1195 S=FE_OFN309_FE_DBTN1_n7298 A=n7759 B=n7760
XU10019 INV1S $PINS O=n7761 I=Buffer/data_buffer[522]
XU10020 MXL2HS $PINS OB=n1187 S=FE_OFN307_FE_DBTN1_n7298 A=n7760 B=n7761
XU10021 MXL2HS $PINS OB=n1179 S=FE_OFN306_FE_DBTN1_n7298 A=n7761 B=n7762
XU10022 MXL2HS $PINS OB=n1171 S=FE_OFN210_FE_DBTN1_n7298 A=n7762 B=n7763
XU10023 MXL2HS $PINS OB=n1163 S=FE_OFN322_FE_DBTN1_n7298 A=n7763 B=n7765
XU10024 MXL2HS $PINS OB=n1155 S=FE_OFN68_FE_DBTN1_n7298 A=n7765 B=n7766
XU10025 MXL2HS $PINS OB=n1147 S=FE_OFN173_FE_DBTN1_n7298 A=n7766 B=n7767
XU10026 MXL2HS $PINS OB=n1139 S=FE_OFN75_FE_DBTN1_n7298 A=n7767 B=n7768
XU10027 INV1S $PINS O=n7769 I=Buffer/data_buffer[578]
XU10028 MXL2HS $PINS OB=n1131 S=FE_OFN124_FE_DBTN1_n7298 A=n7768 B=n7769
XU10029 INV1S $PINS O=n7770 I=Buffer/data_buffer[586]
XU10030 MXL2HS $PINS OB=n1123 S=FE_OFN238_FE_DBTN1_n7298 A=n7769 B=n7770
XU10031 INV1S $PINS O=n7772 I=Buffer/data_buffer[594]
XU10032 MXL2HS $PINS OB=n1115 S=FE_OFN236_FE_DBTN1_n7298 A=n7770 B=n7772
XU10033 INV1S $PINS O=n7773 I=Buffer/data_buffer[602]
XU10034 MXL2HS $PINS OB=n1107 S=FE_OFN235_FE_DBTN1_n7298 A=n7772 B=n7773
XU10035 INV1S $PINS O=n7774 I=Buffer/data_buffer[610]
XU10036 MXL2HS $PINS OB=n1099 S=FE_OFN178_FE_DBTN1_n7298 A=n7773 B=n7774
XU10037 INV1S $PINS O=n7775 I=Buffer/data_buffer[618]
XU10038 MXL2HS $PINS OB=n1091 S=FE_OFN121_FE_DBTN1_n7298 A=n7774 B=n7775
XU10039 INV1S $PINS O=n7776 I=Buffer/data_buffer[626]
XU10040 MXL2HS $PINS OB=n1083 S=FE_OFN121_FE_DBTN1_n7298 A=n7775 B=n7776
XU10041 INV1S $PINS O=n7777 I=Buffer/data_buffer[634]
XU10042 MXL2HS $PINS OB=n1075 S=FE_OFN71_FE_DBTN1_n7298 A=n7776 B=n7777
XU10043 INV1S $PINS O=n7779 I=Buffer/data_buffer[642]
XU10044 MXL2HS $PINS OB=n1067 S=FE_OFN120_FE_DBTN1_n7298 A=n7777 B=n7779
XU10045 INV1S $PINS O=n7781 I=Buffer/data_buffer[650]
XU10046 MXL2HS $PINS OB=n1059 S=FE_OFN120_FE_DBTN1_n7298 A=n7779 B=n7781
XU10047 INV1S $PINS O=n7782 I=Buffer/data_buffer[658]
XU10048 MXL2HS $PINS OB=n1051 S=FE_OFN230_FE_DBTN1_n7298 A=n7781 B=n7782
XU10049 INV1S $PINS O=n7783 I=Buffer/data_buffer[666]
XU10050 MXL2HS $PINS OB=n1043 S=FE_OFN230_FE_DBTN1_n7298 A=n7782 B=n7783
XU10051 INV1S $PINS O=n7784 I=Buffer/data_buffer[674]
XU10052 MXL2HS $PINS OB=n1035 S=FE_OFN230_FE_DBTN1_n7298 A=n7783 B=n7784
XU10053 INV1S $PINS O=n7785 I=Buffer/data_buffer[682]
XU10054 MXL2HS $PINS OB=n1027 S=FE_OFN170_FE_DBTN1_n7298 A=n7784 B=n7785
XU10055 INV1S $PINS O=n7787 I=Buffer/data_buffer[690]
XU10056 MXL2HS $PINS OB=n1019 S=FE_OFN167_FE_DBTN1_n7298 A=n7785 B=n7787
XU10057 INV1S $PINS O=n7788 I=Buffer/data_buffer[698]
XU10058 MXL2HS $PINS OB=n1011 S=FE_OFN167_FE_DBTN1_n7298 A=n7787 B=n7788
XU10059 INV1S $PINS O=n7789 I=Buffer/data_buffer[706]
XU10060 MXL2HS $PINS OB=n1003 S=FE_OFN167_FE_DBTN1_n7298 A=n7788 B=n7789
XU10061 INV1S $PINS O=n7790 I=Buffer/data_buffer[714]
XU10062 MXL2HS $PINS OB=n995 S=FE_OFN281_FE_DBTN1_n7298 A=n7789 B=n7790
XU10063 INV1S $PINS O=n7791 I=Buffer/data_buffer[722]
XU10064 MXL2HS $PINS OB=n987 S=FE_OFN105_FE_DBTN1_n7298 A=n7790 B=n7791
XU10065 INV1S $PINS O=n7793 I=Buffer/data_buffer[730]
XU10066 MXL2HS $PINS OB=n979 S=FE_OFN276_FE_DBTN1_n7298 A=n7791 B=n7793
XU10067 INV1S $PINS O=n7794 I=Buffer/data_buffer[738]
XU10068 MXL2HS $PINS OB=n971 S=FE_OFN61_FE_DBTN1_n7298 A=n7793 B=n7794
XU10069 INV1S $PINS O=n7795 I=Buffer/data_buffer[746]
XU10070 MXL2HS $PINS OB=n963 S=FE_OFN312_FE_DBTN1_n7298 A=n7794 B=n7795
XU10071 INV1S $PINS O=n7796 I=Buffer/data_buffer[754]
XU10072 MXL2HS $PINS OB=n955 S=FE_OFN310_FE_DBTN1_n7298 A=n7795 B=n7796
XU10073 INV1S $PINS O=n7797 I=Buffer/data_buffer[762]
XU10074 MXL2HS $PINS OB=n947 S=FE_OFN306_FE_DBTN1_n7298 A=n7796 B=n7797
XU10075 INV1S $PINS O=n7798 I=Buffer/data_buffer[770]
XU10076 MXL2HS $PINS OB=n939 S=FE_OFN308_FE_DBTN1_n7298 A=n7797 B=n7798
XU10077 INV1S $PINS O=n7800 I=Buffer/data_buffer[778]
XU10078 MXL2HS $PINS OB=n931 S=FE_OFN289_FE_DBTN1_n7298 A=n7798 B=n7800
XU10079 MXL2HS $PINS OB=n923 S=FE_OFN165_FE_DBTN1_n7298 A=n7800 B=n7801
XU10080 MXL2HS $PINS OB=n915 S=FE_OFN224_FE_DBTN1_n7298 A=n7801 B=n7802
XU10081 MXL2HS $PINS OB=n907 S=FE_OFN244_FE_DBTN1_n7298 A=n7802 B=n7803
XU10082 MXL2HS $PINS OB=n899 S=FE_OFN32_FE_DBTN1_n7298 A=n7803 B=n7804
XU10083 MXL2HS $PINS OB=n891 S=FE_OFN30_FE_DBTN1_n7298 A=n7804 B=n7805
XU10084 MXL2HS $PINS OB=n883 S=FE_OFN30_FE_DBTN1_n7298 A=n7805 B=n7807
XU10085 INV1S $PINS O=n7808 I=Buffer/data_buffer[834]
XU10086 MXL2HS $PINS OB=n875 S=FE_OFN43_FE_DBTN1_n7298 A=n7807 B=n7808
XU10087 INV1S $PINS O=n7809 I=Buffer/data_buffer[842]
XU10088 MXL2HS $PINS OB=n867 S=FE_OFN248_FE_DBTN1_n7298 A=n7808 B=n7809
XU10089 INV1S $PINS O=n7810 I=Buffer/data_buffer[850]
XU10090 MXL2HS $PINS OB=n859 S=FE_OFN46_FE_DBTN1_n7298 A=n7809 B=n7810
XU10091 INV1S $PINS O=n7811 I=Buffer/data_buffer[858]
XU10092 MXL2HS $PINS OB=n851 S=FE_OFN87_FE_DBTN1_n7298 A=n7810 B=n7811
XU10093 INV1S $PINS O=n7812 I=Buffer/data_buffer[866]
XU10094 MXL2HS $PINS OB=n843 S=FE_OFN134_FE_DBTN1_n7298 A=n7811 B=n7812
XU10095 INV1S $PINS O=n7814 I=Buffer/data_buffer[874]
XU10096 MXL2HS $PINS OB=n835 S=FE_OFN195_FE_DBTN1_n7298 A=n7812 B=n7814
XU10097 INV1S $PINS O=n7815 I=Buffer/data_buffer[882]
XU10098 MXL2HS $PINS OB=n827 S=FE_OFN195_FE_DBTN1_n7298 A=n7814 B=n7815
XU10099 INV1S $PINS O=n7816 I=Buffer/data_buffer[890]
XU10100 MXL2HS $PINS OB=n819 S=FE_OFN195_FE_DBTN1_n7298 A=n7815 B=n7816
XU10101 INV1S $PINS O=n7817 I=Buffer/data_buffer[898]
XU10102 MXL2HS $PINS OB=n811 S=FE_OFN260_FE_DBTN1_n7298 A=n7816 B=n7817
XU10103 INV1S $PINS O=n7818 I=Buffer/data_buffer[906]
XU10104 MXL2HS $PINS OB=n803 S=FE_OFN260_FE_DBTN1_n7298 A=n7817 B=n7818
XU10105 INV1S $PINS O=n7819 I=Buffer/data_buffer[914]
XU10106 MXL2HS $PINS OB=n795 S=FE_OFN91_FE_DBTN1_n7298 A=n7818 B=n7819
XU10107 INV1S $PINS O=n7821 I=Buffer/data_buffer[922]
XU10108 MXL2HS $PINS OB=n787 S=FE_OFN91_FE_DBTN1_n7298 A=n7819 B=n7821
XU10109 INV1S $PINS O=n7822 I=Buffer/data_buffer[930]
XU10110 MXL2HS $PINS OB=n779 S=FE_OFN91_FE_DBTN1_n7298 A=n7821 B=n7822
XU10111 INV1S $PINS O=n7823 I=Buffer/data_buffer[938]
XU10112 MXL2HS $PINS OB=n771 S=FE_OFN91_FE_DBTN1_n7298 A=n7822 B=n7823
XU10113 INV1S $PINS O=n7824 I=Buffer/data_buffer[946]
XU10114 MXL2HS $PINS OB=n763 S=FE_OFN139_FE_DBTN1_n7298 A=n7823 B=n7824
XU10115 INV1S $PINS O=n7825 I=Buffer/data_buffer[954]
XU10116 MXL2HS $PINS OB=n755 S=FE_OFN139_FE_DBTN1_n7298 A=n7824 B=n7825
XU10117 INV1S $PINS O=n7826 I=Buffer/data_buffer[962]
XU10118 MXL2HS $PINS OB=n747 S=FE_OFN139_FE_DBTN1_n7298 A=n7825 B=n7826
XU10119 INV1S $PINS O=n7828 I=Buffer/data_buffer[970]
XU10120 MXL2HS $PINS OB=n739 S=FE_OFN96_FE_DBTN1_n7298 A=n7826 B=n7828
XU10121 INV1S $PINS O=n7830 I=Buffer/data_buffer[978]
XU10122 MXL2HS $PINS OB=n731 S=FE_OFN147_FE_DBTN1_n7298 A=n7828 B=n7830
XU10123 INV1S $PINS O=n7831 I=Buffer/data_buffer[986]
XU10124 MXL2HS $PINS OB=n723 S=FE_OFN147_FE_DBTN1_n7298 A=n7830 B=n7831
XU10125 INV1S $PINS O=n7832 I=Buffer/data_buffer[994]
XU10126 MXL2HS $PINS OB=n715 S=FE_OFN266_FE_DBTN1_n7298 A=n7831 B=n7832
XU10127 INV1S $PINS O=n7833 I=Buffer/data_buffer[1002]
XU10128 MXL2HS $PINS OB=n707 S=FE_OFN267_FE_DBTN1_n7298 A=n7832 B=n7833
XU10129 INV1S $PINS O=n7834 I=Buffer/data_buffer[1010]
XU10130 MXL2HS $PINS OB=n699 S=FE_OFN203_FE_DBTN1_n7298 A=n7833 B=n7834
XU10131 INV1S $PINS O=n7836 I=Buffer/data_buffer[1018]
XU10132 MXL2HS $PINS OB=n691 S=FE_OFN203_FE_DBTN1_n7298 A=n7834 B=n7836
XU10133 INV1S $PINS O=n7838 I=Buffer/data_buffer[1026]
XU10134 MXL2HS $PINS OB=n683 S=FE_OFN204_FE_DBTN1_n7298 A=n7836 B=n7838
XU10135 INV1S $PINS O=n7839 I=Buffer/data_buffer[1034]
XU10136 MXL2HS $PINS OB=n675 S=FE_OFN204_FE_DBTN1_n7298 A=n7838 B=n7839
XU10137 INV1S $PINS O=n7840 I=Buffer/data_buffer[1042]
XU10138 MXL2HS $PINS OB=n667 S=FE_OFN145_FE_DBTN1_n7298 A=n7839 B=n7840
XU10139 INV1S $PINS O=n7841 I=Buffer/data_buffer[1050]
XU10140 MXL2HS $PINS OB=n659 S=FE_OFN299_FE_DBTN1_n7298 A=n7840 B=n7841
XU10141 INV1S $PINS O=n7842 I=Buffer/data_buffer[1058]
XU10142 MXL2HS $PINS OB=n651 S=FE_OFN300_FE_DBTN1_n7298 A=n7841 B=n7842
XU10143 INV1S $PINS O=n7844 I=Buffer/data_buffer[1066]
XU10144 MXL2HS $PINS OB=n643 S=FE_OFN300_FE_DBTN1_n7298 A=n7842 B=n7844
XU10145 INV1S $PINS O=n7845 I=Buffer/data_buffer[1074]
XU10146 MXL2HS $PINS OB=n635 S=FE_OFN302_FE_DBTN1_n7298 A=n7844 B=n7845
XU10147 INV1S $PINS O=n7846 I=Buffer/data_buffer[1082]
XU10148 MXL2HS $PINS OB=n627 S=FE_OFN302_FE_DBTN1_n7298 A=n7845 B=n7846
XU10149 INV1S $PINS O=n7847 I=Buffer/data_buffer[1090]
XU10150 MXL2HS $PINS OB=n619 S=FE_OFN302_FE_DBTN1_n7298 A=n7846 B=n7847
XU10151 INV1S $PINS O=n7848 I=Buffer/data_buffer[1098]
XU10152 MXL2HS $PINS OB=n611 S=FE_OFN302_FE_DBTN1_n7298 A=n7847 B=n7848
XU10153 INV1S $PINS O=n7849 I=Buffer/data_buffer[1106]
XU10154 MXL2HS $PINS OB=n603 S=FE_OFN303_FE_DBTN1_n7298 A=n7848 B=n7849
XU10155 INV1S $PINS O=n7850 I=Buffer/data_buffer[1114]
XU10156 MXL2HS $PINS OB=n595 S=FE_OFN303_FE_DBTN1_n7298 A=n7849 B=n7850
XU10157 INV1S $PINS O=n7851 I=Buffer/data_buffer[1122]
XU10158 MXL2HS $PINS OB=n587 S=FE_OFN150_FE_DBTN1_n7298 A=n7850 B=n7851
XU10159 INV1S $PINS O=n7853 I=Buffer/data_buffer[1130]
XU10160 MXL2HS $PINS OB=n579 S=FE_OFN97_FE_DBTN1_n7298 A=n7851 B=n7853
XU10161 INV1S $PINS O=n7854 I=Buffer/data_buffer[1138]
XU10162 MXL2HS $PINS OB=n571 S=FE_OFN148_FE_DBTN1_n7298 A=n7853 B=n7854
XU10163 INV1S $PINS O=n7855 I=Buffer/data_buffer[1146]
XU10164 MXL2HS $PINS OB=n563 S=FE_OFN148_FE_DBTN1_n7298 A=n7854 B=n7855
XU10165 INV1S $PINS O=n7856 I=Buffer/data_buffer[1154]
XU10166 MXL2HS $PINS OB=n555 S=FE_OFN101_FE_DBTN1_n7298 A=n7855 B=n7856
XU10167 INV1S $PINS O=n7857 I=Buffer/data_buffer[1162]
XU10168 MXL2HS $PINS OB=n547 S=FE_OFN60_FE_DBTN1_n7298 A=n7856 B=n7857
XU10169 INV1S $PINS O=n7859 I=Buffer/data_buffer[1170]
XU10170 MXL2HS $PINS OB=n539 S=FE_OFN156_FE_DBTN1_n7298 A=n7857 B=n7859
XU10171 INV1S $PINS O=n7860 I=Buffer/data_buffer[1178]
XU10172 MXL2HS $PINS OB=n531 S=FE_OFN324_FE_DBTN1_n7298 A=n7859 B=n7860
XU10173 INV1S $PINS O=n7861 I=Buffer/data_buffer[1186]
XU10174 MXL2HS $PINS OB=n523 S=FE_OFN313_FE_DBTN1_n7298 A=n7860 B=n7861
XU10175 INV1S $PINS O=n7862 I=Buffer/data_buffer[1194]
XU10176 MXL2HS $PINS OB=n515 S=FE_OFN284_FE_DBTN1_n7298 A=n7861 B=n7862
XU10177 MXL2HS $PINS OB=n507 S=FE_OFN323_FE_DBTN1_n7298 A=n7862 B=n8820
XU10178 INV1S $PINS O=n7864 I=weight_0_w[4]
XU10179 ND2 $PINS O=n7863 I1=i_data[4] I2=FE_OFN241_FE_DBTN1_n7298
XU10180 OAI12HS $PINS O=n435 A1=n7863 B1=FE_OFN241_FE_DBTN1_n7298 B2=n7864
XU10181 INV1S $PINS O=n7866 I=weight_0_w[12]
XU10182 MXL2HS $PINS OB=n434 S=FE_OFN240_FE_DBTN1_n7298 A=n7866 B=n7864
XU10183 INV1S $PINS O=n7867 I=weight_0_w[20]
XU10184 MXL2HS $PINS OB=n433 S=FE_OFN240_FE_DBTN1_n7298 A=n7867 B=n7866
XU10185 INV1S $PINS O=n7868 I=weight_1_w[4]
XU10186 MXL2HS $PINS OB=n432 S=FE_OFN112_FE_DBTN1_n7298 A=n7868 B=n7867
XU10187 INV1S $PINS O=n7869 I=weight_1_w[12]
XU10188 MXL2HS $PINS OB=n431 S=FE_OFN228_FE_DBTN1_n7298 A=n7869 B=n7868
XU10189 INV1S $PINS O=n7870 I=weight_1_w[20]
XU10190 MXL2HS $PINS OB=n430 S=FE_OFN228_FE_DBTN1_n7298 A=n7870 B=n7869
XU10191 INV1S $PINS O=n8898 I=weight_2_w[4]
XU10192 MXL2HS $PINS OB=n429 S=FE_OFN314_FE_DBTN1_n7298 A=n8898 B=n7870
XU10193 INV1S $PINS O=n7873 I=weight_0_w[3]
XU10194 ND2 $PINS O=n7871 I1=i_data[3] I2=FE_OFN239_FE_DBTN1_n7298
XU10195 OAI12HS $PINS O=n426 A1=n7871 B1=FE_OFN239_FE_DBTN1_n7298 B2=n7873
XU10196 INV1S $PINS O=n7874 I=weight_0_w[11]
XU10197 MXL2HS $PINS OB=n425 S=FE_OFN184_FE_DBTN1_n7298 A=n7874 B=n7873
XU10198 INV1S $PINS O=n7875 I=weight_0_w[19]
XU10199 MXL2HS $PINS OB=n424 S=FE_OFN185_FE_DBTN1_n7298 A=n7875 B=n7874
XU10200 INV1S $PINS O=n7876 I=weight_1_w[3]
XU10201 MXL2HS $PINS OB=n423 S=FE_OFN113_FE_DBTN1_n7298 A=n7876 B=n7875
XU10202 INV1S $PINS O=n7878 I=weight_1_w[11]
XU10203 MXL2HS $PINS OB=n422 S=FE_OFN290_FE_DBTN1_n7298 A=n7878 B=n7876
XU10204 INV1S $PINS O=n7879 I=weight_1_w[19]
XU10205 MXL2HS $PINS OB=n421 S=FE_OFN290_FE_DBTN1_n7298 A=n7879 B=n7878
XU10206 INV1S $PINS O=n8899 I=weight_2_w[3]
XU10207 MXL2HS $PINS OB=n420 S=FE_OFN227_FE_DBTN1_n7298 A=n8899 B=n7879
XU10208 INV1S $PINS O=n7881 I=Buffer/data_buffer[3]
XU10209 OAI12HS $PINS O=n1706 A1=n7880 B1=FE_OFN1244_n7298 B2=n7881
XU10210 INV1S $PINS O=n7882 I=Buffer/data_buffer[11]
XU10211 MXL2HS $PINS OB=n1698 S=FE_OFN1_FE_DBTN1_n7298 A=n7881 B=n7882
XU10212 INV1S $PINS O=n7883 I=Buffer/data_buffer[19]
XU10213 MXL2HS $PINS OB=n1690 S=FE_OFN1_FE_DBTN1_n7298 A=n7882 B=n7883
XU10214 INV1S $PINS O=n7885 I=Buffer/data_buffer[27]
XU10215 MXL2HS $PINS OB=n1682 S=FE_OFN1_FE_DBTN1_n7298 A=n7883 B=n7885
XU10216 MXL2HS $PINS OB=n1674 S=FE_OFN1_FE_DBTN1_n7298 A=n7885 B=n7886
XU10217 MXL2HS $PINS OB=n1666 S=FE_OFN127_FE_DBTN1_n7298 A=n7886 B=n7887
XU10218 MXL2HS $PINS OB=n1658 S=FE_OFN78_FE_DBTN1_n7298 A=n7887 B=n7888
XU10219 MXL2HS $PINS OB=n1650 S=FE_OFN189_FE_DBTN1_n7298 A=n7888 B=n7890
XU10220 MXL2HS $PINS OB=n1642 S=FE_OFN130_FE_DBTN1_n7298 A=n7890 B=n7891
XU10221 MXL2HS $PINS OB=n1634 S=FE_OFN24_FE_DBTN1_n7298 A=n7891 B=n7892
XU10222 INV1S $PINS O=n7893 I=Buffer/data_buffer[83]
XU10223 MXL2HS $PINS OB=n1626 S=FE_OFN133_FE_DBTN1_n7298 A=n7892 B=n7893
XU10224 INV1S $PINS O=n7894 I=Buffer/data_buffer[91]
XU10225 MXL2HS $PINS OB=n1618 S=FE_OFN315_FE_DBTN1_n7298 A=n7893 B=n7894
XU10226 INV1S $PINS O=n7895 I=Buffer/data_buffer[99]
XU10227 MXL2HS $PINS OB=n1610 S=FE_OFN29_FE_DBTN1_n7298 A=n7894 B=n7895
XU10228 INV1S $PINS O=n7897 I=Buffer/data_buffer[107]
XU10229 MXL2HS $PINS OB=n1602 S=FE_OFN29_FE_DBTN1_n7298 A=n7895 B=n7897
XU10230 MXL2HS $PINS OB=n1594 S=FE_OFN109_FE_DBTN1_n7298 A=n7897 B=n7898
XU10231 MXL2HS $PINS OB=n1586 S=FE_OFN188_FE_DBTN1_n7298 A=n7898 B=n7899
XU10232 MXL2HS $PINS OB=n1578 S=FE_OFN128_FE_DBTN1_n7298 A=n7899 B=n7900
XU10233 MXL2HS $PINS OB=n1570 S=FE_OFN243_FE_DBTN1_n7298 A=n7900 B=n7901
XU10234 MXL2HS $PINS OB=n1562 S=FE_OFN31_FE_DBTN1_n7298 A=n7901 B=n7902
XU10235 MXL2HS $PINS OB=n1554 S=FE_OFN39_FE_DBTN1_n7298 A=n7902 B=n7904
XU10236 MXL2HS $PINS OB=n1546 S=FE_OFN2_FE_DBTN1_n7298 A=n7904 B=n7905
XU10237 MXL2HS $PINS OB=n1538 S=FE_OFN189_FE_DBTN1_n7298 A=n7905 B=n7906
XU10238 MXL2HS $PINS OB=n1530 S=FE_OFN44_FE_DBTN1_n7298 A=n7906 B=n7907
XU10239 MXL2HS $PINS OB=n1522 S=FE_OFN84_FE_DBTN1_n7298 A=n7907 B=n7908
XU10240 MXL2HS $PINS OB=n1514 S=FE_OFN316_FE_DBTN1_n7298 A=n7908 B=n7909
XU10241 MXL2HS $PINS OB=n1506 S=FE_OFN151_FE_DBTN1_n7298 A=n7909 B=n7911
XU10242 MXL2HS $PINS OB=n1498 S=FE_OFN322_FE_DBTN1_n7298 A=n7911 B=n7912
XU10243 MXL2HS $PINS OB=n1490 S=FE_OFN68_FE_DBTN1_n7298 A=n7912 B=n7913
XU10244 MXL2HS $PINS OB=n1482 S=FE_OFN174_FE_DBTN1_n7298 A=n7913 B=n7914
XU10245 MXL2HS $PINS OB=n1474 S=FE_OFN37_FE_DBTN1_n7298 A=n7914 B=n7915
XU10246 INV1S $PINS O=n7916 I=Buffer/data_buffer[243]
XU10247 MXL2HS $PINS OB=n1466 S=FE_OFN37_FE_DBTN1_n7298 A=n7915 B=n7916
XU10248 INV1S $PINS O=n7918 I=Buffer/data_buffer[251]
XU10249 MXL2HS $PINS OB=n1458 S=FE_OFN36_FE_DBTN1_n7298 A=n7916 B=n7918
XU10250 INV1S $PINS O=n7920 I=Buffer/data_buffer[259]
XU10251 MXL2HS $PINS OB=n1450 S=FE_OFN36_FE_DBTN1_n7298 A=n7918 B=n7920
XU10252 INV1S $PINS O=n7921 I=Buffer/data_buffer[267]
XU10253 MXL2HS $PINS OB=n1442 S=FE_OFN219_FE_DBTN1_n7298 A=n7920 B=n7921
XU10254 INV1S $PINS O=n7922 I=Buffer/data_buffer[275]
XU10255 MXL2HS $PINS OB=n1434 S=FE_OFN103_FE_DBTN1_n7298 A=n7921 B=n7922
XU10256 INV1S $PINS O=n7923 I=Buffer/data_buffer[283]
XU10257 MXL2HS $PINS OB=n1426 S=FE_OFN103_FE_DBTN1_n7298 A=n7922 B=n7923
XU10258 INV1S $PINS O=n7924 I=Buffer/data_buffer[291]
XU10259 MXL2HS $PINS OB=n1418 S=FE_OFN284_FE_DBTN1_n7298 A=n7923 B=n7924
XU10260 INV1S $PINS O=n7926 I=Buffer/data_buffer[299]
XU10261 MXL2HS $PINS OB=n1410 S=FE_OFN62_FE_DBTN1_n7298 A=n7924 B=n7926
XU10262 INV1S $PINS O=n7927 I=Buffer/data_buffer[307]
XU10263 MXL2HS $PINS OB=n1402 S=FE_OFN306_FE_DBTN1_n7298 A=n7926 B=n7927
XU10264 INV1S $PINS O=n7928 I=Buffer/data_buffer[315]
XU10265 MXL2HS $PINS OB=n1394 S=FE_OFN152_FE_DBTN1_n7298 A=n7927 B=n7928
XU10266 INV1S $PINS O=n7929 I=Buffer/data_buffer[323]
XU10267 MXL2HS $PINS OB=n1386 S=FE_OFN314_FE_DBTN1_n7298 A=n7928 B=n7929
XU10268 INV1S $PINS O=n7930 I=Buffer/data_buffer[331]
XU10269 MXL2HS $PINS OB=n1378 S=FE_OFN163_FE_DBTN1_n7298 A=n7929 B=n7930
XU10270 MXL2HS $PINS OB=n1370 S=FE_OFN165_FE_DBTN1_n7298 A=n7930 B=n7931
XU10271 MXL2HS $PINS OB=n1362 S=FE_OFN188_FE_DBTN1_n7298 A=n7931 B=n7933
XU10272 MXL2HS $PINS OB=n1354 S=FE_OFN128_FE_DBTN1_n7298 A=n7933 B=n7934
XU10273 MXL2HS $PINS OB=n1346 S=FE_OFN243_FE_DBTN1_n7298 A=n7934 B=n7935
XU10274 MXL2HS $PINS OB=n1338 S=FE_OFN21_FE_DBTN1_n7298 A=n7935 B=n7936
XU10275 MXL2HS $PINS OB=n1330 S=FE_OFN39_FE_DBTN1_n7298 A=n7936 B=n7937
XU10276 MXL2HS $PINS OB=n1322 S=FE_OFN10_FE_DBTN1_n7298 A=n7937 B=n7938
XU10277 MXL2HS $PINS OB=n1314 S=FE_OFN130_FE_DBTN1_n7298 A=n7938 B=n7940
XU10278 MXL2HS $PINS OB=n1306 S=FE_OFN249_FE_DBTN1_n7298 A=n7940 B=n7941
XU10279 MXL2HS $PINS OB=n1298 S=FE_OFN84_FE_DBTN1_n7298 A=n7941 B=n7942
XU10280 INV1S $PINS O=n7943 I=Buffer/data_buffer[419]
XU10281 MXL2HS $PINS OB=n1290 S=FE_OFN333_FE_DBTN1_n7298 A=n7942 B=n7943
XU10282 INV1S $PINS O=n7944 I=Buffer/data_buffer[427]
XU10283 MXL2HS $PINS OB=n1282 S=FE_OFN327_FE_DBTN1_n7298 A=n7943 B=n7944
XU10284 INV1S $PINS O=n7945 I=Buffer/data_buffer[435]
XU10285 MXL2HS $PINS OB=n1274 S=FE_OFN326_FE_DBTN1_n7298 A=n7944 B=n7945
XU10286 INV1S $PINS O=n7947 I=Buffer/data_buffer[443]
XU10287 MXL2HS $PINS OB=n1266 S=FE_OFN325_FE_DBTN1_n7298 A=n7945 B=n7947
XU10288 INV1S $PINS O=n7948 I=Buffer/data_buffer[451]
XU10289 MXL2HS $PINS OB=n1258 S=FE_OFN328_FE_DBTN1_n7298 A=n7947 B=n7948
XU10290 INV1S $PINS O=n7949 I=Buffer/data_buffer[459]
XU10291 MXL2HS $PINS OB=n1250 S=FE_OFN328_FE_DBTN1_n7298 A=n7948 B=n7949
XU10292 INV1S $PINS O=n7950 I=Buffer/data_buffer[467]
XU10293 MXL2HS $PINS OB=n1242 S=FE_OFN296_FE_DBTN1_n7298 A=n7949 B=n7950
XU10294 INV1S $PINS O=n7951 I=Buffer/data_buffer[475]
XU10295 MXL2HS $PINS OB=n1234 S=FE_OFN255_FE_DBTN1_n7298 A=n7950 B=n7951
XU10296 INV1S $PINS O=n7952 I=Buffer/data_buffer[483]
XU10297 MXL2HS $PINS OB=n1226 S=FE_OFN255_FE_DBTN1_n7298 A=n7951 B=n7952
XU10298 INV1S $PINS O=n7954 I=Buffer/data_buffer[491]
XU10299 MXL2HS $PINS OB=n1218 S=FE_OFN196_FE_DBTN1_n7298 A=n7952 B=n7954
XU10300 INV1S $PINS O=n7955 I=Buffer/data_buffer[499]
XU10301 MXL2HS $PINS OB=n1210 S=FE_OFN100_FE_DBTN1_n7298 A=n7954 B=n7955
XU10302 INV1S $PINS O=n7956 I=Buffer/data_buffer[507]
XU10303 MXL2HS $PINS OB=n1202 S=FE_OFN100_FE_DBTN1_n7298 A=n7955 B=n7956
XU10304 INV1S $PINS O=n7957 I=Buffer/data_buffer[515]
XU10305 MXL2HS $PINS OB=n1194 S=FE_OFN59_FE_DBTN1_n7298 A=n7956 B=n7957
XU10306 INV1S $PINS O=n7958 I=Buffer/data_buffer[523]
XU10307 MXL2HS $PINS OB=n1186 S=FE_OFN307_FE_DBTN1_n7298 A=n7957 B=n7958
XU10308 MXL2HS $PINS OB=n1178 S=FE_OFN209_FE_DBTN1_n7298 A=n7958 B=n7959
XU10309 MXL2HS $PINS OB=n1170 S=FE_OFN270_FE_DBTN1_n7298 A=n7959 B=n7961
XU10310 MXL2HS $PINS OB=n1162 S=FE_OFN322_FE_DBTN1_n7298 A=n7961 B=n7963
XU10311 MXL2HS $PINS OB=n1154 S=FE_OFN68_FE_DBTN1_n7298 A=n7963 B=n7964
XU10312 MXL2HS $PINS OB=n1146 S=FE_OFN118_FE_DBTN1_n7298 A=n7964 B=n7965
XU10313 MXL2HS $PINS OB=n1138 S=FE_OFN75_FE_DBTN1_n7298 A=n7965 B=n7966
XU10314 INV1S $PINS O=n7967 I=Buffer/data_buffer[579]
XU10315 MXL2HS $PINS OB=n1130 S=FE_OFN123_FE_DBTN1_n7298 A=n7966 B=n7967
XU10316 INV1S $PINS O=n7969 I=Buffer/data_buffer[587]
XU10317 MXL2HS $PINS OB=n1122 S=FE_OFN182_FE_DBTN1_n7298 A=n7967 B=n7969
XU10318 INV1S $PINS O=n7970 I=Buffer/data_buffer[595]
XU10319 MXL2HS $PINS OB=n1114 S=FE_OFN238_FE_DBTN1_n7298 A=n7969 B=n7970
XU10320 INV1S $PINS O=n7971 I=Buffer/data_buffer[603]
XU10321 MXL2HS $PINS OB=n1106 S=FE_OFN119_FE_DBTN1_n7298 A=n7970 B=n7971
XU10322 INV1S $PINS O=n7972 I=Buffer/data_buffer[611]
XU10323 MXL2HS $PINS OB=n1098 S=FE_OFN175_FE_DBTN1_n7298 A=n7971 B=n7972
XU10324 INV1S $PINS O=n7973 I=Buffer/data_buffer[619]
XU10325 MXL2HS $PINS OB=n1090 S=FE_OFN176_FE_DBTN1_n7298 A=n7972 B=n7973
XU10326 INV1S $PINS O=n7974 I=Buffer/data_buffer[627]
XU10327 MXL2HS $PINS OB=n1082 S=FE_OFN176_FE_DBTN1_n7298 A=n7973 B=n7974
XU10328 INV1S $PINS O=n7976 I=Buffer/data_buffer[635]
XU10329 MXL2HS $PINS OB=n1074 S=FE_OFN175_FE_DBTN1_n7298 A=n7974 B=n7976
XU10330 INV1S $PINS O=n7977 I=Buffer/data_buffer[643]
XU10331 MXL2HS $PINS OB=n1066 S=FE_OFN234_FE_DBTN1_n7298 A=n7976 B=n7977
XU10332 INV1S $PINS O=n7978 I=Buffer/data_buffer[651]
XU10333 MXL2HS $PINS OB=n1058 S=FE_OFN234_FE_DBTN1_n7298 A=n7977 B=n7978
XU10334 INV1S $PINS O=n7979 I=Buffer/data_buffer[659]
XU10335 MXL2HS $PINS OB=n1050 S=FE_OFN120_FE_DBTN1_n7298 A=n7978 B=n7979
XU10336 INV1S $PINS O=n7980 I=Buffer/data_buffer[667]
XU10337 MXL2HS $PINS OB=n1042 S=FE_OFN168_FE_DBTN1_n7298 A=n7979 B=n7980
XU10338 INV1S $PINS O=n7981 I=Buffer/data_buffer[675]
XU10339 MXL2HS $PINS OB=n1034 S=FE_OFN168_FE_DBTN1_n7298 A=n7980 B=n7981
XU10340 INV1S $PINS O=n7983 I=Buffer/data_buffer[683]
XU10341 MXL2HS $PINS OB=n1026 S=FE_OFN115_FE_DBTN1_n7298 A=n7981 B=n7983
XU10342 INV1S $PINS O=n7984 I=Buffer/data_buffer[691]
XU10343 MXL2HS $PINS OB=n1018 S=FE_OFN115_FE_DBTN1_n7298 A=n7983 B=n7984
XU10344 INV1S $PINS O=n7985 I=Buffer/data_buffer[699]
XU10345 MXL2HS $PINS OB=n1010 S=FE_OFN114_FE_DBTN1_n7298 A=n7984 B=n7985
XU10346 INV1S $PINS O=n7986 I=Buffer/data_buffer[707]
XU10347 MXL2HS $PINS OB=n1002 S=FE_OFN114_FE_DBTN1_n7298 A=n7985 B=n7986
XU10348 INV1S $PINS O=n7987 I=Buffer/data_buffer[715]
XU10349 MXL2HS $PINS OB=n994 S=FE_OFN279_FE_DBTN1_n7298 A=n7986 B=n7987
XU10350 INV1S $PINS O=n7989 I=Buffer/data_buffer[723]
XU10351 MXL2HS $PINS OB=n986 S=FE_OFN218_FE_DBTN1_n7298 A=n7987 B=n7989
XU10352 INV1S $PINS O=n7990 I=Buffer/data_buffer[731]
XU10353 MXL2HS $PINS OB=n978 S=FE_OFN158_FE_DBTN1_n7298 A=n7989 B=n7990
XU10354 INV1S $PINS O=n7991 I=Buffer/data_buffer[739]
XU10355 MXL2HS $PINS OB=n970 S=FE_OFN216_FE_DBTN1_n7298 A=n7990 B=n7991
XU10356 INV1S $PINS O=n7992 I=Buffer/data_buffer[747]
XU10357 MXL2HS $PINS OB=n962 S=FE_OFN215_FE_DBTN1_n7298 A=n7991 B=n7992
XU10358 INV1S $PINS O=n7993 I=Buffer/data_buffer[755]
XU10359 MXL2HS $PINS OB=n954 S=FE_OFN214_FE_DBTN1_n7298 A=n7992 B=n7993
XU10360 INV1S $PINS O=n7994 I=Buffer/data_buffer[763]
XU10361 MXL2HS $PINS OB=n946 S=FE_OFN272_FE_DBTN1_n7298 A=n7993 B=n7994
XU10362 INV1S $PINS O=n7996 I=Buffer/data_buffer[771]
XU10363 MXL2HS $PINS OB=n938 S=FE_OFN153_FE_DBTN1_n7298 A=n7994 B=n7996
XU10364 INV1S $PINS O=n7997 I=Buffer/data_buffer[779]
XU10365 MXL2HS $PINS OB=n930 S=FE_OFN288_FE_DBTN1_n7298 A=n7996 B=n7997
XU10366 MXL2HS $PINS OB=n922 S=FE_OFN110_FE_DBTN1_n7298 A=n7997 B=n7998
XU10367 MXL2HS $PINS OB=n914 S=FE_OFN188_FE_DBTN1_n7298 A=n7998 B=n7999
XU10368 MXL2HS $PINS OB=n906 S=FE_OFN128_FE_DBTN1_n7298 A=n7999 B=n8000
XU10369 MXL2HS $PINS OB=n898 S=FE_OFN243_FE_DBTN1_n7298 A=n8000 B=n8001
XU10370 MXL2HS $PINS OB=n890 S=FE_OFN31_FE_DBTN1_n7298 A=n8001 B=n8003
XU10371 MXL2HS $PINS OB=n882 S=FE_OFN21_FE_DBTN1_n7298 A=n8003 B=n8005
XU10372 INV1S $PINS O=n8006 I=Buffer/data_buffer[835]
XU10373 MXL2HS $PINS OB=n874 S=FE_OFN43_FE_DBTN1_n7298 A=n8005 B=n8006
XU10374 INV1S $PINS O=n8007 I=Buffer/data_buffer[843]
XU10375 MXL2HS $PINS OB=n866 S=FE_OFN248_FE_DBTN1_n7298 A=n8006 B=n8007
XU10376 INV1S $PINS O=n8008 I=Buffer/data_buffer[851]
XU10377 MXL2HS $PINS OB=n858 S=FE_OFN87_FE_DBTN1_n7298 A=n8007 B=n8008
XU10378 INV1S $PINS O=n8009 I=Buffer/data_buffer[859]
XU10379 MXL2HS $PINS OB=n850 S=FE_OFN134_FE_DBTN1_n7298 A=n8008 B=n8009
XU10380 INV1S $PINS O=n8011 I=Buffer/data_buffer[867]
XU10381 MXL2HS $PINS OB=n842 S=FE_OFN194_FE_DBTN1_n7298 A=n8009 B=n8011
XU10382 INV1S $PINS O=n8013 I=Buffer/data_buffer[875]
XU10383 MXL2HS $PINS OB=n834 S=FE_OFN252_FE_DBTN1_n7298 A=n8011 B=n8013
XU10384 INV1S $PINS O=n8014 I=Buffer/data_buffer[883]
XU10385 MXL2HS $PINS OB=n826 S=FE_OFN261_FE_DBTN1_n7298 A=n8013 B=n8014
XU10386 INV1S $PINS O=n8015 I=Buffer/data_buffer[891]
XU10387 MXL2HS $PINS OB=n818 S=FE_OFN261_FE_DBTN1_n7298 A=n8014 B=n8015
XU10388 INV1S $PINS O=n8016 I=Buffer/data_buffer[899]
XU10389 MXL2HS $PINS OB=n810 S=FE_OFN199_FE_DBTN1_n7298 A=n8015 B=n8016
XU10390 INV1S $PINS O=n8017 I=Buffer/data_buffer[907]
XU10391 MXL2HS $PINS OB=n802 S=FE_OFN199_FE_DBTN1_n7298 A=n8016 B=n8017
XU10392 INV1S $PINS O=n8019 I=Buffer/data_buffer[915]
XU10393 MXL2HS $PINS OB=n794 S=FE_OFN140_FE_DBTN1_n7298 A=n8017 B=n8019
XU10394 INV1S $PINS O=n8020 I=Buffer/data_buffer[923]
XU10395 MXL2HS $PINS OB=n786 S=FE_OFN140_FE_DBTN1_n7298 A=n8019 B=n8020
XU10396 INV1S $PINS O=n8021 I=Buffer/data_buffer[931]
XU10397 MXL2HS $PINS OB=n778 S=FE_OFN198_FE_DBTN1_n7298 A=n8020 B=n8021
XU10398 INV1S $PINS O=n8022 I=Buffer/data_buffer[939]
XU10399 MXL2HS $PINS OB=n770 S=FE_OFN198_FE_DBTN1_n7298 A=n8021 B=n8022
XU10400 INV1S $PINS O=n8023 I=Buffer/data_buffer[947]
XU10401 MXL2HS $PINS OB=n762 S=FE_OFN198_FE_DBTN1_n7298 A=n8022 B=n8023
XU10402 INV1S $PINS O=n8024 I=Buffer/data_buffer[955]
XU10403 MXL2HS $PINS OB=n754 S=FE_OFN258_FE_DBTN1_n7298 A=n8023 B=n8024
XU10404 INV1S $PINS O=n8026 I=Buffer/data_buffer[963]
XU10405 MXL2HS $PINS OB=n746 S=FE_OFN265_FE_DBTN1_n7298 A=n8024 B=n8026
XU10406 INV1S $PINS O=n8027 I=Buffer/data_buffer[971]
XU10407 MXL2HS $PINS OB=n738 S=FE_OFN206_FE_DBTN1_n7298 A=n8026 B=n8027
XU10408 INV1S $PINS O=n8028 I=Buffer/data_buffer[979]
XU10409 MXL2HS $PINS OB=n730 S=FE_OFN264_FE_DBTN1_n7298 A=n8027 B=n8028
XU10410 INV1S $PINS O=n8029 I=Buffer/data_buffer[987]
XU10411 MXL2HS $PINS OB=n722 S=FE_OFN264_FE_DBTN1_n7298 A=n8028 B=n8029
XU10412 INV1S $PINS O=n8030 I=Buffer/data_buffer[995]
XU10413 MXL2HS $PINS OB=n714 S=FE_OFN267_FE_DBTN1_n7298 A=n8029 B=n8030
XU10414 INV1S $PINS O=n8031 I=Buffer/data_buffer[1003]
XU10415 MXL2HS $PINS OB=n706 S=FE_OFN267_FE_DBTN1_n7298 A=n8030 B=n8031
XU10416 INV1S $PINS O=n8033 I=Buffer/data_buffer[1011]
XU10417 MXL2HS $PINS OB=n698 S=FE_OFN267_FE_DBTN1_n7298 A=n8031 B=n8033
XU10418 INV1S $PINS O=n8034 I=Buffer/data_buffer[1019]
XU10419 MXL2HS $PINS OB=n690 S=FE_OFN203_FE_DBTN1_n7298 A=n8033 B=n8034
XU10420 INV1S $PINS O=n8035 I=Buffer/data_buffer[1027]
XU10421 MXL2HS $PINS OB=n682 S=FE_OFN144_FE_DBTN1_n7298 A=n8034 B=n8035
XU10422 INV1S $PINS O=n8036 I=Buffer/data_buffer[1035]
XU10423 MXL2HS $PINS OB=n674 S=FE_OFN144_FE_DBTN1_n7298 A=n8035 B=n8036
XU10424 INV1S $PINS O=n8037 I=Buffer/data_buffer[1043]
XU10425 MXL2HS $PINS OB=n666 S=FE_OFN144_FE_DBTN1_n7298 A=n8036 B=n8037
XU10426 INV1S $PINS O=n8038 I=Buffer/data_buffer[1051]
XU10427 MXL2HS $PINS OB=n658 S=FE_OFN94_FE_DBTN1_n7298 A=n8037 B=n8038
XU10428 INV1S $PINS O=n8040 I=Buffer/data_buffer[1059]
XU10429 MXL2HS $PINS OB=n650 S=FE_OFN54_FE_DBTN1_n7298 A=n8038 B=n8040
XU10430 INV1S $PINS O=n8041 I=Buffer/data_buffer[1067]
XU10431 MXL2HS $PINS OB=n642 S=FE_OFN340_FE_DBTN1_n7298 A=n8040 B=n8041
XU10432 INV1S $PINS O=n8042 I=Buffer/data_buffer[1075]
XU10433 MXL2HS $PINS OB=n634 S=FE_OFN340_FE_DBTN1_n7298 A=n8041 B=n8042
XU10434 INV1S $PINS O=n8043 I=Buffer/data_buffer[1083]
XU10435 MXL2HS $PINS OB=n626 S=FE_OFN340_FE_DBTN1_n7298 A=n8042 B=n8043
XU10436 INV1S $PINS O=n8044 I=Buffer/data_buffer[1091]
XU10437 MXL2HS $PINS OB=n618 S=FE_OFN340_FE_DBTN1_n7298 A=n8043 B=n8044
XU10438 INV1S $PINS O=n8045 I=Buffer/data_buffer[1099]
XU10439 MXL2HS $PINS OB=n610 S=FE_OFN297_FE_DBTN1_n7298 A=n8044 B=n8045
XU10440 INV1S $PINS O=n8047 I=Buffer/data_buffer[1107]
XU10441 MXL2HS $PINS OB=n602 S=FE_OFN320_FE_DBTN1_n7298 A=n8045 B=n8047
XU10442 INV1S $PINS O=n8049 I=Buffer/data_buffer[1115]
XU10443 MXL2HS $PINS OB=n594 S=FE_OFN201_FE_DBTN1_n7298 A=n8047 B=n8049
XU10444 INV1S $PINS O=n8050 I=Buffer/data_buffer[1123]
XU10445 MXL2HS $PINS OB=n586 S=FE_OFN201_FE_DBTN1_n7298 A=n8049 B=n8050
XU10446 INV1S $PINS O=n8051 I=Buffer/data_buffer[1131]
XU10447 MXL2HS $PINS OB=n578 S=FE_OFN298_FE_DBTN1_n7298 A=n8050 B=n8051
XU10448 INV1S $PINS O=n8052 I=Buffer/data_buffer[1139]
XU10449 MXL2HS $PINS OB=n570 S=FE_OFN298_FE_DBTN1_n7298 A=n8051 B=n8052
XU10450 INV1S $PINS O=n8053 I=Buffer/data_buffer[1147]
XU10451 MXL2HS $PINS OB=n562 S=FE_OFN200_FE_DBTN1_n7298 A=n8052 B=n8053
XU10452 INV1S $PINS O=n8055 I=Buffer/data_buffer[1155]
XU10453 MXL2HS $PINS OB=n554 S=FE_OFN200_FE_DBTN1_n7298 A=n8053 B=n8055
XU10454 INV1S $PINS O=n8056 I=Buffer/data_buffer[1163]
XU10455 MXL2HS $PINS OB=n546 S=FE_OFN338_FE_DBTN1_n7298 A=n8055 B=n8056
XU10456 INV1S $PINS O=n8057 I=Buffer/data_buffer[1171]
XU10457 MXL2HS $PINS OB=n538 S=FE_OFN338_FE_DBTN1_n7298 A=n8056 B=n8057
XU10458 INV1S $PINS O=n8058 I=Buffer/data_buffer[1179]
XU10459 MXL2HS $PINS OB=n530 S=FE_OFN337_FE_DBTN1_n7298 A=n8057 B=n8058
XU10460 INV1S $PINS O=n8059 I=Buffer/data_buffer[1187]
XU10461 MXL2HS $PINS OB=n522 S=FE_OFN215_FE_DBTN1_n7298 A=n8058 B=n8059
XU10462 INV1S $PINS O=n8060 I=Buffer/data_buffer[1195]
XU10463 MXL2HS $PINS OB=n514 S=FE_OFN311_FE_DBTN1_n7298 A=n8059 B=n8060
XU10464 MXL2HS $PINS OB=n506 S=FE_OFN62_FE_DBTN1_n7298 A=n8060 B=n8818
XU10465 INV1S $PINS O=n8063 I=Buffer/data_buffer[1]
XU10466 OAI12HS $PINS O=n1708 A1=n8061 B1=n7298 B2=n8063
XU10467 INV1S $PINS O=n8064 I=Buffer/data_buffer[9]
XU10468 MXL2HS $PINS OB=n1700 S=FE_OFN125_FE_DBTN1_n7298 A=n8063 B=n8064
XU10469 INV1S $PINS O=n8065 I=Buffer/data_buffer[17]
XU10470 MXL2HS $PINS OB=n1692 S=FE_OFN76_FE_DBTN1_n7298 A=n8064 B=n8065
XU10471 INV1S $PINS O=n8066 I=Buffer/data_buffer[25]
XU10472 MXL2HS $PINS OB=n1684 S=FE_OFN38_FE_DBTN1_n7298 A=n8065 B=n8066
XU10473 MXL2HS $PINS OB=n1676 S=FE_OFN19_FE_DBTN1_n7298 A=n8066 B=n8067
XU10474 MXL2HS $PINS OB=n1668 S=FE_OFN20_FE_DBTN1_n7298 A=n8067 B=n8068
XU10475 MXL2HS $PINS OB=n1660 S=FE_OFN39_FE_DBTN1_n7298 A=n8068 B=n8070
XU10476 MXL2HS $PINS OB=n1652 S=FE_OFN82_FE_DBTN1_n7298 A=n8070 B=n8071
XU10477 MXL2HS $PINS OB=n1644 S=FE_OFN191_FE_DBTN1_n7298 A=n8071 B=n8072
XU10478 MXL2HS $PINS OB=n1636 S=FE_OFN85_FE_DBTN1_n7298 A=n8072 B=n8073
XU10479 INV1S $PINS O=n8074 I=Buffer/data_buffer[81]
XU10480 MXL2HS $PINS OB=n1628 S=FE_OFN133_FE_DBTN1_n7298 A=n8073 B=n8074
XU10481 INV1S $PINS O=n8075 I=Buffer/data_buffer[89]
XU10482 MXL2HS $PINS OB=n1620 S=FE_OFN315_FE_DBTN1_n7298 A=n8074 B=n8075
XU10483 INV1S $PINS O=n8077 I=Buffer/data_buffer[97]
XU10484 MXL2HS $PINS OB=n1612 S=FE_OFN29_FE_DBTN1_n7298 A=n8075 B=n8077
XU10485 INV1S $PINS O=n8079 I=Buffer/data_buffer[105]
XU10486 MXL2HS $PINS OB=n1604 S=FE_OFN3_FE_DBTN1_n7298 A=n8077 B=n8079
XU10487 MXL2HS $PINS OB=n1596 S=FE_OFN242_FE_DBTN1_n7298 A=n8079 B=n8080
XU10488 MXL2HS $PINS OB=n1588 S=FE_OFN245_FE_DBTN1_n7298 A=n8080 B=n8081
XU10489 MXL2HS $PINS OB=n1580 S=FE_OFN243_FE_DBTN1_n7298 A=n8081 B=n8082
XU10490 MXL2HS $PINS OB=n1572 S=FE_OFN112_FE_DBTN1_n7298 A=n8082 B=n8083
XU10491 MXL2HS $PINS OB=n1564 S=FE_OFN31_FE_DBTN1_n7298 A=n8083 B=n8085
XU10492 MXL2HS $PINS OB=n1556 S=FE_OFN77_FE_DBTN1_n7298 A=n8085 B=n8087
XU10493 MXL2HS $PINS OB=n1548 S=FE_OFN42_FE_DBTN1_n7298 A=n8087 B=n8088
XU10494 MXL2HS $PINS OB=n1540 S=FE_OFN23_FE_DBTN1_n7298 A=n8088 B=n8089
XU10495 MXL2HS $PINS OB=n1532 S=FE_OFN85_FE_DBTN1_n7298 A=n8089 B=n8090
XU10496 MXL2HS $PINS OB=n1524 S=FE_OFN251_FE_DBTN1_n7298 A=n8090 B=n8091
XU10497 MXL2HS $PINS OB=n1516 S=FE_OFN316_FE_DBTN1_n7298 A=n8091 B=n8092
XU10498 MXL2HS $PINS OB=n1508 S=FE_OFN210_FE_DBTN1_n7298 A=n8092 B=n8093
XU10499 MXL2HS $PINS OB=n1500 S=FE_OFN322_FE_DBTN1_n7298 A=n8093 B=n8094
XU10500 MXL2HS $PINS OB=n1492 S=FE_OFN171_FE_DBTN1_n7298 A=n8094 B=n8095
XU10501 MXL2HS $PINS OB=n1484 S=FE_OFN287_FE_DBTN1_n7298 A=n8095 B=n8096
XU10502 MXL2HS $PINS OB=n1476 S=FE_OFN287_FE_DBTN1_n7298 A=n8096 B=n8097
XU10503 INV1S $PINS O=n8098 I=Buffer/data_buffer[241]
XU10504 MXL2HS $PINS OB=n1468 S=FE_OFN18_FE_DBTN1_n7298 A=n8097 B=n8098
XU10505 INV1S $PINS O=n8099 I=Buffer/data_buffer[249]
XU10506 MXL2HS $PINS OB=n1460 S=FE_OFN36_FE_DBTN1_n7298 A=n8098 B=n8099
XU10507 INV1S $PINS O=n8101 I=Buffer/data_buffer[257]
XU10508 MXL2HS $PINS OB=n1452 S=FE_OFN219_FE_DBTN1_n7298 A=n8099 B=n8101
XU10509 INV1S $PINS O=n8102 I=Buffer/data_buffer[265]
XU10510 MXL2HS $PINS OB=n1444 S=FE_OFN219_FE_DBTN1_n7298 A=n8101 B=n8102
XU10511 INV1S $PINS O=n8103 I=Buffer/data_buffer[273]
XU10512 MXL2HS $PINS OB=n1436 S=FE_OFN219_FE_DBTN1_n7298 A=n8102 B=n8103
XU10513 INV1S $PINS O=n8104 I=Buffer/data_buffer[281]
XU10514 MXL2HS $PINS OB=n1428 S=FE_OFN284_FE_DBTN1_n7298 A=n8103 B=n8104
XU10515 INV1S $PINS O=n8105 I=Buffer/data_buffer[289]
XU10516 MXL2HS $PINS OB=n1420 S=FE_OFN222_FE_DBTN1_n7298 A=n8104 B=n8105
XU10517 INV1S $PINS O=n8106 I=Buffer/data_buffer[297]
XU10518 MXL2HS $PINS OB=n1412 S=FE_OFN106_FE_DBTN1_n7298 A=n8105 B=n8106
XU10519 INV1S $PINS O=n8108 I=Buffer/data_buffer[305]
XU10520 MXL2HS $PINS OB=n1404 S=FE_OFN209_FE_DBTN1_n7298 A=n8106 B=n8108
XU10521 INV1S $PINS O=n8109 I=Buffer/data_buffer[313]
XU10522 MXL2HS $PINS OB=n1396 S=FE_OFN152_FE_DBTN1_n7298 A=n8108 B=n8109
XU10523 INV1S $PINS O=n8110 I=Buffer/data_buffer[321]
XU10524 MXL2HS $PINS OB=n1388 S=FE_OFN314_FE_DBTN1_n7298 A=n8109 B=n8110
XU10525 INV1S $PINS O=n8111 I=Buffer/data_buffer[329]
XU10526 MXL2HS $PINS OB=n1380 S=FE_OFN289_FE_DBTN1_n7298 A=n8110 B=n8111
XU10527 MXL2HS $PINS OB=n1372 S=FE_OFN110_FE_DBTN1_n7298 A=n8111 B=n8112
XU10528 MXL2HS $PINS OB=n1364 S=FE_OFN224_FE_DBTN1_n7298 A=n8112 B=n8113
XU10529 MXL2HS $PINS OB=n1356 S=FE_OFN243_FE_DBTN1_n7298 A=n8113 B=n8115
XU10530 MXL2HS $PINS OB=n1348 S=FE_OFN112_FE_DBTN1_n7298 A=n8115 B=n8116
XU10531 MXL2HS $PINS OB=n1340 S=FE_OFN32_FE_DBTN1_n7298 A=n8116 B=n8117
XU10532 MXL2HS $PINS OB=n1332 S=FE_OFN39_FE_DBTN1_n7298 A=n8117 B=n8118
XU10533 MXL2HS $PINS OB=n1324 S=FE_OFN2_FE_DBTN1_n7298 A=n8118 B=n8119
XU10534 MXL2HS $PINS OB=n1316 S=FE_OFN23_FE_DBTN1_n7298 A=n8119 B=n8120
XU10535 MXL2HS $PINS OB=n1308 S=FE_OFN248_FE_DBTN1_n7298 A=n8120 B=n8122
XU10536 MXL2HS $PINS OB=n1300 S=FE_OFN132_FE_DBTN1_n7298 A=n8122 B=n8124
XU10537 INV1S $PINS O=n8125 I=Buffer/data_buffer[417]
XU10538 MXL2HS $PINS OB=n1292 S=FE_OFN132_FE_DBTN1_n7298 A=n8124 B=n8125
XU10539 INV1S $PINS O=n8126 I=Buffer/data_buffer[425]
XU10540 MXL2HS $PINS OB=n1284 S=FE_OFN132_FE_DBTN1_n7298 A=n8125 B=n8126
XU10541 INV1S $PINS O=n8127 I=Buffer/data_buffer[433]
XU10542 MXL2HS $PINS OB=n1276 S=FE_OFN48_FE_DBTN1_n7298 A=n8126 B=n8127
XU10543 INV1S $PINS O=n8128 I=Buffer/data_buffer[441]
XU10544 MXL2HS $PINS OB=n1268 S=FE_OFN48_FE_DBTN1_n7298 A=n8127 B=n8128
XU10545 INV1S $PINS O=n8130 I=Buffer/data_buffer[449]
XU10546 MXL2HS $PINS OB=n1260 S=FE_OFN137_FE_DBTN1_n7298 A=n8128 B=n8130
XU10547 INV1S $PINS O=n8131 I=Buffer/data_buffer[457]
XU10548 MXL2HS $PINS OB=n1252 S=FE_OFN137_FE_DBTN1_n7298 A=n8130 B=n8131
XU10549 INV1S $PINS O=n8132 I=Buffer/data_buffer[465]
XU10550 MXL2HS $PINS OB=n1244 S=FE_OFN138_FE_DBTN1_n7298 A=n8131 B=n8132
XU10551 INV1S $PINS O=n8133 I=Buffer/data_buffer[473]
XU10552 MXL2HS $PINS OB=n1236 S=FE_OFN138_FE_DBTN1_n7298 A=n8132 B=n8133
XU10553 INV1S $PINS O=n8134 I=Buffer/data_buffer[481]
XU10554 MXL2HS $PINS OB=n1228 S=FE_OFN138_FE_DBTN1_n7298 A=n8133 B=n8134
XU10555 INV1S $PINS O=n8135 I=Buffer/data_buffer[489]
XU10556 MXL2HS $PINS OB=n1220 S=FE_OFN197_FE_DBTN1_n7298 A=n8134 B=n8135
XU10557 INV1S $PINS O=n8137 I=Buffer/data_buffer[497]
XU10558 MXL2HS $PINS OB=n1212 S=FE_OFN273_FE_DBTN1_n7298 A=n8135 B=n8137
XU10559 INV1S $PINS O=n8138 I=Buffer/data_buffer[505]
XU10560 MXL2HS $PINS OB=n1204 S=FE_OFN273_FE_DBTN1_n7298 A=n8137 B=n8138
XU10561 INV1S $PINS O=n8139 I=Buffer/data_buffer[513]
XU10562 MXL2HS $PINS OB=n1196 S=FE_OFN309_FE_DBTN1_n7298 A=n8138 B=n8139
XU10563 INV1S $PINS O=n8140 I=Buffer/data_buffer[521]
XU10564 MXL2HS $PINS OB=n1188 S=FE_OFN306_FE_DBTN1_n7298 A=n8139 B=n8140
XU10565 MXL2HS $PINS OB=n1180 S=FE_OFN209_FE_DBTN1_n7298 A=n8140 B=n8141
XU10566 MXL2HS $PINS OB=n1172 S=FE_OFN270_FE_DBTN1_n7298 A=n8141 B=n8142
XU10567 MXL2HS $PINS OB=n1164 S=FE_OFN322_FE_DBTN1_n7298 A=n8142 B=n8144
XU10568 MXL2HS $PINS OB=n1156 S=FE_OFN171_FE_DBTN1_n7298 A=n8144 B=n8145
XU10569 MXL2HS $PINS OB=n1148 S=FE_OFN291_FE_DBTN1_n7298 A=n8145 B=n8146
XU10570 MXL2HS $PINS OB=n1140 S=FE_OFN232_FE_DBTN1_n7298 A=n8146 B=n8147
XU10571 INV1S $PINS O=n8148 I=Buffer/data_buffer[577]
XU10572 MXL2HS $PINS OB=n1132 S=FE_OFN179_FE_DBTN1_n7298 A=n8147 B=n8148
XU10573 INV1S $PINS O=n8149 I=Buffer/data_buffer[585]
XU10574 MXL2HS $PINS OB=n1124 S=FE_OFN123_FE_DBTN1_n7298 A=n8148 B=n8149
XU10575 INV1S $PINS O=n8151 I=Buffer/data_buffer[593]
XU10576 MXL2HS $PINS OB=n1116 S=FE_OFN123_FE_DBTN1_n7298 A=n8149 B=n8151
XU10577 INV1S $PINS O=n8152 I=Buffer/data_buffer[601]
XU10578 MXL2HS $PINS OB=n1108 S=FE_OFN123_FE_DBTN1_n7298 A=n8151 B=n8152
XU10579 INV1S $PINS O=n8153 I=Buffer/data_buffer[609]
XU10580 MXL2HS $PINS OB=n1100 S=FE_OFN119_FE_DBTN1_n7298 A=n8152 B=n8153
XU10581 INV1S $PINS O=n8154 I=Buffer/data_buffer[617]
XU10582 MXL2HS $PINS OB=n1092 S=FE_OFN119_FE_DBTN1_n7298 A=n8153 B=n8154
XU10583 INV1S $PINS O=n8155 I=Buffer/data_buffer[625]
XU10584 MXL2HS $PINS OB=n1084 S=FE_OFN71_FE_DBTN1_n7298 A=n8154 B=n8155
XU10585 INV1S $PINS O=n8156 I=Buffer/data_buffer[633]
XU10586 MXL2HS $PINS OB=n1076 S=FE_OFN120_FE_DBTN1_n7298 A=n8155 B=n8156
XU10587 INV1S $PINS O=n8158 I=Buffer/data_buffer[641]
XU10588 MXL2HS $PINS OB=n1068 S=FE_OFN120_FE_DBTN1_n7298 A=n8156 B=n8158
XU10589 INV1S $PINS O=n8159 I=Buffer/data_buffer[649]
XU10590 MXL2HS $PINS OB=n1060 S=FE_OFN120_FE_DBTN1_n7298 A=n8158 B=n8159
XU10591 INV1S $PINS O=n8160 I=Buffer/data_buffer[657]
XU10592 MXL2HS $PINS OB=n1052 S=FE_OFN168_FE_DBTN1_n7298 A=n8159 B=n8160
XU10593 INV1S $PINS O=n8161 I=Buffer/data_buffer[665]
XU10594 MXL2HS $PINS OB=n1044 S=FE_OFN168_FE_DBTN1_n7298 A=n8160 B=n8161
XU10595 INV1S $PINS O=n8162 I=Buffer/data_buffer[673]
XU10596 MXL2HS $PINS OB=n1036 S=FE_OFN168_FE_DBTN1_n7298 A=n8161 B=n8162
XU10597 INV1S $PINS O=n8163 I=Buffer/data_buffer[681]
XU10598 MXL2HS $PINS OB=n1028 S=FE_OFN67_FE_DBTN1_n7298 A=n8162 B=n8163
XU10599 INV1S $PINS O=n8165 I=Buffer/data_buffer[689]
XU10600 MXL2HS $PINS OB=n1020 S=FE_OFN67_FE_DBTN1_n7298 A=n8163 B=n8165
XU10601 INV1S $PINS O=n8167 I=Buffer/data_buffer[697]
XU10602 MXL2HS $PINS OB=n1012 S=FE_OFN33_FE_DBTN1_n7298 A=n8165 B=n8167
XU10603 INV1S $PINS O=n8168 I=Buffer/data_buffer[705]
XU10604 MXL2HS $PINS OB=n1004 S=FE_OFN15_FE_DBTN1_n7298 A=n8167 B=n8168
XU10605 INV1S $PINS O=n8169 I=Buffer/data_buffer[713]
XU10606 MXL2HS $PINS OB=n996 S=FE_OFN279_FE_DBTN1_n7298 A=n8168 B=n8169
XU10607 INV1S $PINS O=n8170 I=Buffer/data_buffer[721]
XU10608 MXL2HS $PINS OB=n988 S=FE_OFN277_FE_DBTN1_n7298 A=n8169 B=n8170
XU10609 INV1S $PINS O=n8171 I=Buffer/data_buffer[729]
XU10610 MXL2HS $PINS OB=n980 S=FE_OFN277_FE_DBTN1_n7298 A=n8170 B=n8171
XU10611 INV1S $PINS O=n8173 I=Buffer/data_buffer[737]
XU10612 MXL2HS $PINS OB=n972 S=FE_OFN216_FE_DBTN1_n7298 A=n8171 B=n8173
XU10613 INV1S $PINS O=n8174 I=Buffer/data_buffer[745]
XU10614 MXL2HS $PINS OB=n964 S=FE_OFN313_FE_DBTN1_n7298 A=n8173 B=n8174
XU10615 INV1S $PINS O=n8175 I=Buffer/data_buffer[753]
XU10616 MXL2HS $PINS OB=n956 S=FE_OFN275_FE_DBTN1_n7298 A=n8174 B=n8175
XU10617 INV1S $PINS O=n8176 I=Buffer/data_buffer[761]
XU10618 MXL2HS $PINS OB=n948 S=FE_OFN307_FE_DBTN1_n7298 A=n8175 B=n8176
XU10619 INV1S $PINS O=n8177 I=Buffer/data_buffer[769]
XU10620 MXL2HS $PINS OB=n940 S=FE_OFN308_FE_DBTN1_n7298 A=n8176 B=n8177
XU10621 INV1S $PINS O=n8178 I=Buffer/data_buffer[777]
XU10622 MXL2HS $PINS OB=n932 S=FE_OFN288_FE_DBTN1_n7298 A=n8177 B=n8178
XU10623 MXL2HS $PINS OB=n924 S=FE_OFN110_FE_DBTN1_n7298 A=n8178 B=n8180
XU10624 MXL2HS $PINS OB=n916 S=FE_OFN224_FE_DBTN1_n7298 A=n8180 B=n8181
XU10625 MXL2HS $PINS OB=n908 S=FE_OFN243_FE_DBTN1_n7298 A=n8181 B=n8182
XU10626 MXL2HS $PINS OB=n900 S=FE_OFN112_FE_DBTN1_n7298 A=n8182 B=n8183
XU10627 MXL2HS $PINS OB=n892 S=FE_OFN31_FE_DBTN1_n7298 A=n8183 B=n8184
XU10628 MXL2HS $PINS OB=n884 S=FE_OFN30_FE_DBTN1_n7298 A=n8184 B=n8186
XU10629 INV1S $PINS O=n8187 I=Buffer/data_buffer[833]
XU10630 MXL2HS $PINS OB=n876 S=FE_OFN42_FE_DBTN1_n7298 A=n8186 B=n8187
XU10631 INV1S $PINS O=n8188 I=Buffer/data_buffer[841]
XU10632 MXL2HS $PINS OB=n868 S=FE_OFN129_FE_DBTN1_n7298 A=n8187 B=n8188
XU10633 INV1S $PINS O=n8189 I=Buffer/data_buffer[849]
XU10634 MXL2HS $PINS OB=n860 S=FE_OFN333_FE_DBTN1_n7298 A=n8188 B=n8189
XU10635 INV1S $PINS O=n8190 I=Buffer/data_buffer[857]
XU10636 MXL2HS $PINS OB=n852 S=FE_OFN333_FE_DBTN1_n7298 A=n8189 B=n8190
XU10637 INV1S $PINS O=n8191 I=Buffer/data_buffer[865]
XU10638 MXL2HS $PINS OB=n844 S=FE_OFN295_FE_DBTN1_n7298 A=n8190 B=n8191
XU10639 INV1S $PINS O=n8193 I=Buffer/data_buffer[873]
XU10640 MXL2HS $PINS OB=n836 S=FE_OFN295_FE_DBTN1_n7298 A=n8191 B=n8193
XU10641 INV1S $PINS O=n8194 I=Buffer/data_buffer[881]
XU10642 MXL2HS $PINS OB=n828 S=FE_OFN253_FE_DBTN1_n7298 A=n8193 B=n8194
XU10643 INV1S $PINS O=n8195 I=Buffer/data_buffer[889]
XU10644 MXL2HS $PINS OB=n820 S=FE_OFN253_FE_DBTN1_n7298 A=n8194 B=n8195
XU10645 INV1S $PINS O=n8196 I=Buffer/data_buffer[897]
XU10646 MXL2HS $PINS OB=n812 S=FE_OFN49_FE_DBTN1_n7298 A=n8195 B=n8196
XU10647 INV1S $PINS O=n8197 I=Buffer/data_buffer[905]
XU10648 MXL2HS $PINS OB=n804 S=FE_OFN49_FE_DBTN1_n7298 A=n8196 B=n8197
XU10649 INV1S $PINS O=n8198 I=Buffer/data_buffer[913]
XU10650 MXL2HS $PINS OB=n796 S=FE_OFN26_FE_DBTN1_n7298 A=n8197 B=n8198
XU10651 INV1S $PINS O=n8200 I=Buffer/data_buffer[921]
XU10652 MXL2HS $PINS OB=n788 S=FE_OFN50_FE_DBTN1_n7298 A=n8198 B=n8200
XU10653 INV1S $PINS O=n8201 I=Buffer/data_buffer[929]
XU10654 MXL2HS $PINS OB=n780 S=FE_OFN50_FE_DBTN1_n7298 A=n8200 B=n8201
XU10655 INV1S $PINS O=n8202 I=Buffer/data_buffer[937]
XU10656 MXL2HS $PINS OB=n772 S=FE_OFN90_FE_DBTN1_n7298 A=n8201 B=n8202
XU10657 INV1S $PINS O=n8203 I=Buffer/data_buffer[945]
XU10658 MXL2HS $PINS OB=n764 S=FE_OFN90_FE_DBTN1_n7298 A=n8202 B=n8203
XU10659 INV1S $PINS O=n8204 I=Buffer/data_buffer[953]
XU10660 MXL2HS $PINS OB=n756 S=FE_OFN90_FE_DBTN1_n7298 A=n8203 B=n8204
XU10661 INV1S $PINS O=n8205 I=Buffer/data_buffer[961]
XU10662 MXL2HS $PINS OB=n748 S=FE_OFN55_FE_DBTN1_n7298 A=n8204 B=n8205
XU10663 INV1S $PINS O=n8207 I=Buffer/data_buffer[969]
XU10664 MXL2HS $PINS OB=n740 S=FE_OFN55_FE_DBTN1_n7298 A=n8205 B=n8207
XU10665 INV1S $PINS O=n8208 I=Buffer/data_buffer[977]
XU10666 MXL2HS $PINS OB=n732 S=FE_OFN96_FE_DBTN1_n7298 A=n8207 B=n8208
XU10667 INV1S $PINS O=n8209 I=Buffer/data_buffer[985]
XU10668 MXL2HS $PINS OB=n724 S=FE_OFN146_FE_DBTN1_n7298 A=n8208 B=n8209
XU10669 INV1S $PINS O=n8210 I=Buffer/data_buffer[993]
XU10670 MXL2HS $PINS OB=n716 S=FE_OFN266_FE_DBTN1_n7298 A=n8209 B=n8210
XU10671 INV1S $PINS O=n8211 I=Buffer/data_buffer[1001]
XU10672 MXL2HS $PINS OB=n708 S=FE_OFN202_FE_DBTN1_n7298 A=n8210 B=n8211
XU10673 INV1S $PINS O=n8212 I=Buffer/data_buffer[1009]
XU10674 MXL2HS $PINS OB=n700 S=FE_OFN203_FE_DBTN1_n7298 A=n8211 B=n8212
XU10675 INV1S $PINS O=n8214 I=Buffer/data_buffer[1017]
XU10676 MXL2HS $PINS OB=n692 S=FE_OFN204_FE_DBTN1_n7298 A=n8212 B=n8214
XU10677 INV1S $PINS O=n8216 I=Buffer/data_buffer[1025]
XU10678 MXL2HS $PINS OB=n684 S=FE_OFN204_FE_DBTN1_n7298 A=n8214 B=n8216
XU10679 INV1S $PINS O=n8217 I=Buffer/data_buffer[1033]
XU10680 MXL2HS $PINS OB=n676 S=FE_OFN204_FE_DBTN1_n7298 A=n8216 B=n8217
XU10681 INV1S $PINS O=n8218 I=Buffer/data_buffer[1041]
XU10682 MXL2HS $PINS OB=n668 S=FE_OFN299_FE_DBTN1_n7298 A=n8217 B=n8218
XU10683 INV1S $PINS O=n8219 I=Buffer/data_buffer[1049]
XU10684 MXL2HS $PINS OB=n660 S=FE_OFN299_FE_DBTN1_n7298 A=n8218 B=n8219
XU10685 INV1S $PINS O=n8220 I=Buffer/data_buffer[1057]
XU10686 MXL2HS $PINS OB=n652 S=FE_OFN205_FE_DBTN1_n7298 A=n8219 B=n8220
XU10687 INV1S $PINS O=n8222 I=Buffer/data_buffer[1065]
XU10688 MXL2HS $PINS OB=n644 S=FE_OFN205_FE_DBTN1_n7298 A=n8220 B=n8222
XU10689 INV1S $PINS O=n8223 I=Buffer/data_buffer[1073]
XU10690 MXL2HS $PINS OB=n636 S=FE_OFN301_FE_DBTN1_n7298 A=n8222 B=n8223
XU10691 INV1S $PINS O=n8224 I=Buffer/data_buffer[1081]
XU10692 MXL2HS $PINS OB=n628 S=FE_OFN301_FE_DBTN1_n7298 A=n8223 B=n8224
XU10693 INV1S $PINS O=n8225 I=Buffer/data_buffer[1089]
XU10694 MXL2HS $PINS OB=n620 S=FE_OFN301_FE_DBTN1_n7298 A=n8224 B=n8225
XU10695 INV1S $PINS O=n8226 I=Buffer/data_buffer[1097]
XU10696 MXL2HS $PINS OB=n612 S=FE_OFN208_FE_DBTN1_n7298 A=n8225 B=n8226
XU10697 INV1S $PINS O=n8227 I=Buffer/data_buffer[1105]
XU10698 MXL2HS $PINS OB=n604 S=FE_OFN208_FE_DBTN1_n7298 A=n8226 B=n8227
XU10699 INV1S $PINS O=n8229 I=Buffer/data_buffer[1113]
XU10700 MXL2HS $PINS OB=n596 S=FE_OFN150_FE_DBTN1_n7298 A=n8227 B=n8229
XU10701 INV1S $PINS O=n8230 I=Buffer/data_buffer[1121]
XU10702 MXL2HS $PINS OB=n588 S=FE_OFN150_FE_DBTN1_n7298 A=n8229 B=n8230
XU10703 INV1S $PINS O=n8231 I=Buffer/data_buffer[1129]
XU10704 MXL2HS $PINS OB=n580 S=FE_OFN150_FE_DBTN1_n7298 A=n8230 B=n8231
XU10705 INV1S $PINS O=n8232 I=Buffer/data_buffer[1137]
XU10706 MXL2HS $PINS OB=n572 S=FE_OFN148_FE_DBTN1_n7298 A=n8231 B=n8232
XU10707 INV1S $PINS O=n8233 I=Buffer/data_buffer[1145]
XU10708 MXL2HS $PINS OB=n564 S=FE_OFN279_FE_DBTN1_n7298 A=n8232 B=n8233
XU10709 INV1S $PINS O=n8234 I=Buffer/data_buffer[1153]
XU10710 MXL2HS $PINS OB=n556 S=FE_OFN217_FE_DBTN1_n7298 A=n8233 B=n8234
XU10711 INV1S $PINS O=n8236 I=Buffer/data_buffer[1161]
XU10712 MXL2HS $PINS OB=n548 S=FE_OFN158_FE_DBTN1_n7298 A=n8234 B=n8236
XU10713 INV1S $PINS O=n8237 I=Buffer/data_buffer[1169]
XU10714 MXL2HS $PINS OB=n540 S=FE_OFN156_FE_DBTN1_n7298 A=n8236 B=n8237
XU10715 INV1S $PINS O=n8238 I=Buffer/data_buffer[1177]
XU10716 MXL2HS $PINS OB=n532 S=FE_OFN216_FE_DBTN1_n7298 A=n8237 B=n8238
XU10717 INV1S $PINS O=n8239 I=Buffer/data_buffer[1185]
XU10718 MXL2HS $PINS OB=n524 S=FE_OFN103_FE_DBTN1_n7298 A=n8238 B=n8239
XU10719 INV1S $PINS O=n8240 I=Buffer/data_buffer[1193]
XU10720 MXL2HS $PINS OB=n516 S=FE_OFN103_FE_DBTN1_n7298 A=n8239 B=n8240
XU10721 MXL2HS $PINS OB=n508 S=FE_OFN106_FE_DBTN1_n7298 A=n8240 B=n8817
XU10722 INV1S $PINS O=n8243 I=weight_0_w[6]
XU10723 ND2 $PINS O=n8242 I1=i_data[6] I2=FE_OFN183_FE_DBTN1_n7298
XU10724 OAI12HS $PINS O=n453 A1=n8242 B1=FE_OFN183_FE_DBTN1_n7298 B2=n8243
XU10725 INV1S $PINS O=n8245 I=weight_0_w[14]
XU10726 MXL2HS $PINS OB=n452 S=FE_OFN241_FE_DBTN1_n7298 A=n8245 B=n8243
XU10727 INV1S $PINS O=n8246 I=weight_0_w[22]
XU10728 MXL2HS $PINS OB=n451 S=FE_OFN185_FE_DBTN1_n7298 A=n8246 B=n8245
XU10729 INV1S $PINS O=n8247 I=weight_1_w[6]
XU10730 MXL2HS $PINS OB=n450 S=FE_OFN65_FE_DBTN1_n7298 A=n8247 B=n8246
XU10731 INV1S $PINS O=n8248 I=weight_1_w[14]
XU10732 MXL2HS $PINS OB=n449 S=FE_OFN290_FE_DBTN1_n7298 A=n8248 B=n8247
XU10733 INV1S $PINS O=n8249 I=weight_1_w[22]
XU10734 MXL2HS $PINS OB=n448 S=FE_OFN290_FE_DBTN1_n7298 A=n8249 B=n8248
XU10735 INV1S $PINS O=n8903 I=weight_2_w[6]
XU10736 MXL2HS $PINS OB=n447 S=FE_OFN226_FE_DBTN1_n7298 A=n8903 B=n8249
XU10737 INV1S $PINS O=n8251 I=weight_0_w[2]
XU10738 ND2 $PINS O=n8250 I1=i_data[2] I2=FE_OFN125_FE_DBTN1_n7298
XU10739 OAI12HS $PINS O=n417 A1=n8250 B1=FE_OFN125_FE_DBTN1_n7298 B2=n8251
XU10740 INV1S $PINS O=n8253 I=weight_0_w[10]
XU10741 MXL2HS $PINS OB=n416 S=FE_OFN184_FE_DBTN1_n7298 A=n8253 B=n8251
XU10742 INV1S $PINS O=n8254 I=weight_0_w[18]
XU10743 MXL2HS $PINS OB=n415 S=FE_OFN185_FE_DBTN1_n7298 A=n8254 B=n8253
XU10744 INV1S $PINS O=n8255 I=weight_1_w[2]
XU10745 MXL2HS $PINS OB=n414 S=FE_OFN113_FE_DBTN1_n7298 A=n8255 B=n8254
XU10746 INV1S $PINS O=n8256 I=weight_1_w[10]
XU10747 MXL2HS $PINS OB=n413 S=FE_OFN228_FE_DBTN1_n7298 A=n8256 B=n8255
XU10748 INV1S $PINS O=n8257 I=weight_1_w[18]
XU10749 MXL2HS $PINS OB=n412 S=FE_OFN228_FE_DBTN1_n7298 A=n8257 B=n8256
XU10750 INV1S $PINS O=n8904 I=weight_2_w[2]
XU10751 MXL2HS $PINS OB=n411 S=FE_OFN57_FE_DBTN1_n7298 A=n8904 B=n8257
XU10752 INV1S $PINS O=n8259 I=Buffer/data_buffer[5]
XU10753 OAI12HS $PINS O=n1704 A1=n8258 B1=FE_OFN1245_n7298 B2=n8259
XU10754 INV1S $PINS O=n8261 I=Buffer/data_buffer[13]
XU10755 MXL2HS $PINS OB=n1696 S=FE_OFN239_FE_DBTN1_n7298 A=n8259 B=n8261
XU10756 INV1S $PINS O=n8262 I=Buffer/data_buffer[21]
XU10757 MXL2HS $PINS OB=n1688 S=FE_OFN239_FE_DBTN1_n7298 A=n8261 B=n8262
XU10758 INV1S $PINS O=n8263 I=Buffer/data_buffer[29]
XU10759 MXL2HS $PINS OB=n1680 S=FE_OFN184_FE_DBTN1_n7298 A=n8262 B=n8263
XU10760 MXL2HS $PINS OB=n1672 S=FE_OFN127_FE_DBTN1_n7298 A=n8263 B=n8264
XU10761 MXL2HS $PINS OB=n1664 S=FE_OFN126_FE_DBTN1_n7298 A=n8264 B=n8265
XU10762 MXL2HS $PINS OB=n1656 S=FE_OFN22_FE_DBTN1_n7298 A=n8265 B=n8266
XU10763 MXL2HS $PINS OB=n1648 S=FE_OFN190_FE_DBTN1_n7298 A=n8266 B=n8268
XU10764 MXL2HS $PINS OB=n1640 S=FE_OFN44_FE_DBTN1_n7298 A=n8268 B=n8269
XU10765 MXL2HS $PINS OB=n1632 S=FE_OFN131_FE_DBTN1_n7298 A=n8269 B=n8270
XU10766 INV1S $PINS O=n8271 I=Buffer/data_buffer[85]
XU10767 MXL2HS $PINS OB=n1624 S=FE_OFN251_FE_DBTN1_n7298 A=n8270 B=n8271
XU10768 INV1S $PINS O=n8272 I=Buffer/data_buffer[93]
XU10769 MXL2HS $PINS OB=n1616 S=FE_OFN250_FE_DBTN1_n7298 A=n8271 B=n8272
XU10770 INV1S $PINS O=n8273 I=Buffer/data_buffer[101]
XU10771 MXL2HS $PINS OB=n1608 S=FE_OFN292_FE_DBTN1_n7298 A=n8272 B=n8273
XU10772 INV1S $PINS O=n8275 I=Buffer/data_buffer[109]
XU10773 MXL2HS $PINS OB=n1600 S=FE_OFN63_FE_DBTN1_n7298 A=n8273 B=n8275
XU10774 MXL2HS $PINS OB=n1592 S=FE_OFN109_FE_DBTN1_n7298 A=n8275 B=n8276
XU10775 MXL2HS $PINS OB=n1584 S=FE_OFN162_FE_DBTN1_n7298 A=n8276 B=n8277
XU10776 MXL2HS $PINS OB=n1576 S=FE_OFN242_FE_DBTN1_n7298 A=n8277 B=n8278
XU10777 MXL2HS $PINS OB=n1568 S=FE_OFN80_FE_DBTN1_n7298 A=n8278 B=n8279
XU10778 MXL2HS $PINS OB=n1560 S=FE_OFN40_FE_DBTN1_n7298 A=n8279 B=n8280
XU10779 MXL2HS $PINS OB=n1552 S=FE_OFN9_FE_DBTN1_n7298 A=n8280 B=n8282
XU10780 MXL2HS $PINS OB=n1544 S=FE_OFN10_FE_DBTN1_n7298 A=n8282 B=n8283
XU10781 MXL2HS $PINS OB=n1536 S=FE_OFN192_FE_DBTN1_n7298 A=n8283 B=n8284
XU10782 MXL2HS $PINS OB=n1528 S=FE_OFN131_FE_DBTN1_n7298 A=n8284 B=n8285
XU10783 MXL2HS $PINS OB=n1520 S=FE_OFN333_FE_DBTN1_n7298 A=n8285 B=n8286
XU10784 MXL2HS $PINS OB=n1512 S=FE_OFN271_FE_DBTN1_n7298 A=n8286 B=n8287
XU10785 MXL2HS $PINS OB=n1504 S=FE_OFN305_FE_DBTN1_n7298 A=n8287 B=n8288
XU10786 MXL2HS $PINS OB=n1496 S=FE_OFN287_FE_DBTN1_n7298 A=n8288 B=n8290
XU10787 MXL2HS $PINS OB=n1488 S=FE_OFN233_FE_DBTN1_n7298 A=n8290 B=n8291
XU10788 MXL2HS $PINS OB=n1480 S=FE_OFN37_FE_DBTN1_n7298 A=n8291 B=n8293
XU10789 MXL2HS $PINS OB=n1472 S=FE_OFN73_FE_DBTN1_n7298 A=n8293 B=n8294
XU10790 INV1S $PINS O=n8295 I=Buffer/data_buffer[245]
XU10791 MXL2HS $PINS OB=n1464 S=FE_OFN123_FE_DBTN1_n7298 A=n8294 B=n8295
XU10792 INV1S $PINS O=n8296 I=Buffer/data_buffer[253]
XU10793 MXL2HS $PINS OB=n1456 S=FE_OFN179_FE_DBTN1_n7298 A=n8295 B=n8296
XU10794 INV1S $PINS O=n8297 I=Buffer/data_buffer[261]
XU10795 MXL2HS $PINS OB=n1448 S=FE_OFN179_FE_DBTN1_n7298 A=n8296 B=n8297
XU10796 INV1S $PINS O=n8298 I=Buffer/data_buffer[269]
XU10797 MXL2HS $PINS OB=n1440 S=FE_OFN220_FE_DBTN1_n7298 A=n8297 B=n8298
XU10798 INV1S $PINS O=n8299 I=Buffer/data_buffer[277]
XU10799 MXL2HS $PINS OB=n1432 S=FE_OFN160_FE_DBTN1_n7298 A=n8298 B=n8299
XU10800 INV1S $PINS O=n8300 I=Buffer/data_buffer[285]
XU10801 MXL2HS $PINS OB=n1424 S=FE_OFN104_FE_DBTN1_n7298 A=n8299 B=n8300
XU10802 INV1S $PINS O=n8301 I=Buffer/data_buffer[293]
XU10803 MXL2HS $PINS OB=n1416 S=FE_OFN222_FE_DBTN1_n7298 A=n8300 B=n8301
XU10804 INV1S $PINS O=n8302 I=Buffer/data_buffer[301]
XU10805 MXL2HS $PINS OB=n1408 S=FE_OFN107_FE_DBTN1_n7298 A=n8301 B=n8302
XU10806 INV1S $PINS O=n8304 I=Buffer/data_buffer[309]
XU10807 MXL2HS $PINS OB=n1400 S=FE_OFN62_FE_DBTN1_n7298 A=n8302 B=n8304
XU10808 INV1S $PINS O=n8305 I=Buffer/data_buffer[317]
XU10809 MXL2HS $PINS OB=n1392 S=FE_OFN308_FE_DBTN1_n7298 A=n8304 B=n8305
XU10810 INV1S $PINS O=n8306 I=Buffer/data_buffer[325]
XU10811 MXL2HS $PINS OB=n1384 S=FE_OFN99_FE_DBTN1_n7298 A=n8305 B=n8306
XU10812 INV1S $PINS O=n8307 I=Buffer/data_buffer[333]
XU10813 MXL2HS $PINS OB=n1376 S=FE_OFN99_FE_DBTN1_n7298 A=n8306 B=n8307
XU10814 MXL2HS $PINS OB=n1368 S=FE_OFN163_FE_DBTN1_n7298 A=n8307 B=n8308
XU10815 MXL2HS $PINS OB=n1360 S=FE_OFN162_FE_DBTN1_n7298 A=n8308 B=n8309
XU10816 MXL2HS $PINS OB=n1352 S=FE_OFN186_FE_DBTN1_n7298 A=n8309 B=n8311
XU10817 MXL2HS $PINS OB=n1344 S=FE_OFN80_FE_DBTN1_n7298 A=n8311 B=n8312
XU10818 MXL2HS $PINS OB=n1336 S=FE_OFN21_FE_DBTN1_n7298 A=n8312 B=n8313
XU10819 MXL2HS $PINS OB=n1328 S=FE_OFN79_FE_DBTN1_n7298 A=n8313 B=n8314
XU10820 MXL2HS $PINS OB=n1320 S=FE_OFN10_FE_DBTN1_n7298 A=n8314 B=n8315
XU10821 MXL2HS $PINS OB=n1312 S=FE_OFN192_FE_DBTN1_n7298 A=n8315 B=n8316
XU10822 MXL2HS $PINS OB=n1304 S=FE_OFN131_FE_DBTN1_n7298 A=n8316 B=n8318
XU10823 MXL2HS $PINS OB=n1296 S=FE_OFN86_FE_DBTN1_n7298 A=n8318 B=n8319
XU10824 INV1S $PINS O=n8320 I=Buffer/data_buffer[421]
XU10825 MXL2HS $PINS OB=n1288 S=FE_OFN327_FE_DBTN1_n7298 A=n8319 B=n8320
XU10826 INV1S $PINS O=n8321 I=Buffer/data_buffer[429]
XU10827 MXL2HS $PINS OB=n1280 S=FE_OFN326_FE_DBTN1_n7298 A=n8320 B=n8321
XU10828 INV1S $PINS O=n8322 I=Buffer/data_buffer[437]
XU10829 MXL2HS $PINS OB=n1272 S=FE_OFN325_FE_DBTN1_n7298 A=n8321 B=n8322
XU10830 INV1S $PINS O=n8323 I=Buffer/data_buffer[445]
XU10831 MXL2HS $PINS OB=n1264 S=FE_OFN325_FE_DBTN1_n7298 A=n8322 B=n8323
XU10832 INV1S $PINS O=n8325 I=Buffer/data_buffer[453]
XU10833 MXL2HS $PINS OB=n1256 S=FE_OFN325_FE_DBTN1_n7298 A=n8323 B=n8325
XU10834 INV1S $PINS O=n8326 I=Buffer/data_buffer[461]
XU10835 MXL2HS $PINS OB=n1248 S=FE_OFN55_FE_DBTN1_n7298 A=n8325 B=n8326
XU10836 INV1S $PINS O=n8327 I=Buffer/data_buffer[469]
XU10837 MXL2HS $PINS OB=n1240 S=FE_OFN92_FE_DBTN1_n7298 A=n8326 B=n8327
XU10838 INV1S $PINS O=n8328 I=Buffer/data_buffer[477]
XU10839 MXL2HS $PINS OB=n1232 S=FE_OFN92_FE_DBTN1_n7298 A=n8327 B=n8328
XU10840 INV1S $PINS O=n8329 I=Buffer/data_buffer[485]
XU10841 MXL2HS $PINS OB=n1224 S=FE_OFN255_FE_DBTN1_n7298 A=n8328 B=n8329
XU10842 INV1S $PINS O=n8330 I=Buffer/data_buffer[493]
XU10843 MXL2HS $PINS OB=n1216 S=FE_OFN154_FE_DBTN1_n7298 A=n8329 B=n8330
XU10844 INV1S $PINS O=n8332 I=Buffer/data_buffer[501]
XU10845 MXL2HS $PINS OB=n1208 S=FE_OFN155_FE_DBTN1_n7298 A=n8330 B=n8332
XU10846 INV1S $PINS O=n8333 I=Buffer/data_buffer[509]
XU10847 MXL2HS $PINS OB=n1200 S=FE_OFN155_FE_DBTN1_n7298 A=n8332 B=n8333
XU10848 INV1S $PINS O=n8334 I=Buffer/data_buffer[517]
XU10849 MXL2HS $PINS OB=n1192 S=FE_OFN214_FE_DBTN1_n7298 A=n8333 B=n8334
XU10850 INV1S $PINS O=n8335 I=Buffer/data_buffer[525]
XU10851 MXL2HS $PINS OB=n1184 S=FE_OFN274_FE_DBTN1_n7298 A=n8334 B=n8335
XU10852 MXL2HS $PINS OB=n1176 S=FE_OFN62_FE_DBTN1_n7298 A=n8335 B=n8336
XU10853 MXL2HS $PINS OB=n1168 S=FE_OFN287_FE_DBTN1_n7298 A=n8336 B=n8338
XU10854 MXL2HS $PINS OB=n1160 S=FE_OFN287_FE_DBTN1_n7298 A=n8338 B=n8340
XU10855 MXL2HS $PINS OB=n1152 S=FE_OFN233_FE_DBTN1_n7298 A=n8340 B=n8341
XU10856 MXL2HS $PINS OB=n1144 S=FE_OFN233_FE_DBTN1_n7298 A=n8341 B=n8342
XU10857 MXL2HS $PINS OB=n1136 S=FE_OFN122_FE_DBTN1_n7298 A=n8342 B=n8343
XU10858 INV1S $PINS O=n8344 I=Buffer/data_buffer[581]
XU10859 MXL2HS $PINS OB=n1128 S=FE_OFN182_FE_DBTN1_n7298 A=n8343 B=n8344
XU10860 INV1S $PINS O=n8346 I=Buffer/data_buffer[589]
XU10861 MXL2HS $PINS OB=n1120 S=FE_OFN182_FE_DBTN1_n7298 A=n8344 B=n8346
XU10862 INV1S $PINS O=n8347 I=Buffer/data_buffer[597]
XU10863 MXL2HS $PINS OB=n1112 S=FE_OFN182_FE_DBTN1_n7298 A=n8346 B=n8347
XU10864 INV1S $PINS O=n8348 I=Buffer/data_buffer[605]
XU10865 MXL2HS $PINS OB=n1104 S=FE_OFN238_FE_DBTN1_n7298 A=n8347 B=n8348
XU10866 INV1S $PINS O=n8349 I=Buffer/data_buffer[613]
XU10867 MXL2HS $PINS OB=n1096 S=FE_OFN119_FE_DBTN1_n7298 A=n8348 B=n8349
XU10868 INV1S $PINS O=n8350 I=Buffer/data_buffer[621]
XU10869 MXL2HS $PINS OB=n1088 S=FE_OFN119_FE_DBTN1_n7298 A=n8349 B=n8350
XU10870 INV1S $PINS O=n8351 I=Buffer/data_buffer[629]
XU10871 MXL2HS $PINS OB=n1080 S=FE_OFN35_FE_DBTN1_n7298 A=n8350 B=n8351
XU10872 INV1S $PINS O=n8353 I=Buffer/data_buffer[637]
XU10873 MXL2HS $PINS OB=n1072 S=FE_OFN35_FE_DBTN1_n7298 A=n8351 B=n8353
XU10874 INV1S $PINS O=n8354 I=Buffer/data_buffer[645]
XU10875 MXL2HS $PINS OB=n1064 S=FE_OFN35_FE_DBTN1_n7298 A=n8353 B=n8354
XU10876 INV1S $PINS O=n8355 I=Buffer/data_buffer[653]
XU10877 MXL2HS $PINS OB=n1056 S=FE_OFN35_FE_DBTN1_n7298 A=n8354 B=n8355
XU10878 INV1S $PINS O=n8356 I=Buffer/data_buffer[661]
XU10879 MXL2HS $PINS OB=n1048 S=FE_OFN230_FE_DBTN1_n7298 A=n8355 B=n8356
XU10880 INV1S $PINS O=n8357 I=Buffer/data_buffer[669]
XU10881 MXL2HS $PINS OB=n1040 S=FE_OFN230_FE_DBTN1_n7298 A=n8356 B=n8357
XU10882 INV1S $PINS O=n8358 I=Buffer/data_buffer[677]
XU10883 MXL2HS $PINS OB=n1032 S=FE_OFN170_FE_DBTN1_n7298 A=n8357 B=n8358
XU10884 INV1S $PINS O=n8360 I=Buffer/data_buffer[685]
XU10885 MXL2HS $PINS OB=n1024 S=FE_OFN170_FE_DBTN1_n7298 A=n8358 B=n8360
XU10886 INV1S $PINS O=n8361 I=Buffer/data_buffer[693]
XU10887 MXL2HS $PINS OB=n1016 S=FE_OFN170_FE_DBTN1_n7298 A=n8360 B=n8361
XU10888 INV1S $PINS O=n8362 I=Buffer/data_buffer[701]
XU10889 MXL2HS $PINS OB=n1008 S=FE_OFN167_FE_DBTN1_n7298 A=n8361 B=n8362
XU10890 INV1S $PINS O=n8363 I=Buffer/data_buffer[709]
XU10891 MXL2HS $PINS OB=n1000 S=FE_OFN167_FE_DBTN1_n7298 A=n8362 B=n8363
XU10892 INV1S $PINS O=n8364 I=Buffer/data_buffer[717]
XU10893 MXL2HS $PINS OB=n992 S=FE_OFN114_FE_DBTN1_n7298 A=n8363 B=n8364
XU10894 INV1S $PINS O=n8365 I=Buffer/data_buffer[725]
XU10895 MXL2HS $PINS OB=n984 S=FE_OFN278_FE_DBTN1_n7298 A=n8364 B=n8365
XU10896 INV1S $PINS O=n8367 I=Buffer/data_buffer[733]
XU10897 MXL2HS $PINS OB=n976 S=FE_OFN158_FE_DBTN1_n7298 A=n8365 B=n8367
XU10898 INV1S $PINS O=n8368 I=Buffer/data_buffer[741]
XU10899 MXL2HS $PINS OB=n968 S=FE_OFN156_FE_DBTN1_n7298 A=n8367 B=n8368
XU10900 INV1S $PINS O=n8369 I=Buffer/data_buffer[749]
XU10901 MXL2HS $PINS OB=n960 S=FE_OFN324_FE_DBTN1_n7298 A=n8368 B=n8369
XU10902 INV1S $PINS O=n8370 I=Buffer/data_buffer[757]
XU10903 MXL2HS $PINS OB=n952 S=FE_OFN214_FE_DBTN1_n7298 A=n8369 B=n8370
XU10904 INV1S $PINS O=n8371 I=Buffer/data_buffer[765]
XU10905 MXL2HS $PINS OB=n944 S=FE_OFN273_FE_DBTN1_n7298 A=n8370 B=n8371
XU10906 INV1S $PINS O=n8372 I=Buffer/data_buffer[773]
XU10907 MXL2HS $PINS OB=n936 S=FE_OFN213_FE_DBTN1_n7298 A=n8371 B=n8372
XU10908 INV1S $PINS O=n8374 I=Buffer/data_buffer[781]
XU10909 MXL2HS $PINS OB=n928 S=FE_OFN288_FE_DBTN1_n7298 A=n8372 B=n8374
XU10910 MXL2HS $PINS OB=n920 S=FE_OFN63_FE_DBTN1_n7298 A=n8374 B=n8375
XU10911 MXL2HS $PINS OB=n912 S=FE_OFN162_FE_DBTN1_n7298 A=n8375 B=n8376
XU10912 MXL2HS $PINS OB=n904 S=FE_OFN186_FE_DBTN1_n7298 A=n8376 B=n8377
XU10913 MXL2HS $PINS OB=n896 S=FE_OFN80_FE_DBTN1_n7298 A=n8377 B=n8378
XU10914 MXL2HS $PINS OB=n888 S=FE_OFN41_FE_DBTN1_n7298 A=n8378 B=n8380
XU10915 MXL2HS $PINS OB=n880 S=FE_OFN41_FE_DBTN1_n7298 A=n8380 B=n8382
XU10916 INV1S $PINS O=n8383 I=Buffer/data_buffer[837]
XU10917 MXL2HS $PINS OB=n872 S=FE_OFN81_FE_DBTN1_n7298 A=n8382 B=n8383
XU10918 INV1S $PINS O=n8384 I=Buffer/data_buffer[845]
XU10919 MXL2HS $PINS OB=n864 S=FE_OFN129_FE_DBTN1_n7298 A=n8383 B=n8384
XU10920 INV1S $PINS O=n8385 I=Buffer/data_buffer[853]
XU10921 MXL2HS $PINS OB=n856 S=FE_OFN46_FE_DBTN1_n7298 A=n8384 B=n8385
XU10922 INV1S $PINS O=n8386 I=Buffer/data_buffer[861]
XU10923 MXL2HS $PINS OB=n848 S=FE_OFN87_FE_DBTN1_n7298 A=n8385 B=n8386
XU10924 INV1S $PINS O=n8388 I=Buffer/data_buffer[869]
XU10925 MXL2HS $PINS OB=n840 S=FE_OFN295_FE_DBTN1_n7298 A=n8386 B=n8388
XU10926 INV1S $PINS O=n8390 I=Buffer/data_buffer[877]
XU10927 MXL2HS $PINS OB=n832 S=FE_OFN295_FE_DBTN1_n7298 A=n8388 B=n8390
XU10928 INV1S $PINS O=n8391 I=Buffer/data_buffer[885]
XU10929 MXL2HS $PINS OB=n824 S=FE_OFN253_FE_DBTN1_n7298 A=n8390 B=n8391
XU10930 INV1S $PINS O=n8392 I=Buffer/data_buffer[893]
XU10931 MXL2HS $PINS OB=n816 S=FE_OFN49_FE_DBTN1_n7298 A=n8391 B=n8392
XU10932 INV1S $PINS O=n8393 I=Buffer/data_buffer[901]
XU10933 MXL2HS $PINS OB=n808 S=FE_OFN49_FE_DBTN1_n7298 A=n8392 B=n8393
XU10934 INV1S $PINS O=n8394 I=Buffer/data_buffer[909]
XU10935 MXL2HS $PINS OB=n800 S=FE_OFN49_FE_DBTN1_n7298 A=n8393 B=n8394
XU10936 INV1S $PINS O=n8396 I=Buffer/data_buffer[917]
XU10937 MXL2HS $PINS OB=n792 S=FE_OFN26_FE_DBTN1_n7298 A=n8394 B=n8396
XU10938 INV1S $PINS O=n8397 I=Buffer/data_buffer[925]
XU10939 MXL2HS $PINS OB=n784 S=FE_OFN51_FE_DBTN1_n7298 A=n8396 B=n8397
XU10940 INV1S $PINS O=n8398 I=Buffer/data_buffer[933]
XU10941 MXL2HS $PINS OB=n776 S=FE_OFN51_FE_DBTN1_n7298 A=n8397 B=n8398
XU10942 INV1S $PINS O=n8399 I=Buffer/data_buffer[941]
XU10943 MXL2HS $PINS OB=n768 S=FE_OFN51_FE_DBTN1_n7298 A=n8398 B=n8399
XU10944 INV1S $PINS O=n8400 I=Buffer/data_buffer[949]
XU10945 MXL2HS $PINS OB=n760 S=FE_OFN139_FE_DBTN1_n7298 A=n8399 B=n8400
XU10946 INV1S $PINS O=n8401 I=Buffer/data_buffer[957]
XU10947 MXL2HS $PINS OB=n752 S=FE_OFN139_FE_DBTN1_n7298 A=n8400 B=n8401
XU10948 INV1S $PINS O=n8403 I=Buffer/data_buffer[965]
XU10949 MXL2HS $PINS OB=n744 S=FE_OFN265_FE_DBTN1_n7298 A=n8401 B=n8403
XU10950 INV1S $PINS O=n8404 I=Buffer/data_buffer[973]
XU10951 MXL2HS $PINS OB=n736 S=FE_OFN206_FE_DBTN1_n7298 A=n8403 B=n8404
XU10952 INV1S $PINS O=n8405 I=Buffer/data_buffer[981]
XU10953 MXL2HS $PINS OB=n728 S=FE_OFN206_FE_DBTN1_n7298 A=n8404 B=n8405
XU10954 INV1S $PINS O=n8406 I=Buffer/data_buffer[989]
XU10955 MXL2HS $PINS OB=n720 S=FE_OFN207_FE_DBTN1_n7298 A=n8405 B=n8406
XU10956 INV1S $PINS O=n8407 I=Buffer/data_buffer[997]
XU10957 MXL2HS $PINS OB=n712 S=FE_OFN267_FE_DBTN1_n7298 A=n8406 B=n8407
XU10958 INV1S $PINS O=n8408 I=Buffer/data_buffer[1005]
XU10959 MXL2HS $PINS OB=n704 S=FE_OFN267_FE_DBTN1_n7298 A=n8407 B=n8408
XU10960 INV1S $PINS O=n8410 I=Buffer/data_buffer[1013]
XU10961 MXL2HS $PINS OB=n696 S=FE_OFN203_FE_DBTN1_n7298 A=n8408 B=n8410
XU10962 INV1S $PINS O=n8411 I=Buffer/data_buffer[1021]
XU10963 MXL2HS $PINS OB=n688 S=FE_OFN203_FE_DBTN1_n7298 A=n8410 B=n8411
XU10964 INV1S $PINS O=n8412 I=Buffer/data_buffer[1029]
XU10965 MXL2HS $PINS OB=n680 S=FE_OFN144_FE_DBTN1_n7298 A=n8411 B=n8412
XU10966 INV1S $PINS O=n8413 I=Buffer/data_buffer[1037]
XU10967 MXL2HS $PINS OB=n672 S=FE_OFN204_FE_DBTN1_n7298 A=n8412 B=n8413
XU10968 INV1S $PINS O=n8414 I=Buffer/data_buffer[1045]
XU10969 MXL2HS $PINS OB=n664 S=FE_OFN145_FE_DBTN1_n7298 A=n8413 B=n8414
XU10970 INV1S $PINS O=n8415 I=Buffer/data_buffer[1053]
XU10971 MXL2HS $PINS OB=n656 S=FE_OFN205_FE_DBTN1_n7298 A=n8414 B=n8415
XU10972 INV1S $PINS O=n8417 I=Buffer/data_buffer[1061]
XU10973 MXL2HS $PINS OB=n648 S=FE_OFN205_FE_DBTN1_n7298 A=n8415 B=n8417
XU10974 INV1S $PINS O=n8418 I=Buffer/data_buffer[1069]
XU10975 MXL2HS $PINS OB=n640 S=FE_OFN205_FE_DBTN1_n7298 A=n8417 B=n8418
XU10976 INV1S $PINS O=n8419 I=Buffer/data_buffer[1077]
XU10977 MXL2HS $PINS OB=n632 S=FE_OFN301_FE_DBTN1_n7298 A=n8418 B=n8419
XU10978 INV1S $PINS O=n8420 I=Buffer/data_buffer[1085]
XU10979 MXL2HS $PINS OB=n624 S=FE_OFN301_FE_DBTN1_n7298 A=n8419 B=n8420
XU10980 INV1S $PINS O=n8421 I=Buffer/data_buffer[1093]
XU10981 MXL2HS $PINS OB=n616 S=FE_OFN301_FE_DBTN1_n7298 A=n8420 B=n8421
XU10982 INV1S $PINS O=n8422 I=Buffer/data_buffer[1101]
XU10983 MXL2HS $PINS OB=n608 S=FE_OFN268_FE_DBTN1_n7298 A=n8421 B=n8422
XU10984 INV1S $PINS O=n8424 I=Buffer/data_buffer[1109]
XU10985 MXL2HS $PINS OB=n600 S=FE_OFN208_FE_DBTN1_n7298 A=n8422 B=n8424
XU10986 INV1S $PINS O=n8426 I=Buffer/data_buffer[1117]
XU10987 MXL2HS $PINS OB=n592 S=FE_OFN208_FE_DBTN1_n7298 A=n8424 B=n8426
XU10988 INV1S $PINS O=n8427 I=Buffer/data_buffer[1125]
XU10989 MXL2HS $PINS OB=n584 S=FE_OFN150_FE_DBTN1_n7298 A=n8426 B=n8427
XU10990 INV1S $PINS O=n8428 I=Buffer/data_buffer[1133]
XU10991 MXL2HS $PINS OB=n576 S=FE_OFN97_FE_DBTN1_n7298 A=n8427 B=n8428
XU10992 INV1S $PINS O=n8429 I=Buffer/data_buffer[1141]
XU10993 MXL2HS $PINS OB=n568 S=FE_OFN148_FE_DBTN1_n7298 A=n8428 B=n8429
XU10994 INV1S $PINS O=n8430 I=Buffer/data_buffer[1149]
XU10995 MXL2HS $PINS OB=n560 S=FE_OFN217_FE_DBTN1_n7298 A=n8429 B=n8430
XU10996 INV1S $PINS O=n8432 I=Buffer/data_buffer[1157]
XU10997 MXL2HS $PINS OB=n552 S=FE_OFN217_FE_DBTN1_n7298 A=n8430 B=n8432
XU10998 INV1S $PINS O=n8434 I=Buffer/data_buffer[1165]
XU10999 MXL2HS $PINS OB=n544 S=FE_OFN217_FE_DBTN1_n7298 A=n8432 B=n8434
XU11000 INV1S $PINS O=n8435 I=Buffer/data_buffer[1173]
XU11001 MXL2HS $PINS OB=n536 S=FE_OFN156_FE_DBTN1_n7298 A=n8434 B=n8435
XU11002 INV1S $PINS O=n8436 I=Buffer/data_buffer[1181]
XU11003 MXL2HS $PINS OB=n528 S=FE_OFN276_FE_DBTN1_n7298 A=n8435 B=n8436
XU11004 INV1S $PINS O=n8437 I=Buffer/data_buffer[1189]
XU11005 MXL2HS $PINS OB=n520 S=FE_OFN61_FE_DBTN1_n7298 A=n8436 B=n8437
XU11006 INV1S $PINS O=n8438 I=Buffer/data_buffer[1197]
XU11007 MXL2HS $PINS OB=n512 S=FE_OFN103_FE_DBTN1_n7298 A=n8437 B=n8438
XU11008 MXL2HS $PINS OB=n504 S=FE_OFN222_FE_DBTN1_n7298 A=n8438 B=n8821
XU11009 INV1S $PINS O=n8442 I=Buffer/data_buffer[4]
XU11010 OAI12HS $PINS O=n1705 A1=n8439 B1=FE_OFN1245_n7298 B2=n8442
XU11011 INV1S $PINS O=n8443 I=Buffer/data_buffer[12]
XU11012 MXL2HS $PINS OB=n1697 S=FE_OFN239_FE_DBTN1_n7298 A=n8442 B=n8443
XU11013 INV1S $PINS O=n8444 I=Buffer/data_buffer[20]
XU11014 MXL2HS $PINS OB=n1689 S=FE_OFN239_FE_DBTN1_n7298 A=n8443 B=n8444
XU11015 INV1S $PINS O=n8445 I=Buffer/data_buffer[28]
XU11016 MXL2HS $PINS OB=n1681 S=FE_OFN127_FE_DBTN1_n7298 A=n8444 B=n8445
XU11017 MXL2HS $PINS OB=n1673 S=FE_OFN127_FE_DBTN1_n7298 A=n8445 B=n8446
XU11018 MXL2HS $PINS OB=n1665 S=FE_OFN126_FE_DBTN1_n7298 A=n8446 B=n8447
XU11019 MXL2HS $PINS OB=n1657 S=FE_OFN126_FE_DBTN1_n7298 A=n8447 B=n8449
XU11020 MXL2HS $PINS OB=n1649 S=FE_OFN190_FE_DBTN1_n7298 A=n8449 B=n8450
XU11021 MXL2HS $PINS OB=n1641 S=FE_OFN249_FE_DBTN1_n7298 A=n8450 B=n8451
XU11022 MXL2HS $PINS OB=n1633 S=FE_OFN131_FE_DBTN1_n7298 A=n8451 B=n8452
XU11023 INV1S $PINS O=n8453 I=Buffer/data_buffer[84]
XU11024 MXL2HS $PINS OB=n1625 S=FE_OFN133_FE_DBTN1_n7298 A=n8452 B=n8453
XU11025 INV1S $PINS O=n8454 I=Buffer/data_buffer[92]
XU11026 MXL2HS $PINS OB=n1617 S=FE_OFN315_FE_DBTN1_n7298 A=n8453 B=n8454
XU11027 INV1S $PINS O=n8456 I=Buffer/data_buffer[100]
XU11028 MXL2HS $PINS OB=n1609 S=FE_OFN292_FE_DBTN1_n7298 A=n8454 B=n8456
XU11029 INV1S $PINS O=n8457 I=Buffer/data_buffer[108]
XU11030 MXL2HS $PINS OB=n1601 S=FE_OFN63_FE_DBTN1_n7298 A=n8456 B=n8457
XU11031 MXL2HS $PINS OB=n1593 S=FE_OFN109_FE_DBTN1_n7298 A=n8457 B=n8458
XU11032 MXL2HS $PINS OB=n1585 S=FE_OFN242_FE_DBTN1_n7298 A=n8458 B=n8459
XU11033 MXL2HS $PINS OB=n1577 S=FE_OFN80_FE_DBTN1_n7298 A=n8459 B=n8460
XU11034 MXL2HS $PINS OB=n1569 S=FE_OFN41_FE_DBTN1_n7298 A=n8460 B=n8461
XU11035 MXL2HS $PINS OB=n1561 S=FE_OFN21_FE_DBTN1_n7298 A=n8461 B=n8463
XU11036 MXL2HS $PINS OB=n1553 S=FE_OFN2_FE_DBTN1_n7298 A=n8463 B=n8464
XU11037 MXL2HS $PINS OB=n1545 S=FE_OFN22_FE_DBTN1_n7298 A=n8464 B=n8465
XU11038 MXL2HS $PINS OB=n1537 S=FE_OFN190_FE_DBTN1_n7298 A=n8465 B=n8466
XU11039 MXL2HS $PINS OB=n1529 S=FE_OFN249_FE_DBTN1_n7298 A=n8466 B=n8467
XU11040 MXL2HS $PINS OB=n1521 S=FE_OFN333_FE_DBTN1_n7298 A=n8467 B=n8468
XU11041 MXL2HS $PINS OB=n1513 S=FE_OFN212_FE_DBTN1_n7298 A=n8468 B=n8470
XU11042 MXL2HS $PINS OB=n1505 S=FE_OFN270_FE_DBTN1_n7298 A=n8470 B=n8472
XU11043 MXL2HS $PINS OB=n1497 S=FE_OFN68_FE_DBTN1_n7298 A=n8472 B=n8473
XU11044 MXL2HS $PINS OB=n1489 S=FE_OFN70_FE_DBTN1_n7298 A=n8473 B=n8474
XU11045 MXL2HS $PINS OB=n1481 S=FE_OFN118_FE_DBTN1_n7298 A=n8474 B=n8475
XU11046 MXL2HS $PINS OB=n1473 S=FE_OFN122_FE_DBTN1_n7298 A=n8475 B=n8476
XU11047 INV1S $PINS O=n8478 I=Buffer/data_buffer[244]
XU11048 MXL2HS $PINS OB=n1465 S=FE_OFN73_FE_DBTN1_n7298 A=n8476 B=n8478
XU11049 INV1S $PINS O=n8480 I=Buffer/data_buffer[252]
XU11050 MXL2HS $PINS OB=n1457 S=FE_OFN179_FE_DBTN1_n7298 A=n8478 B=n8480
XU11051 INV1S $PINS O=n8482 I=Buffer/data_buffer[260]
XU11052 MXL2HS $PINS OB=n1449 S=FE_OFN179_FE_DBTN1_n7298 A=n8480 B=n8482
XU11053 INV1S $PINS O=n8484 I=Buffer/data_buffer[268]
XU11054 MXL2HS $PINS OB=n1441 S=FE_OFN220_FE_DBTN1_n7298 A=n8482 B=n8484
XU11055 INV1S $PINS O=n8485 I=Buffer/data_buffer[276]
XU11056 MXL2HS $PINS OB=n1433 S=FE_OFN160_FE_DBTN1_n7298 A=n8484 B=n8485
XU11057 INV1S $PINS O=n8486 I=Buffer/data_buffer[284]
XU11058 MXL2HS $PINS OB=n1425 S=FE_OFN103_FE_DBTN1_n7298 A=n8485 B=n8486
XU11059 INV1S $PINS O=n8487 I=Buffer/data_buffer[292]
XU11060 MXL2HS $PINS OB=n1417 S=FE_OFN284_FE_DBTN1_n7298 A=n8486 B=n8487
XU11061 INV1S $PINS O=n8488 I=Buffer/data_buffer[300]
XU11062 MXL2HS $PINS OB=n1409 S=FE_OFN107_FE_DBTN1_n7298 A=n8487 B=n8488
XU11063 INV1S $PINS O=n8489 I=Buffer/data_buffer[308]
XU11064 MXL2HS $PINS OB=n1401 S=FE_OFN306_FE_DBTN1_n7298 A=n8488 B=n8489
XU11065 INV1S $PINS O=n8491 I=Buffer/data_buffer[316]
XU11066 MXL2HS $PINS OB=n1393 S=FE_OFN308_FE_DBTN1_n7298 A=n8489 B=n8491
XU11067 INV1S $PINS O=n8492 I=Buffer/data_buffer[324]
XU11068 MXL2HS $PINS OB=n1385 S=FE_OFN99_FE_DBTN1_n7298 A=n8491 B=n8492
XU11069 INV1S $PINS O=n8493 I=Buffer/data_buffer[332]
XU11070 MXL2HS $PINS OB=n1377 S=FE_OFN163_FE_DBTN1_n7298 A=n8492 B=n8493
XU11071 MXL2HS $PINS OB=n1369 S=FE_OFN163_FE_DBTN1_n7298 A=n8493 B=n8494
XU11072 MXL2HS $PINS OB=n1361 S=FE_OFN162_FE_DBTN1_n7298 A=n8494 B=n8495
XU11073 MXL2HS $PINS OB=n1353 S=FE_OFN242_FE_DBTN1_n7298 A=n8495 B=n8496
XU11074 MXL2HS $PINS OB=n1345 S=FE_OFN41_FE_DBTN1_n7298 A=n8496 B=n8498
XU11075 MXL2HS $PINS OB=n1337 S=FE_OFN40_FE_DBTN1_n7298 A=n8498 B=n8499
XU11076 MXL2HS $PINS OB=n1329 S=FE_OFN9_FE_DBTN1_n7298 A=n8499 B=n8500
XU11077 MXL2HS $PINS OB=n1321 S=FE_OFN22_FE_DBTN1_n7298 A=n8500 B=n8501
XU11078 MXL2HS $PINS OB=n1313 S=FE_OFN190_FE_DBTN1_n7298 A=n8501 B=n8502
XU11079 MXL2HS $PINS OB=n1305 S=FE_OFN249_FE_DBTN1_n7298 A=n8502 B=n8503
XU11080 MXL2HS $PINS OB=n1297 S=FE_OFN86_FE_DBTN1_n7298 A=n8503 B=n8505
XU11081 INV1S $PINS O=n8506 I=Buffer/data_buffer[420]
XU11082 MXL2HS $PINS OB=n1289 S=FE_OFN327_FE_DBTN1_n7298 A=n8505 B=n8506
XU11083 INV1S $PINS O=n8507 I=Buffer/data_buffer[428]
XU11084 MXL2HS $PINS OB=n1281 S=FE_OFN318_FE_DBTN1_n7298 A=n8506 B=n8507
XU11085 INV1S $PINS O=n8508 I=Buffer/data_buffer[436]
XU11086 MXL2HS $PINS OB=n1273 S=FE_OFN317_FE_DBTN1_n7298 A=n8507 B=n8508
XU11087 INV1S $PINS O=n8509 I=Buffer/data_buffer[444]
XU11088 MXL2HS $PINS OB=n1265 S=FE_OFN325_FE_DBTN1_n7298 A=n8508 B=n8509
XU11089 INV1S $PINS O=n8510 I=Buffer/data_buffer[452]
XU11090 MXL2HS $PINS OB=n1257 S=FE_OFN329_FE_DBTN1_n7298 A=n8509 B=n8510
XU11091 INV1S $PINS O=n8512 I=Buffer/data_buffer[460]
XU11092 MXL2HS $PINS OB=n1249 S=FE_OFN329_FE_DBTN1_n7298 A=n8510 B=n8512
XU11093 INV1S $PINS O=n8513 I=Buffer/data_buffer[468]
XU11094 MXL2HS $PINS OB=n1241 S=FE_OFN296_FE_DBTN1_n7298 A=n8512 B=n8513
XU11095 INV1S $PINS O=n8514 I=Buffer/data_buffer[476]
XU11096 MXL2HS $PINS OB=n1233 S=FE_OFN296_FE_DBTN1_n7298 A=n8513 B=n8514
XU11097 INV1S $PINS O=n8515 I=Buffer/data_buffer[484]
XU11098 MXL2HS $PINS OB=n1225 S=FE_OFN255_FE_DBTN1_n7298 A=n8514 B=n8515
XU11099 INV1S $PINS O=n8516 I=Buffer/data_buffer[492]
XU11100 MXL2HS $PINS OB=n1217 S=FE_OFN154_FE_DBTN1_n7298 A=n8515 B=n8516
XU11101 INV1S $PINS O=n8517 I=Buffer/data_buffer[500]
XU11102 MXL2HS $PINS OB=n1209 S=FE_OFN100_FE_DBTN1_n7298 A=n8516 B=n8517
XU11103 INV1S $PINS O=n8519 I=Buffer/data_buffer[508]
XU11104 MXL2HS $PINS OB=n1201 S=FE_OFN100_FE_DBTN1_n7298 A=n8517 B=n8519
XU11105 INV1S $PINS O=n8520 I=Buffer/data_buffer[516]
XU11106 MXL2HS $PINS OB=n1193 S=FE_OFN59_FE_DBTN1_n7298 A=n8519 B=n8520
XU11107 INV1S $PINS O=n8521 I=Buffer/data_buffer[524]
XU11108 MXL2HS $PINS OB=n1185 S=FE_OFN310_FE_DBTN1_n7298 A=n8520 B=n8521
XU11109 MXL2HS $PINS OB=n1177 S=FE_OFN209_FE_DBTN1_n7298 A=n8521 B=n8522
XU11110 MXL2HS $PINS OB=n1169 S=FE_OFN210_FE_DBTN1_n7298 A=n8522 B=n8523
XU11111 MXL2HS $PINS OB=n1161 S=FE_OFN116_FE_DBTN1_n7298 A=n8523 B=n8524
XU11112 MXL2HS $PINS OB=n1153 S=FE_OFN70_FE_DBTN1_n7298 A=n8524 B=n8526
XU11113 MXL2HS $PINS OB=n1145 S=FE_OFN173_FE_DBTN1_n7298 A=n8526 B=n8527
XU11114 MXL2HS $PINS OB=n1137 S=FE_OFN180_FE_DBTN1_n7298 A=n8527 B=n8528
XU11115 INV1S $PINS O=n8529 I=Buffer/data_buffer[580]
XU11116 MXL2HS $PINS OB=n1129 S=FE_OFN181_FE_DBTN1_n7298 A=n8528 B=n8529
XU11117 INV1S $PINS O=n8530 I=Buffer/data_buffer[588]
XU11118 MXL2HS $PINS OB=n1121 S=FE_OFN238_FE_DBTN1_n7298 A=n8529 B=n8530
XU11119 INV1S $PINS O=n8531 I=Buffer/data_buffer[596]
XU11120 MXL2HS $PINS OB=n1113 S=FE_OFN236_FE_DBTN1_n7298 A=n8530 B=n8531
XU11121 INV1S $PINS O=n8533 I=Buffer/data_buffer[604]
XU11122 MXL2HS $PINS OB=n1105 S=FE_OFN235_FE_DBTN1_n7298 A=n8531 B=n8533
XU11123 INV1S $PINS O=n8534 I=Buffer/data_buffer[612]
XU11124 MXL2HS $PINS OB=n1097 S=FE_OFN178_FE_DBTN1_n7298 A=n8533 B=n8534
XU11125 INV1S $PINS O=n8535 I=Buffer/data_buffer[620]
XU11126 MXL2HS $PINS OB=n1089 S=FE_OFN176_FE_DBTN1_n7298 A=n8534 B=n8535
XU11127 INV1S $PINS O=n8536 I=Buffer/data_buffer[628]
XU11128 MXL2HS $PINS OB=n1081 S=FE_OFN176_FE_DBTN1_n7298 A=n8535 B=n8536
XU11129 INV1S $PINS O=n8537 I=Buffer/data_buffer[636]
XU11130 MXL2HS $PINS OB=n1073 S=FE_OFN234_FE_DBTN1_n7298 A=n8536 B=n8537
XU11131 INV1S $PINS O=n8538 I=Buffer/data_buffer[644]
XU11132 MXL2HS $PINS OB=n1065 S=FE_OFN234_FE_DBTN1_n7298 A=n8537 B=n8538
XU11133 INV1S $PINS O=n8540 I=Buffer/data_buffer[652]
XU11134 MXL2HS $PINS OB=n1057 S=FE_OFN234_FE_DBTN1_n7298 A=n8538 B=n8540
XU11135 INV1S $PINS O=n8541 I=Buffer/data_buffer[660]
XU11136 MXL2HS $PINS OB=n1049 S=FE_OFN229_FE_DBTN1_n7298 A=n8540 B=n8541
XU11137 INV1S $PINS O=n8542 I=Buffer/data_buffer[668]
XU11138 MXL2HS $PINS OB=n1041 S=FE_OFN229_FE_DBTN1_n7298 A=n8541 B=n8542
XU11139 INV1S $PINS O=n8543 I=Buffer/data_buffer[676]
XU11140 MXL2HS $PINS OB=n1033 S=FE_OFN229_FE_DBTN1_n7298 A=n8542 B=n8543
XU11141 INV1S $PINS O=n8544 I=Buffer/data_buffer[684]
XU11142 MXL2HS $PINS OB=n1025 S=FE_OFN169_FE_DBTN1_n7298 A=n8543 B=n8544
XU11143 INV1S $PINS O=n8545 I=Buffer/data_buffer[692]
XU11144 MXL2HS $PINS OB=n1017 S=FE_OFN67_FE_DBTN1_n7298 A=n8544 B=n8545
XU11145 INV1S $PINS O=n8547 I=Buffer/data_buffer[700]
XU11146 MXL2HS $PINS OB=n1009 S=FE_OFN33_FE_DBTN1_n7298 A=n8545 B=n8547
XU11147 INV1S $PINS O=n8548 I=Buffer/data_buffer[708]
XU11148 MXL2HS $PINS OB=n1001 S=FE_OFN15_FE_DBTN1_n7298 A=n8547 B=n8548
XU11149 INV1S $PINS O=n8549 I=Buffer/data_buffer[716]
XU11150 MXL2HS $PINS OB=n993 S=FE_OFN15_FE_DBTN1_n7298 A=n8548 B=n8549
XU11151 INV1S $PINS O=n8550 I=Buffer/data_buffer[724]
XU11152 MXL2HS $PINS OB=n985 S=FE_OFN218_FE_DBTN1_n7298 A=n8549 B=n8550
XU11153 INV1S $PINS O=n8551 I=Buffer/data_buffer[732]
XU11154 MXL2HS $PINS OB=n977 S=FE_OFN158_FE_DBTN1_n7298 A=n8550 B=n8551
XU11155 INV1S $PINS O=n8552 I=Buffer/data_buffer[740]
XU11156 MXL2HS $PINS OB=n969 S=FE_OFN216_FE_DBTN1_n7298 A=n8551 B=n8552
XU11157 INV1S $PINS O=n8554 I=Buffer/data_buffer[748]
XU11158 MXL2HS $PINS OB=n961 S=FE_OFN313_FE_DBTN1_n7298 A=n8552 B=n8554
XU11159 INV1S $PINS O=n8555 I=Buffer/data_buffer[756]
XU11160 MXL2HS $PINS OB=n953 S=FE_OFN214_FE_DBTN1_n7298 A=n8554 B=n8555
XU11161 INV1S $PINS O=n8556 I=Buffer/data_buffer[764]
XU11162 MXL2HS $PINS OB=n945 S=FE_OFN213_FE_DBTN1_n7298 A=n8555 B=n8556
XU11163 INV1S $PINS O=n8557 I=Buffer/data_buffer[772]
XU11164 MXL2HS $PINS OB=n937 S=FE_OFN213_FE_DBTN1_n7298 A=n8556 B=n8557
XU11165 INV1S $PINS O=n8558 I=Buffer/data_buffer[780]
XU11166 MXL2HS $PINS OB=n929 S=FE_OFN288_FE_DBTN1_n7298 A=n8557 B=n8558
XU11167 MXL2HS $PINS OB=n921 S=FE_OFN63_FE_DBTN1_n7298 A=n8558 B=n8559
XU11168 MXL2HS $PINS OB=n913 S=FE_OFN162_FE_DBTN1_n7298 A=n8559 B=n8561
XU11169 MXL2HS $PINS OB=n905 S=FE_OFN186_FE_DBTN1_n7298 A=n8561 B=n8563
XU11170 MXL2HS $PINS OB=n897 S=FE_OFN80_FE_DBTN1_n7298 A=n8563 B=n8564
XU11171 MXL2HS $PINS OB=n889 S=FE_OFN79_FE_DBTN1_n7298 A=n8564 B=n8565
XU11172 MXL2HS $PINS OB=n881 S=FE_OFN79_FE_DBTN1_n7298 A=n8565 B=n8566
XU11173 INV1S $PINS O=n8567 I=Buffer/data_buffer[836]
XU11174 MXL2HS $PINS OB=n873 S=FE_OFN43_FE_DBTN1_n7298 A=n8566 B=n8567
XU11175 INV1S $PINS O=n8569 I=Buffer/data_buffer[844]
XU11176 MXL2HS $PINS OB=n865 S=FE_OFN248_FE_DBTN1_n7298 A=n8567 B=n8569
XU11177 INV1S $PINS O=n8570 I=Buffer/data_buffer[852]
XU11178 MXL2HS $PINS OB=n857 S=FE_OFN87_FE_DBTN1_n7298 A=n8569 B=n8570
XU11179 INV1S $PINS O=n8571 I=Buffer/data_buffer[860]
XU11180 MXL2HS $PINS OB=n849 S=FE_OFN134_FE_DBTN1_n7298 A=n8570 B=n8571
XU11181 INV1S $PINS O=n8572 I=Buffer/data_buffer[868]
XU11182 MXL2HS $PINS OB=n841 S=FE_OFN134_FE_DBTN1_n7298 A=n8571 B=n8572
XU11183 INV1S $PINS O=n8573 I=Buffer/data_buffer[876]
XU11184 MXL2HS $PINS OB=n833 S=FE_OFN195_FE_DBTN1_n7298 A=n8572 B=n8573
XU11185 INV1S $PINS O=n8574 I=Buffer/data_buffer[884]
XU11186 MXL2HS $PINS OB=n825 S=FE_OFN253_FE_DBTN1_n7298 A=n8573 B=n8574
XU11187 INV1S $PINS O=n8576 I=Buffer/data_buffer[892]
XU11188 MXL2HS $PINS OB=n817 S=FE_OFN260_FE_DBTN1_n7298 A=n8574 B=n8576
XU11189 INV1S $PINS O=n8577 I=Buffer/data_buffer[900]
XU11190 MXL2HS $PINS OB=n809 S=FE_OFN260_FE_DBTN1_n7298 A=n8576 B=n8577
XU11191 INV1S $PINS O=n8578 I=Buffer/data_buffer[908]
XU11192 MXL2HS $PINS OB=n801 S=FE_OFN260_FE_DBTN1_n7298 A=n8577 B=n8578
XU11193 INV1S $PINS O=n8579 I=Buffer/data_buffer[916]
XU11194 MXL2HS $PINS OB=n793 S=FE_OFN140_FE_DBTN1_n7298 A=n8578 B=n8579
XU11195 INV1S $PINS O=n8580 I=Buffer/data_buffer[924]
XU11196 MXL2HS $PINS OB=n785 S=FE_OFN198_FE_DBTN1_n7298 A=n8579 B=n8580
XU11197 INV1S $PINS O=n8582 I=Buffer/data_buffer[932]
XU11198 MXL2HS $PINS OB=n777 S=FE_OFN259_FE_DBTN1_n7298 A=n8580 B=n8582
XU11199 INV1S $PINS O=n8583 I=Buffer/data_buffer[940]
XU11200 MXL2HS $PINS OB=n769 S=FE_OFN259_FE_DBTN1_n7298 A=n8582 B=n8583
XU11201 INV1S $PINS O=n8584 I=Buffer/data_buffer[948]
XU11202 MXL2HS $PINS OB=n761 S=FE_OFN258_FE_DBTN1_n7298 A=n8583 B=n8584
XU11203 INV1S $PINS O=n8585 I=Buffer/data_buffer[956]
XU11204 MXL2HS $PINS OB=n753 S=FE_OFN258_FE_DBTN1_n7298 A=n8584 B=n8585
XU11205 INV1S $PINS O=n8586 I=Buffer/data_buffer[964]
XU11206 MXL2HS $PINS OB=n745 S=FE_OFN265_FE_DBTN1_n7298 A=n8585 B=n8586
XU11207 INV1S $PINS O=n8587 I=Buffer/data_buffer[972]
XU11208 MXL2HS $PINS OB=n737 S=FE_OFN265_FE_DBTN1_n7298 A=n8586 B=n8587
XU11209 INV1S $PINS O=n8589 I=Buffer/data_buffer[980]
XU11210 MXL2HS $PINS OB=n729 S=FE_OFN206_FE_DBTN1_n7298 A=n8587 B=n8589
XU11211 INV1S $PINS O=n8590 I=Buffer/data_buffer[988]
XU11212 MXL2HS $PINS OB=n721 S=FE_OFN147_FE_DBTN1_n7298 A=n8589 B=n8590
XU11213 INV1S $PINS O=n8591 I=Buffer/data_buffer[996]
XU11214 MXL2HS $PINS OB=n713 S=FE_OFN207_FE_DBTN1_n7298 A=n8590 B=n8591
XU11215 INV1S $PINS O=n8592 I=Buffer/data_buffer[1004]
XU11216 MXL2HS $PINS OB=n705 S=FE_OFN207_FE_DBTN1_n7298 A=n8591 B=n8592
XU11217 INV1S $PINS O=n8593 I=Buffer/data_buffer[1012]
XU11218 MXL2HS $PINS OB=n697 S=FE_OFN266_FE_DBTN1_n7298 A=n8592 B=n8593
XU11219 INV1S $PINS O=n8594 I=Buffer/data_buffer[1020]
XU11220 MXL2HS $PINS OB=n689 S=FE_OFN202_FE_DBTN1_n7298 A=n8593 B=n8594
XU11221 INV1S $PINS O=n8596 I=Buffer/data_buffer[1028]
XU11222 MXL2HS $PINS OB=n681 S=FE_OFN202_FE_DBTN1_n7298 A=n8594 B=n8596
XU11223 INV1S $PINS O=n8597 I=Buffer/data_buffer[1036]
XU11224 MXL2HS $PINS OB=n673 S=FE_OFN202_FE_DBTN1_n7298 A=n8596 B=n8597
XU11225 INV1S $PINS O=n8598 I=Buffer/data_buffer[1044]
XU11226 MXL2HS $PINS OB=n665 S=FE_OFN143_FE_DBTN1_n7298 A=n8597 B=n8598
XU11227 INV1S $PINS O=n8599 I=Buffer/data_buffer[1052]
XU11228 MXL2HS $PINS OB=n657 S=FE_OFN94_FE_DBTN1_n7298 A=n8598 B=n8599
XU11229 INV1S $PINS O=n8600 I=Buffer/data_buffer[1060]
XU11230 MXL2HS $PINS OB=n649 S=FE_OFN54_FE_DBTN1_n7298 A=n8599 B=n8600
XU11231 INV1S $PINS O=n8601 I=Buffer/data_buffer[1068]
XU11232 MXL2HS $PINS OB=n641 S=FE_OFN54_FE_DBTN1_n7298 A=n8600 B=n8601
XU11233 INV1S $PINS O=n8603 I=Buffer/data_buffer[1076]
XU11234 MXL2HS $PINS OB=n633 S=FE_OFN340_FE_DBTN1_n7298 A=n8601 B=n8603
XU11235 INV1S $PINS O=n8604 I=Buffer/data_buffer[1084]
XU11236 MXL2HS $PINS OB=n625 S=FE_OFN27_FE_DBTN1_n7298 A=n8603 B=n8604
XU11237 INV1S $PINS O=n8605 I=Buffer/data_buffer[1092]
XU11238 MXL2HS $PINS OB=n617 S=FE_OFN56_FE_DBTN1_n7298 A=n8604 B=n8605
XU11239 INV1S $PINS O=n8606 I=Buffer/data_buffer[1100]
XU11240 MXL2HS $PINS OB=n609 S=FE_OFN56_FE_DBTN1_n7298 A=n8605 B=n8606
XU11241 INV1S $PINS O=n8607 I=Buffer/data_buffer[1108]
XU11242 MXL2HS $PINS OB=n601 S=FE_OFN56_FE_DBTN1_n7298 A=n8606 B=n8607
XU11243 INV1S $PINS O=n8608 I=Buffer/data_buffer[1116]
XU11244 MXL2HS $PINS OB=n593 S=FE_OFN56_FE_DBTN1_n7298 A=n8607 B=n8608
XU11245 INV1S $PINS O=n8610 I=Buffer/data_buffer[1124]
XU11246 MXL2HS $PINS OB=n585 S=FE_OFN56_FE_DBTN1_n7298 A=n8608 B=n8610
XU11247 INV1S $PINS O=n8612 I=Buffer/data_buffer[1132]
XU11248 MXL2HS $PINS OB=n577 S=FE_OFN97_FE_DBTN1_n7298 A=n8610 B=n8612
XU11249 INV1S $PINS O=n8613 I=Buffer/data_buffer[1140]
XU11250 MXL2HS $PINS OB=n569 S=FE_OFN148_FE_DBTN1_n7298 A=n8612 B=n8613
XU11251 INV1S $PINS O=n8614 I=Buffer/data_buffer[1148]
XU11252 MXL2HS $PINS OB=n561 S=FE_OFN101_FE_DBTN1_n7298 A=n8613 B=n8614
XU11253 INV1S $PINS O=n8615 I=Buffer/data_buffer[1156]
XU11254 MXL2HS $PINS OB=n553 S=FE_OFN101_FE_DBTN1_n7298 A=n8614 B=n8615
XU11255 INV1S $PINS O=n8616 I=Buffer/data_buffer[1164]
XU11256 MXL2HS $PINS OB=n545 S=FE_OFN101_FE_DBTN1_n7298 A=n8615 B=n8616
XU11257 INV1S $PINS O=n8618 I=Buffer/data_buffer[1172]
XU11258 MXL2HS $PINS OB=n537 S=FE_OFN156_FE_DBTN1_n7298 A=n8616 B=n8618
XU11259 INV1S $PINS O=n8620 I=Buffer/data_buffer[1180]
XU11260 MXL2HS $PINS OB=n529 S=FE_OFN313_FE_DBTN1_n7298 A=n8618 B=n8620
XU11261 INV1S $PINS O=n8621 I=Buffer/data_buffer[1188]
XU11262 MXL2HS $PINS OB=n521 S=FE_OFN313_FE_DBTN1_n7298 A=n8620 B=n8621
XU11263 INV1S $PINS O=n8622 I=Buffer/data_buffer[1196]
XU11264 MXL2HS $PINS OB=n513 S=FE_OFN284_FE_DBTN1_n7298 A=n8621 B=n8622
XU11265 MXL2HS $PINS OB=n505 S=FE_OFN323_FE_DBTN1_n7298 A=n8622 B=n8819
XU11266 INV1S $PINS O=n8626 I=weight_0_w[7]
XU11267 ND2 $PINS O=n8624 I1=i_data[7] I2=FE_OFN183_FE_DBTN1_n7298
XU11268 OAI12HS $PINS O=n461 A1=n8624 B1=FE_OFN183_FE_DBTN1_n7298 B2=n8626
XU11269 INV1S $PINS O=n8627 I=weight_0_w[15]
XU11270 MXL2HS $PINS OB=n460 S=FE_OFN241_FE_DBTN1_n7298 A=n8627 B=n8626
XU11271 INV1S $PINS O=n8629 I=weight_0_w[23]
XU11272 MXL2HS $PINS OB=n459 S=FE_OFN240_FE_DBTN1_n7298 A=n8629 B=n8627
XU11273 INV1S $PINS O=n8630 I=weight_1_w[7]
XU11274 MXL2HS $PINS OB=n458 S=FE_OFN113_FE_DBTN1_n7298 A=n8630 B=n8629
XU11275 INV1S $PINS O=n8631 I=weight_1_w[15]
XU11276 MXL2HS $PINS OB=n457 S=FE_OFN290_FE_DBTN1_n7298 A=n8631 B=n8630
XU11277 INV1S $PINS O=n8632 I=weight_1_w[23]
XU11278 MXL2HS $PINS OB=n456 S=FE_OFN290_FE_DBTN1_n7298 A=n8632 B=n8631
XU11279 INV1S $PINS O=n8907 I=weight_2_w[7]
XU11280 MXL2HS $PINS OB=n455 S=FE_OFN227_FE_DBTN1_n7298 A=n8907 B=n8632
XU11281 INV1S $PINS O=n8635 I=Buffer/data_buffer[0]
XU11282 ND2 $PINS O=n8634 I1=i_data[0] I2=FE_OCPN9770_FE_OFN1244_n7298
XU11283 OAI12HS $PINS O=n1709 A1=n8634 B1=FE_OCPN9770_FE_OFN1244_n7298 B2=n8635
XU11284 INV1S $PINS O=n8636 I=Buffer/data_buffer[8]
XU11285 MXL2HS $PINS OB=n1701 S=FE_OFN81_FE_DBTN1_n7298 A=n8635 B=n8636
XU11286 INV1S $PINS O=n8638 I=Buffer/data_buffer[16]
XU11287 MXL2HS $PINS OB=n1693 S=FE_OFN81_FE_DBTN1_n7298 A=n8636 B=n8638
XU11288 INV1S $PINS O=n8640 I=Buffer/data_buffer[24]
XU11289 MXL2HS $PINS OB=n1685 S=FE_OFN81_FE_DBTN1_n7298 A=n8638 B=n8640
XU11290 INV1S $PINS O=n8641 I=Buffer/data_buffer[32]
XU11291 MXL2HS $PINS OB=n1677 S=FE_OFN129_FE_DBTN1_n7298 A=n8640 B=n8641
XU11292 MXL2HS $PINS OB=n1669 S=FE_OFN315_FE_DBTN1_n7298 A=n8641 B=n8642
XU11293 INV1S $PINS O=n8643 I=Buffer/data_buffer[48]
XU11294 MXL2HS $PINS OB=n1661 S=FE_OFN133_FE_DBTN1_n7298 A=n8642 B=n8643
XU11295 MXL2HS $PINS OB=n1653 S=FE_OFN251_FE_DBTN1_n7298 A=n8643 B=n8644
XU11296 INV1S $PINS O=n8646 I=Buffer/data_buffer[64]
XU11297 MXL2HS $PINS OB=n1645 S=FE_OFN293_FE_DBTN1_n7298 A=n8644 B=n8646
XU11298 MXL2HS $PINS OB=n1637 S=FE_OFN135_FE_DBTN1_n7298 A=n8646 B=n8647
XU11299 INV1S $PINS O=n8648 I=Buffer/data_buffer[80]
XU11300 MXL2HS $PINS OB=n1629 S=FE_OFN135_FE_DBTN1_n7298 A=n8647 B=n8648
XU11301 INV1S $PINS O=n8649 I=Buffer/data_buffer[88]
XU11302 MXL2HS $PINS OB=n1621 S=FE_OFN271_FE_DBTN1_n7298 A=n8648 B=n8649
XU11303 INV1S $PINS O=n8650 I=Buffer/data_buffer[96]
XU11304 MXL2HS $PINS OB=n1613 S=FE_OFN271_FE_DBTN1_n7298 A=n8649 B=n8650
XU11305 INV1S $PINS O=n8651 I=Buffer/data_buffer[104]
XU11306 MXL2HS $PINS OB=n1605 S=FE_OFN271_FE_DBTN1_n7298 A=n8650 B=n8651
XU11307 INV1S $PINS O=n8653 I=Buffer/data_buffer[112]
XU11308 MXL2HS $PINS OB=n1597 S=FE_OFN212_FE_DBTN1_n7298 A=n8651 B=n8653
XU11309 MXL2HS $PINS OB=n1589 S=FE_OFN212_FE_DBTN1_n7298 A=n8653 B=n8654
XU11310 INV1S $PINS O=n8655 I=Buffer/data_buffer[128]
XU11311 MXL2HS $PINS OB=n1581 S=FE_OFN212_FE_DBTN1_n7298 A=n8654 B=n8655
XU11312 MXL2HS $PINS OB=n1573 S=FE_OFN58_FE_DBTN1_n7298 A=n8655 B=n8656
XU11313 INV1S $PINS O=n8657 I=Buffer/data_buffer[144]
XU11314 MXL2HS $PINS OB=n1565 S=FE_OFN292_FE_DBTN1_n7298 A=n8656 B=n8657
XU11315 MXL2HS $PINS OB=n1557 S=FE_OFN250_FE_DBTN1_n7298 A=n8657 B=n8658
XU11316 INV1S $PINS O=n8660 I=Buffer/data_buffer[160]
XU11317 MXL2HS $PINS OB=n1549 S=FE_OFN250_FE_DBTN1_n7298 A=n8658 B=n8660
XU11318 MXL2HS $PINS OB=n1541 S=FE_OFN293_FE_DBTN1_n7298 A=n8660 B=n8661
XU11319 INV1S $PINS O=n8662 I=Buffer/data_buffer[176]
XU11320 MXL2HS $PINS OB=n1533 S=FE_OFN293_FE_DBTN1_n7298 A=n8661 B=n8662
XU11321 MXL2HS $PINS OB=n1525 S=FE_OFN135_FE_DBTN1_n7298 A=n8662 B=n8663
XU11322 INV1S $PINS O=n8664 I=Buffer/data_buffer[192]
XU11323 MXL2HS $PINS OB=n1517 S=FE_OFN271_FE_DBTN1_n7298 A=n8663 B=n8664
XU11324 MXL2HS $PINS OB=n1509 S=FE_OFN275_FE_DBTN1_n7298 A=n8664 B=n8665
XU11325 INV1S $PINS O=n8667 I=Buffer/data_buffer[208]
XU11326 MXL2HS $PINS OB=n1501 S=FE_OFN222_FE_DBTN1_n7298 A=n8665 B=n8667
XU11327 MXL2HS $PINS OB=n1493 S=FE_OFN285_FE_DBTN1_n7298 A=n8667 B=n8668
XU11328 INV1S $PINS O=n8669 I=Buffer/data_buffer[224]
XU11329 MXL2HS $PINS OB=n1485 S=FE_OFN285_FE_DBTN1_n7298 A=n8668 B=n8669
XU11330 MXL2HS $PINS OB=n1477 S=FE_OFN286_FE_DBTN1_n7298 A=n8669 B=n8670
XU11331 INV1S $PINS O=n8671 I=Buffer/data_buffer[240]
XU11332 MXL2HS $PINS OB=n1469 S=FE_OFN220_FE_DBTN1_n7298 A=n8670 B=n8671
XU11333 INV1S $PINS O=n8672 I=Buffer/data_buffer[248]
XU11334 MXL2HS $PINS OB=n1461 S=FE_OFN160_FE_DBTN1_n7298 A=n8671 B=n8672
XU11335 INV1S $PINS O=n8674 I=Buffer/data_buffer[256]
XU11336 MXL2HS $PINS OB=n1453 S=FE_OFN280_FE_DBTN1_n7298 A=n8672 B=n8674
XU11337 INV1S $PINS O=n8676 I=Buffer/data_buffer[264]
XU11338 MXL2HS $PINS OB=n1445 S=FE_OFN280_FE_DBTN1_n7298 A=n8674 B=n8676
XU11339 INV1S $PINS O=n8677 I=Buffer/data_buffer[272]
XU11340 MXL2HS $PINS OB=n1437 S=FE_OFN159_FE_DBTN1_n7298 A=n8676 B=n8677
XU11341 INV1S $PINS O=n8678 I=Buffer/data_buffer[280]
XU11342 MXL2HS $PINS OB=n1429 S=FE_OFN159_FE_DBTN1_n7298 A=n8677 B=n8678
XU11343 INV1S $PINS O=n8679 I=Buffer/data_buffer[288]
XU11344 MXL2HS $PINS OB=n1421 S=FE_OFN159_FE_DBTN1_n7298 A=n8678 B=n8679
XU11345 INV1S $PINS O=n8680 I=Buffer/data_buffer[296]
XU11346 MXL2HS $PINS OB=n1413 S=FE_OFN104_FE_DBTN1_n7298 A=n8679 B=n8680
XU11347 INV1S $PINS O=n8682 I=Buffer/data_buffer[304]
XU11348 MXL2HS $PINS OB=n1405 S=FE_OFN61_FE_DBTN1_n7298 A=n8680 B=n8682
XU11349 INV1S $PINS O=n8683 I=Buffer/data_buffer[312]
XU11350 MXL2HS $PINS OB=n1397 S=FE_OFN312_FE_DBTN1_n7298 A=n8682 B=n8683
XU11351 INV1S $PINS O=n8684 I=Buffer/data_buffer[320]
XU11352 MXL2HS $PINS OB=n1389 S=FE_OFN311_FE_DBTN1_n7298 A=n8683 B=n8684
XU11353 INV1S $PINS O=n8685 I=Buffer/data_buffer[328]
XU11354 MXL2HS $PINS OB=n1381 S=FE_OFN307_FE_DBTN1_n7298 A=n8684 B=n8685
XU11355 INV1S $PINS O=n8686 I=Buffer/data_buffer[336]
XU11356 MXL2HS $PINS OB=n1373 S=FE_OFN272_FE_DBTN1_n7298 A=n8685 B=n8686
XU11357 MXL2HS $PINS OB=n1365 S=FE_OFN308_FE_DBTN1_n7298 A=n8686 B=n8688
XU11358 INV1S $PINS O=n8689 I=Buffer/data_buffer[352]
XU11359 MXL2HS $PINS OB=n1357 S=FE_OFN212_FE_DBTN1_n7298 A=n8688 B=n8689
XU11360 MXL2HS $PINS OB=n1349 S=FE_OFN58_FE_DBTN1_n7298 A=n8689 B=n8690
XU11361 INV1S $PINS O=n8691 I=Buffer/data_buffer[368]
XU11362 MXL2HS $PINS OB=n1341 S=FE_OFN292_FE_DBTN1_n7298 A=n8690 B=n8691
XU11363 MXL2HS $PINS OB=n1333 S=FE_OFN315_FE_DBTN1_n7298 A=n8691 B=n8692
XU11364 INV1S $PINS O=n8693 I=Buffer/data_buffer[384]
XU11365 MXL2HS $PINS OB=n1325 S=FE_OFN250_FE_DBTN1_n7298 A=n8692 B=n8693
XU11366 MXL2HS $PINS OB=n1317 S=FE_OFN293_FE_DBTN1_n7298 A=n8693 B=n8695
XU11367 INV1S $PINS O=n8697 I=Buffer/data_buffer[400]
XU11368 MXL2HS $PINS OB=n1309 S=FE_OFN293_FE_DBTN1_n7298 A=n8695 B=n8697
XU11369 MXL2HS $PINS OB=n1301 S=FE_OFN135_FE_DBTN1_n7298 A=n8697 B=n8698
XU11370 INV1S $PINS O=n8699 I=Buffer/data_buffer[416]
XU11371 MXL2HS $PINS OB=n1293 S=FE_OFN88_FE_DBTN1_n7298 A=n8698 B=n8699
XU11372 INV1S $PINS O=n8700 I=Buffer/data_buffer[424]
XU11373 MXL2HS $PINS OB=n1285 S=FE_OFN89_FE_DBTN1_n7298 A=n8699 B=n8700
XU11374 INV1S $PINS O=n8701 I=Buffer/data_buffer[432]
XU11375 MXL2HS $PINS OB=n1277 S=FE_OFN137_FE_DBTN1_n7298 A=n8700 B=n8701
XU11376 INV1S $PINS O=n8703 I=Buffer/data_buffer[440]
XU11377 MXL2HS $PINS OB=n1269 S=FE_OFN92_FE_DBTN1_n7298 A=n8701 B=n8703
XU11378 INV1S $PINS O=n8704 I=Buffer/data_buffer[448]
XU11379 MXL2HS $PINS OB=n1261 S=FE_OFN92_FE_DBTN1_n7298 A=n8703 B=n8704
XU11380 INV1S $PINS O=n8705 I=Buffer/data_buffer[456]
XU11381 MXL2HS $PINS OB=n1253 S=FE_OFN92_FE_DBTN1_n7298 A=n8704 B=n8705
XU11382 INV1S $PINS O=n8706 I=Buffer/data_buffer[464]
XU11383 MXL2HS $PINS OB=n1245 S=FE_OFN141_FE_DBTN1_n7298 A=n8705 B=n8706
XU11384 INV1S $PINS O=n8707 I=Buffer/data_buffer[472]
XU11385 MXL2HS $PINS OB=n1237 S=FE_OFN141_FE_DBTN1_n7298 A=n8706 B=n8707
XU11386 INV1S $PINS O=n8708 I=Buffer/data_buffer[480]
XU11387 MXL2HS $PINS OB=n1229 S=FE_OFN200_FE_DBTN1_n7298 A=n8707 B=n8708
XU11388 INV1S $PINS O=n8710 I=Buffer/data_buffer[488]
XU11389 MXL2HS $PINS OB=n1221 S=FE_OFN338_FE_DBTN1_n7298 A=n8708 B=n8710
XU11390 INV1S $PINS O=n8711 I=Buffer/data_buffer[496]
XU11391 MXL2HS $PINS OB=n1213 S=FE_OFN102_FE_DBTN1_n7298 A=n8710 B=n8711
XU11392 INV1S $PINS O=n8712 I=Buffer/data_buffer[504]
XU11393 MXL2HS $PINS OB=n1205 S=FE_OFN102_FE_DBTN1_n7298 A=n8711 B=n8712
XU11394 INV1S $PINS O=n8713 I=Buffer/data_buffer[512]
XU11395 MXL2HS $PINS OB=n1197 S=FE_OFN276_FE_DBTN1_n7298 A=n8712 B=n8713
XU11396 INV1S $PINS O=n8714 I=Buffer/data_buffer[520]
XU11397 MXL2HS $PINS OB=n1189 S=FE_OFN276_FE_DBTN1_n7298 A=n8713 B=n8714
XU11398 INV1S $PINS O=n8715 I=Buffer/data_buffer[528]
XU11399 MXL2HS $PINS OB=n1181 S=FE_OFN105_FE_DBTN1_n7298 A=n8714 B=n8715
XU11400 MXL2HS $PINS OB=n1173 S=FE_OFN104_FE_DBTN1_n7298 A=n8715 B=n8717
XU11401 INV1S $PINS O=n8718 I=Buffer/data_buffer[544]
XU11402 MXL2HS $PINS OB=n1165 S=FE_OFN283_FE_DBTN1_n7298 A=n8717 B=n8718
XU11403 MXL2HS $PINS OB=n1157 S=FE_OFN283_FE_DBTN1_n7298 A=n8718 B=n8719
XU11404 INV1S $PINS O=n8720 I=Buffer/data_buffer[560]
XU11405 MXL2HS $PINS OB=n1149 S=FE_OFN283_FE_DBTN1_n7298 A=n8719 B=n8720
XU11406 MXL2HS $PINS OB=n1141 S=FE_OFN219_FE_DBTN1_n7298 A=n8720 B=n8721
XU11407 INV1S $PINS O=n8722 I=Buffer/data_buffer[576]
XU11408 MXL2HS $PINS OB=n1133 S=FE_OFN220_FE_DBTN1_n7298 A=n8721 B=n8722
XU11409 INV1S $PINS O=n8724 I=Buffer/data_buffer[584]
XU11410 MXL2HS $PINS OB=n1125 S=FE_OFN221_FE_DBTN1_n7298 A=n8722 B=n8724
XU11411 INV1S $PINS O=n8725 I=Buffer/data_buffer[592]
XU11412 MXL2HS $PINS OB=n1117 S=FE_OFN221_FE_DBTN1_n7298 A=n8724 B=n8725
XU11413 INV1S $PINS O=n8726 I=Buffer/data_buffer[600]
XU11414 MXL2HS $PINS OB=n1109 S=FE_OFN221_FE_DBTN1_n7298 A=n8725 B=n8726
XU11415 INV1S $PINS O=n8727 I=Buffer/data_buffer[608]
XU11416 MXL2HS $PINS OB=n1101 S=FE_OFN281_FE_DBTN1_n7298 A=n8726 B=n8727
XU11417 INV1S $PINS O=n8728 I=Buffer/data_buffer[616]
XU11418 MXL2HS $PINS OB=n1093 S=FE_OFN170_FE_DBTN1_n7298 A=n8727 B=n8728
XU11419 INV1S $PINS O=n8729 I=Buffer/data_buffer[624]
XU11420 MXL2HS $PINS OB=n1085 S=FE_OFN115_FE_DBTN1_n7298 A=n8728 B=n8729
XU11421 INV1S $PINS O=n8731 I=Buffer/data_buffer[632]
XU11422 MXL2HS $PINS OB=n1077 S=FE_OFN33_FE_DBTN1_n7298 A=n8729 B=n8731
XU11423 INV1S $PINS O=n8732 I=Buffer/data_buffer[640]
XU11424 MXL2HS $PINS OB=n1069 S=FE_OFN33_FE_DBTN1_n7298 A=n8731 B=n8732
XU11425 INV1S $PINS O=n8733 I=Buffer/data_buffer[648]
XU11426 MXL2HS $PINS OB=n1061 S=FE_OFN66_FE_DBTN1_n7298 A=n8732 B=n8733
XU11427 INV1S $PINS O=n8734 I=Buffer/data_buffer[656]
XU11428 MXL2HS $PINS OB=n1053 S=FE_OFN66_FE_DBTN1_n7298 A=n8733 B=n8734
XU11429 INV1S $PINS O=n8735 I=Buffer/data_buffer[664]
XU11430 MXL2HS $PINS OB=n1045 S=FE_OFN66_FE_DBTN1_n7298 A=n8734 B=n8735
XU11431 INV1S $PINS O=n8736 I=Buffer/data_buffer[672]
XU11432 MXL2HS $PINS OB=n1037 S=FE_OFN66_FE_DBTN1_n7298 A=n8735 B=n8736
XU11433 INV1S $PINS O=n8738 I=Buffer/data_buffer[680]
XU11434 MXL2HS $PINS OB=n1029 S=FE_OFN342_FE_DBTN1_n7298 A=n8736 B=n8738
XU11435 INV1S $PINS O=n8739 I=Buffer/data_buffer[688]
XU11436 MXL2HS $PINS OB=n1021 S=FE_OFN342_FE_DBTN1_n7298 A=n8738 B=n8739
XU11437 INV1S $PINS O=n8740 I=Buffer/data_buffer[696]
XU11438 MXL2HS $PINS OB=n1013 S=FE_OFN342_FE_DBTN1_n7298 A=n8739 B=n8740
XU11439 INV1S $PINS O=n8741 I=Buffer/data_buffer[704]
XU11440 MXL2HS $PINS OB=n1005 S=FE_OFN342_FE_DBTN1_n7298 A=n8740 B=n8741
XU11441 INV1S $PINS O=n8742 I=Buffer/data_buffer[712]
XU11442 MXL2HS $PINS OB=n997 S=FE_OFN343_FE_DBTN1_n7298 A=n8741 B=n8742
XU11443 INV1S $PINS O=n8743 I=Buffer/data_buffer[720]
XU11444 MXL2HS $PINS OB=n989 S=FE_OFN343_FE_DBTN1_n7298 A=n8742 B=n8743
XU11445 INV1S $PINS O=n8745 I=Buffer/data_buffer[728]
XU11446 MXL2HS $PINS OB=n981 S=FE_OFN279_FE_DBTN1_n7298 A=n8743 B=n8745
XU11447 INV1S $PINS O=n8747 I=Buffer/data_buffer[736]
XU11448 MXL2HS $PINS OB=n973 S=FE_OFN279_FE_DBTN1_n7298 A=n8745 B=n8747
XU11449 INV1S $PINS O=n8748 I=Buffer/data_buffer[744]
XU11450 MXL2HS $PINS OB=n965 S=FE_OFN102_FE_DBTN1_n7298 A=n8747 B=n8748
XU11451 INV1S $PINS O=n8749 I=Buffer/data_buffer[752]
XU11452 MXL2HS $PINS OB=n957 S=FE_OFN324_FE_DBTN1_n7298 A=n8748 B=n8749
XU11453 INV1S $PINS O=n8750 I=Buffer/data_buffer[760]
XU11454 MXL2HS $PINS OB=n949 S=FE_OFN337_FE_DBTN1_n7298 A=n8749 B=n8750
XU11455 INV1S $PINS O=n8751 I=Buffer/data_buffer[768]
XU11456 MXL2HS $PINS OB=n941 S=FE_OFN155_FE_DBTN1_n7298 A=n8750 B=n8751
XU11457 INV1S $PINS O=n8753 I=Buffer/data_buffer[776]
XU11458 MXL2HS $PINS OB=n933 S=FE_OFN273_FE_DBTN1_n7298 A=n8751 B=n8753
XU11459 INV1S $PINS O=n8754 I=Buffer/data_buffer[784]
XU11460 MXL2HS $PINS OB=n925 S=FE_OFN213_FE_DBTN1_n7298 A=n8753 B=n8754
XU11461 MXL2HS $PINS OB=n917 S=FE_OFN153_FE_DBTN1_n7298 A=n8754 B=n8755
XU11462 INV1S $PINS O=n8756 I=Buffer/data_buffer[800]
XU11463 MXL2HS $PINS OB=n909 S=FE_OFN99_FE_DBTN1_n7298 A=n8755 B=n8756
XU11464 MXL2HS $PINS OB=n901 S=FE_OFN58_FE_DBTN1_n7298 A=n8756 B=n8757
XU11465 INV1S $PINS O=n8758 I=Buffer/data_buffer[816]
XU11466 MXL2HS $PINS OB=n893 S=FE_OFN292_FE_DBTN1_n7298 A=n8757 B=n8758
XU11467 MXL2HS $PINS OB=n885 S=FE_OFN250_FE_DBTN1_n7298 A=n8758 B=n8760
XU11468 INV1S $PINS O=n8761 I=Buffer/data_buffer[832]
XU11469 MXL2HS $PINS OB=n877 S=FE_OFN316_FE_DBTN1_n7298 A=n8760 B=n8761
XU11470 INV1S $PINS O=n8762 I=Buffer/data_buffer[840]
XU11471 MXL2HS $PINS OB=n869 S=FE_OFN135_FE_DBTN1_n7298 A=n8761 B=n8762
XU11472 INV1S $PINS O=n8763 I=Buffer/data_buffer[848]
XU11473 MXL2HS $PINS OB=n861 S=FE_OFN135_FE_DBTN1_n7298 A=n8762 B=n8763
XU11474 INV1S $PINS O=n8764 I=Buffer/data_buffer[856]
XU11475 MXL2HS $PINS OB=n853 S=FE_OFN48_FE_DBTN1_n7298 A=n8763 B=n8764
XU11476 INV1S $PINS O=n8765 I=Buffer/data_buffer[864]
XU11477 MXL2HS $PINS OB=n845 S=FE_OFN328_FE_DBTN1_n7298 A=n8764 B=n8765
XU11478 INV1S $PINS O=n8767 I=Buffer/data_buffer[872]
XU11479 MXL2HS $PINS OB=n837 S=FE_OFN53_FE_DBTN1_n7298 A=n8765 B=n8767
XU11480 INV1S $PINS O=n8768 I=Buffer/data_buffer[880]
XU11481 MXL2HS $PINS OB=n829 S=FE_OFN53_FE_DBTN1_n7298 A=n8767 B=n8768
XU11482 INV1S $PINS O=n8769 I=Buffer/data_buffer[888]
XU11483 MXL2HS $PINS OB=n821 S=FE_OFN53_FE_DBTN1_n7298 A=n8768 B=n8769
XU11484 INV1S $PINS O=n8770 I=Buffer/data_buffer[896]
XU11485 MXL2HS $PINS OB=n813 S=FE_OFN53_FE_DBTN1_n7298 A=n8769 B=n8770
XU11486 INV1S $PINS O=n8771 I=Buffer/data_buffer[904]
XU11487 MXL2HS $PINS OB=n805 S=FE_OFN53_FE_DBTN1_n7298 A=n8770 B=n8771
XU11488 INV1S $PINS O=n8772 I=Buffer/data_buffer[912]
XU11489 MXL2HS $PINS OB=n797 S=FE_OFN93_FE_DBTN1_n7298 A=n8771 B=n8772
XU11490 INV1S $PINS O=n8774 I=Buffer/data_buffer[920]
XU11491 MXL2HS $PINS OB=n789 S=FE_OFN93_FE_DBTN1_n7298 A=n8772 B=n8774
XU11492 INV1S $PINS O=n8775 I=Buffer/data_buffer[928]
XU11493 MXL2HS $PINS OB=n781 S=FE_OFN93_FE_DBTN1_n7298 A=n8774 B=n8775
XU11494 INV1S $PINS O=n8776 I=Buffer/data_buffer[936]
XU11495 MXL2HS $PINS OB=n773 S=FE_OFN93_FE_DBTN1_n7298 A=n8775 B=n8776
XU11496 INV1S $PINS O=n8777 I=Buffer/data_buffer[944]
XU11497 MXL2HS $PINS OB=n765 S=FE_OFN93_FE_DBTN1_n7298 A=n8776 B=n8777
XU11498 INV1S $PINS O=n8778 I=Buffer/data_buffer[952]
XU11499 MXL2HS $PINS OB=n757 S=FE_OFN142_FE_DBTN1_n7298 A=n8777 B=n8778
XU11500 INV1S $PINS O=n8779 I=Buffer/data_buffer[960]
XU11501 MXL2HS $PINS OB=n749 S=FE_OFN142_FE_DBTN1_n7298 A=n8778 B=n8779
XU11502 INV1S $PINS O=n8781 I=Buffer/data_buffer[968]
XU11503 MXL2HS $PINS OB=n741 S=FE_OFN142_FE_DBTN1_n7298 A=n8779 B=n8781
XU11504 INV1S $PINS O=n8782 I=Buffer/data_buffer[976]
XU11505 MXL2HS $PINS OB=n733 S=FE_OFN142_FE_DBTN1_n7298 A=n8781 B=n8782
XU11506 INV1S $PINS O=n8783 I=Buffer/data_buffer[984]
XU11507 MXL2HS $PINS OB=n725 S=FE_OFN142_FE_DBTN1_n7298 A=n8782 B=n8783
XU11508 INV1S $PINS O=n8784 I=Buffer/data_buffer[992]
XU11509 MXL2HS $PINS OB=n717 S=FE_OFN143_FE_DBTN1_n7298 A=n8783 B=n8784
XU11510 INV1S $PINS O=n8785 I=Buffer/data_buffer[1000]
XU11511 MXL2HS $PINS OB=n709 S=FE_OFN94_FE_DBTN1_n7298 A=n8784 B=n8785
XU11512 INV1S $PINS O=n8787 I=Buffer/data_buffer[1008]
XU11513 MXL2HS $PINS OB=n701 S=FE_OFN145_FE_DBTN1_n7298 A=n8785 B=n8787
XU11514 INV1S $PINS O=n8789 I=Buffer/data_buffer[1016]
XU11515 MXL2HS $PINS OB=n693 S=FE_OFN145_FE_DBTN1_n7298 A=n8787 B=n8789
XU11516 INV1S $PINS O=n8790 I=Buffer/data_buffer[1024]
XU11517 MXL2HS $PINS OB=n685 S=FE_OFN299_FE_DBTN1_n7298 A=n8789 B=n8790
XU11518 INV1S $PINS O=n8791 I=Buffer/data_buffer[1032]
XU11519 MXL2HS $PINS OB=n677 S=FE_OFN300_FE_DBTN1_n7298 A=n8790 B=n8791
XU11520 INV1S $PINS O=n8792 I=Buffer/data_buffer[1040]
XU11521 MXL2HS $PINS OB=n669 S=FE_OFN300_FE_DBTN1_n7298 A=n8791 B=n8792
XU11522 INV1S $PINS O=n8793 I=Buffer/data_buffer[1048]
XU11523 MXL2HS $PINS OB=n661 S=FE_OFN321_FE_DBTN1_n7298 A=n8792 B=n8793
XU11524 INV1S $PINS O=n8795 I=Buffer/data_buffer[1056]
XU11525 MXL2HS $PINS OB=n653 S=FE_OFN321_FE_DBTN1_n7298 A=n8793 B=n8795
XU11526 INV1S $PINS O=n8796 I=Buffer/data_buffer[1064]
XU11527 MXL2HS $PINS OB=n645 S=FE_OFN321_FE_DBTN1_n7298 A=n8795 B=n8796
XU11528 INV1S $PINS O=n8797 I=Buffer/data_buffer[1072]
XU11529 MXL2HS $PINS OB=n637 S=FE_OFN321_FE_DBTN1_n7298 A=n8796 B=n8797
XU11530 INV1S $PINS O=n8798 I=Buffer/data_buffer[1080]
XU11531 MXL2HS $PINS OB=n629 S=FE_OFN321_FE_DBTN1_n7298 A=n8797 B=n8798
XU11532 INV1S $PINS O=n8799 I=Buffer/data_buffer[1088]
XU11533 MXL2HS $PINS OB=n621 S=FE_OFN331_FE_DBTN1_n7298 A=n8798 B=n8799
XU11534 INV1S $PINS O=n8800 I=Buffer/data_buffer[1096]
XU11535 MXL2HS $PINS OB=n613 S=FE_OFN331_FE_DBTN1_n7298 A=n8799 B=n8800
XU11536 INV1S $PINS O=n8802 I=Buffer/data_buffer[1104]
XU11537 MXL2HS $PINS OB=n605 S=FE_OFN331_FE_DBTN1_n7298 A=n8800 B=n8802
XU11538 INV1S $PINS O=n8803 I=Buffer/data_buffer[1112]
XU11539 MXL2HS $PINS OB=n597 S=FE_OFN331_FE_DBTN1_n7298 A=n8802 B=n8803
XU11540 INV1S $PINS O=n8804 I=Buffer/data_buffer[1120]
XU11541 MXL2HS $PINS OB=n589 S=FE_OFN331_FE_DBTN1_n7298 A=n8803 B=n8804
XU11542 INV1S $PINS O=n8805 I=Buffer/data_buffer[1128]
XU11543 MXL2HS $PINS OB=n581 S=FE_OFN336_FE_DBTN1_n7298 A=n8804 B=n8805
XU11544 INV1S $PINS O=n8806 I=Buffer/data_buffer[1136]
XU11545 MXL2HS $PINS OB=n573 S=FE_OFN336_FE_DBTN1_n7298 A=n8805 B=n8806
XU11546 INV1S $PINS O=n8807 I=Buffer/data_buffer[1144]
XU11547 MXL2HS $PINS OB=n565 S=FE_OFN336_FE_DBTN1_n7298 A=n8806 B=n8807
XU11548 INV1S $PINS O=n8809 I=Buffer/data_buffer[1152]
XU11549 MXL2HS $PINS OB=n557 S=FE_OFN336_FE_DBTN1_n7298 A=n8807 B=n8809
XU11550 INV1S $PINS O=n8810 I=Buffer/data_buffer[1160]
XU11551 MXL2HS $PINS OB=n549 S=FE_OFN336_FE_DBTN1_n7298 A=n8809 B=n8810
XU11552 INV1S $PINS O=n8811 I=Buffer/data_buffer[1168]
XU11553 MXL2HS $PINS OB=n541 S=FE_OFN343_FE_DBTN1_n7298 A=n8810 B=n8811
XU11554 INV1S $PINS O=n8812 I=Buffer/data_buffer[1176]
XU11555 MXL2HS $PINS OB=n533 S=FE_OFN279_FE_DBTN1_n7298 A=n8811 B=n8812
XU11556 INV1S $PINS O=n8813 I=Buffer/data_buffer[1184]
XU11557 MXL2HS $PINS OB=n525 S=FE_OFN218_FE_DBTN1_n7298 A=n8812 B=n8813
XU11558 INV1S $PINS O=n8814 I=Buffer/data_buffer[1192]
XU11559 MXL2HS $PINS OB=n517 S=FE_OFN277_FE_DBTN1_n7298 A=n8813 B=n8814
XU11560 INV1S $PINS O=n8816 I=Buffer/data_buffer[1200]
XU11561 MXL2HS $PINS OB=n509 S=FE_OFN105_FE_DBTN1_n7298 A=n8814 B=n8816
XU11562 MXL2HS $PINS OB=n501 S=FE_OFN104_FE_DBTN1_n7298 A=n8816 B=n8908
XU11563 MXL2HS $PINS OB=n500 S=FE_OFN305_FE_DBTN1_n7298 A=n8817 B=n8901
XU11564 MXL2HS $PINS OB=n498 S=FE_OFN151_FE_DBTN1_n7298 A=n8818 B=n8900
XU11565 MXL2HS $PINS OB=n497 S=FE_OFN304_FE_DBTN1_n7298 A=n8819 B=n8906
XU11566 MXL2HS $PINS OB=n499 S=FE_OFN270_FE_DBTN1_n7298 A=n8820 B=n8897
XU11567 MXL2HS $PINS OB=n496 S=FE_OFN287_FE_DBTN1_n7298 A=n8821 B=n8905
XU11568 MXL2HS $PINS OB=n494 S=FE_OFN304_FE_DBTN1_n7298 A=n8823 B=n8893
XU11569 MXL2HS $PINS OB=n495 S=FE_OFN305_FE_DBTN1_n7298 A=n8824 B=n8891
XU11570 INV1S $PINS O=n8827 I=n8825
XU11571 INV1S $PINS O=n8830 I=n8828
XU11572 AOI12H $PINS O=n8839 A1=n8837 B1=FE_OFN1156_n2894 B2=n8838
XU11573 XOR2HS $PINS O=pConv_2/product_0_w[15] I1=n8840 I2=n8839
XU11574 AOI12H $PINS O=n8847 A1=n8845 B1=FE_OFN1156_n2894 B2=n8846
XU11575 XOR2HS $PINS O=pConv_2/product_0_w[14] I1=n8848 I2=n8847
XU11576 INV1S $PINS O=n8851 I=n8849
XU11577 ND3 $PINS O=n8857 I1=n8856 I2=n8855 I3=n8854
XU11578 XNR2HS $PINS O=pConv_2/product_0_w[12] I1=n8858 I2=n8857
XU11579 OA12 $PINS O=n8868 A1=n8864 B1=n8865 B2=n5944
XU11580 NR2 $PINS O=n8867 I1=n5943 I2=n8866
XU11581 XNR2HS $PINS O=pConv_2/product_0_w[6] I1=n8868 I2=n8867
XU11582 INV1S $PINS O=n8871 I=n8870
XU11583 NR2 $PINS O=n8873 I1=n8869 I2=n8871
XU11584 XOR2HS $PINS O=pConv_2/product_0_w[4] I1=n8872 I2=n8873
XU11585 INV1S $PINS O=n8875 I=n8874
XU11586 NR2 $PINS O=n8877 I1=n8875 I2=n8876
XU11587 XNR2HS $PINS O=pConv_2/product_0_w[3] I1=n8878 I2=n8877
XU11588 INV1S $PINS O=n8881 I=n8879
XU11589 XOR2HS $PINS O=pConv_2/product_0_w[2] I1=n8885 I2=n8882
XU11590 AN2 $PINS O=n8887 I1=n8884 I2=n8883
XU11591 INV1S $PINS O=n8886 I=n8885
XU11592 NR2 $PINS O=pConv_2/product_0_w[1] I1=n8887 I2=n8886
XU11593 NR2 $PINS O=pConv_2/product_0_w[0] I1=n8889 I2=FE_OFN1246_n8888
XU11594 INV1S $PINS O=n8997 I=weight_2_w[9]
XU11595 MXL2HS $PINS OB=n401 S=FE_OFN117_FE_DBTN1_n7298 A=n8997 B=n8890
XU11596 MXL2HS $PINS OB=n487 S=FE_OFN304_FE_DBTN1_n7298 A=n8891 B=n8918
XU11597 INV1S $PINS O=n9000 I=weight_2_w[8]
XU11598 MXL2HS $PINS OB=n392 S=FE_OFN117_FE_DBTN1_n7298 A=n9000 B=n8892
XU11599 MXL2HS $PINS OB=n486 S=FE_OFN171_FE_DBTN1_n7298 A=n8893 B=n8917
XU11600 INV1S $PINS O=n9004 I=weight_2_w[13]
XU11601 MXL2HS $PINS OB=n437 S=FE_OFN117_FE_DBTN1_n7298 A=n9004 B=n8895
XU11602 MXL2HS $PINS OB=n491 S=FE_OFN116_FE_DBTN1_n7298 A=n8897 B=n8914
XU11603 INV1S $PINS O=n9008 I=weight_2_w[12]
XU11604 MXL2HS $PINS OB=n428 S=FE_OFN172_FE_DBTN1_n7298 A=n9008 B=n8898
XU11605 INV1S $PINS O=n9010 I=weight_2_w[11]
XU11606 MXL2HS $PINS OB=n419 S=FE_OFN117_FE_DBTN1_n7298 A=n9010 B=n8899
XU11607 MXL2HS $PINS OB=n490 S=FE_OFN322_FE_DBTN1_n7298 A=n8900 B=n8912
XU11608 MXL2HS $PINS OB=n492 S=FE_OFN171_FE_DBTN1_n7298 A=n8901 B=n8911
XU11609 INV1S $PINS O=n9015 I=weight_2_w[14]
XU11610 MXL2HS $PINS OB=n446 S=FE_OFN172_FE_DBTN1_n7298 A=n9015 B=n8903
XU11611 INV1S $PINS O=n9018 I=weight_2_w[10]
XU11612 MXL2HS $PINS OB=n410 S=FE_OFN117_FE_DBTN1_n7298 A=n9018 B=n8904
XU11613 MXL2HS $PINS OB=n488 S=FE_OFN291_FE_DBTN1_n7298 A=n8905 B=n8915
XU11614 MXL2HS $PINS OB=n489 S=FE_OFN171_FE_DBTN1_n7298 A=n8906 B=n8913
XU11615 INV1S $PINS O=n9022 I=weight_2_w[15]
XU11616 MXL2HS $PINS OB=n454 S=FE_OFN172_FE_DBTN1_n7298 A=n9022 B=n8907
XU11617 INV1S $PINS O=n8910 I=Buffer/data_buffer[1216]
XU11618 MXL2HS $PINS OB=n493 S=FE_OFN283_FE_DBTN1_n7298 A=n8908 B=n8910
XU11619 MXL2HS $PINS OB=n485 S=FE_OFN283_FE_DBTN1_n7298 A=n8910 B=n9024
XU11620 MXL2HS $PINS OB=n484 S=FE_OFN171_FE_DBTN1_n7298 A=n8911 B=n9013
XU11621 MXL2HS $PINS OB=n482 S=FE_OFN68_FE_DBTN1_n7298 A=n8912 B=n9012
XU11622 MXL2HS $PINS OB=n479 S=FE_OFN70_FE_DBTN1_n7298 A=n8913 B=n9021
XU11623 MXL2HS $PINS OB=n483 S=FE_OFN34_FE_DBTN1_n7298 A=n8914 B=n9007
XU11624 MXL2HS $PINS OB=n476 S=FE_OFN291_FE_DBTN1_n7298 A=n8915 B=n9020
XU11625 MXL2HS $PINS OB=n470 S=FE_OFN70_FE_DBTN1_n7298 A=n8917 B=n9002
XU11626 MXL2HS $PINS OB=n473 S=FE_OFN291_FE_DBTN1_n7298 A=n8918 B=n8999
XU11627 NR2 $PINS O=n8933 I1=n8924 I2=n8923
XU11628 AOI12HS $PINS O=n8939 A1=n8937 B1=n2596 B2=n8938
XU11629 XOR2HS $PINS O=pConv_2/product_1_w[15] I1=n8940 I2=n8939
XU11630 INV1S $PINS O=n8942 I=n8941
XU11631 ND2S $PINS O=n8946 I1=n8943 I2=n8942
XU11632 INV1S $PINS O=n8948 I=n8944
XU11633 INV1S $PINS O=n8945 I=n8947
XU11634 ND2S $PINS O=n8949 I1=n8947 I2=n8948
XU11635 XNR2HS $PINS O=pConv_2/product_1_w[13] I1=n8949 I2=n2596
XU11636 INV1S $PINS O=n8952 I=n8950
XU11637 ND2S $PINS O=n8961 I1=n8951 I2=n8952
XU11638 XNR2HS $PINS O=pConv_2/product_1_w[12] I1=n8961 I2=n8960
XU11639 ND2 $PINS O=n8967 I1=n8963 I2=n8962
XU11640 XOR2HS $PINS O=pConv_2/product_1_w[8] I1=n8967 I2=n8966
XU11641 INV1S $PINS O=n8970 I=n8968
XU11642 OA12 $PINS O=n8975 A1=n8969 B1=n8971 B2=n8970
XU11643 INV1S $PINS O=n8973 I=n2867
XU11644 NR2 $PINS O=n8974 I1=n8973 I2=n8972
XU11645 XNR2HS $PINS O=pConv_2/product_1_w[6] I1=n8975 I2=n8974
XU11646 INV1S $PINS O=n8977 I=n8976
XU11647 NR2 $PINS O=n8980 I1=n8977 I2=n8978
XU11648 XOR2HS $PINS O=pConv_2/product_1_w[4] I1=n8979 I2=n8980
XU11649 INV1S $PINS O=n8982 I=n8981
XU11650 NR2 $PINS O=n8984 I1=n8983 I2=n8982
XU11651 XNR2HS $PINS O=pConv_2/product_1_w[3] I1=n8985 I2=n8984
XU11652 INV1S $PINS O=n8988 I=n8986
XU11653 XOR2HS $PINS O=pConv_2/product_1_w[2] I1=n8992 I2=n8989
XU11654 AN2 $PINS O=n8994 I1=n8991 I2=n8990
XU11655 INV1S $PINS O=n8993 I=n8992
XU11656 NR2 $PINS O=pConv_2/product_1_w[1] I1=n8994 I2=n8993
XU11657 NR2 $PINS O=pConv_2/product_1_w[0] I1=n8996 I2=FE_OFN1546_n8995
XU11658 INV1S $PINS O=n8998 I=weight_2_w[17]
XU11659 MXL2HS $PINS OB=n400 S=FE_OFN69_FE_DBTN1_n7298 A=n8998 B=n8997
XU11660 MXL2HS $PINS OB=n472 S=FE_OFN231_FE_DBTN1_n7298 A=n8999 B=n9044
XU11661 INV1S $PINS O=n9001 I=weight_2_w[16]
XU11662 MXL2HS $PINS OB=n391 S=FE_OFN69_FE_DBTN1_n7298 A=n9001 B=n9000
XU11663 MXL2HS $PINS OB=n469 S=FE_OFN173_FE_DBTN1_n7298 A=n9002 B=n9041
XU11664 INV1S $PINS O=n9005 I=weight_2_w[21]
XU11665 MXL2HS $PINS OB=n436 S=FE_OFN69_FE_DBTN1_n7298 A=n9005 B=n9004
XU11666 MXL2HS $PINS OB=n463 S=FE_OFN70_FE_DBTN1_n7298 A=n9007 B=n9035
XU11667 INV1S $PINS O=n9009 I=weight_2_w[20]
XU11668 MXL2HS $PINS OB=n427 S=FE_OFN172_FE_DBTN1_n7298 A=n9009 B=n9008
XU11669 INV1S $PINS O=n9011 I=weight_2_w[19]
XU11670 MXL2HS $PINS OB=n418 S=FE_OFN69_FE_DBTN1_n7298 A=n9011 B=n9010
XU11671 MXL2HS $PINS OB=n481 S=FE_OFN118_FE_DBTN1_n7298 A=n9012 B=n9031
XU11672 MXL2HS $PINS OB=n465 S=FE_OFN233_FE_DBTN1_n7298 A=n9013 B=n9029
XU11673 INV1S $PINS O=n9016 I=weight_2_w[22]
XU11674 MXL2HS $PINS OB=n445 S=FE_OFN172_FE_DBTN1_n7298 A=n9016 B=n9015
XU11675 INV1S $PINS O=n9019 I=weight_2_w[18]
XU11676 MXL2HS $PINS OB=n409 S=FE_OFN69_FE_DBTN1_n7298 A=n9019 B=n9018
XU11677 MXL2HS $PINS OB=n475 S=FE_OFN232_FE_DBTN1_n7298 A=n9020 B=n9038
XU11678 MXL2HS $PINS OB=n478 S=FE_OFN173_FE_DBTN1_n7298 A=n9021 B=n9033
XU11679 INV1S $PINS O=n9023 I=weight_2_w[23]
XU11680 MXL2HS $PINS OB=n390 S=FE_OFN172_FE_DBTN1_n7298 A=n9023 B=n9022
XU11681 INV1S $PINS O=n9027 I=Buffer/data_buffer[1232]
XU11682 MXL2HS $PINS OB=n467 S=FE_OFN286_FE_DBTN1_n7298 A=n9024 B=n9027
XU11683 MXL2HS $PINS OB=n466 S=FE_OFN286_FE_DBTN1_n7298 A=n9027 B=n9026
XU11684 MXL2HS $PINS OB=n464 S=FE_OFN233_FE_DBTN1_n7298 A=n9029 B=n9028
XU11685 MXL2HS $PINS OB=n480 S=FE_OFN231_FE_DBTN1_n7298 A=n9031 B=n9030
XU11686 MXL2HS $PINS OB=n477 S=FE_OFN75_FE_DBTN1_n7298 A=n9033 B=n9032
XU11687 MXL2HS $PINS OB=n462 S=FE_OFN231_FE_DBTN1_n7298 A=n9035 B=n9034
XU11688 MXL2HS $PINS OB=n474 S=FE_OFN122_FE_DBTN1_n7298 A=n9038 B=n9037
XU11689 MXL2HS $PINS OB=n468 S=FE_OFN75_FE_DBTN1_n7298 A=n9041 B=n9040
XU11690 MXL2HS $PINS OB=n471 S=FE_OFN124_FE_DBTN1_n7298 A=n9044 B=n9043
XU11691 XNR2HS $PINS O=n9052 I1=n9047 I2=n9046
XU11692 XNR2HS $PINS O=n9057 I1=n9052 I2=n9051
XU11693 XNR2HS $PINS O=n9065 I1=n9057 I2=n9056
XU11694 OAI12HS $PINS O=n9064 A1=n9060 B1=n9062 B2=n9061
XU11695 ND2S $PINS O=n9071 I1=n9067 I2=n9066
XU11696 XOR2HS $PINS O=pConv_2/product_2_w[15] I1=n9071 I2=n9070
XU11697 ND2S $PINS O=n9075 I1=n1961 I2=n9072
XU11699 XOR2HS $PINS O=pConv_2/product_2_w[14] I1=n9075 I2=n9074
XU11700 ND2S $PINS O=n9079 I1=n9076 I2=FE_DBTN4_n9073
XU11701 XNR2HS $PINS O=pConv_2/product_2_w[13] I1=n9079 I2=n9078
XU11702 INV1S $PINS O=n9082 I=n9080
XU11703 XNR2HS $PINS O=pConv_2/product_2_w[12] I1=n9088 I2=n9087
XU11704 XOR2HS $PINS O=pConv_2/product_2_w[8] I1=n9091 I2=n9090
XU11706 OA12 $PINS O=n9100 A1=n9093 B1=n9095 B2=n3761
XU11707 INV1S $PINS O=n9098 I=n9096
XU11708 NR2 $PINS O=n9099 I1=n9098 I2=n9097
XU11709 XNR2HS $PINS O=pConv_2/product_2_w[6] I1=n9100 I2=n9099
XU11710 INV1S $PINS O=n9103 I=n9101
XU11711 NR2 $PINS O=n9105 I1=n9103 I2=n9102
XU11712 XOR2HS $PINS O=pConv_2/product_2_w[4] I1=n9104 I2=n9105
XU11713 INV1S $PINS O=n9107 I=n9106
XU11714 NR2 $PINS O=n9109 I1=n9107 I2=n9108
XU11715 XNR2HS $PINS O=pConv_2/product_2_w[3] I1=n9110 I2=n9109
XU11716 INV1S $PINS O=n9113 I=n9111
XU11717 XOR2HS $PINS O=pConv_2/product_2_w[2] I1=n9117 I2=n9114
XU11718 AN2 $PINS O=n9119 I1=n9116 I2=n9115
XU11719 INV1S $PINS O=n9118 I=n9117
XU11720 NR2 $PINS O=pConv_2/product_2_w[1] I1=n9119 I2=n9118
XU11721 ND2 $PINS O=n9124 I1=FE_OFN1341_weight_1_r_7 I2=data_1_r[7]
XU11722 XNR2HS $PINS O=n9129 I1=n9124 I2=n9123
XU11723 XNR2HS $PINS O=n9134 I1=n9129 I2=n9128
XU11725 XOR2HS $PINS O=pConv_1/product_0_w[15] I1=n9151 I2=n9150
XU11726 INV1S $PINS O=n9154 I=n9152
XU11727 ND2S $PINS O=n9157 I1=n9154 I2=n9153
XU11728 INV1S $PINS O=n9159 I=n9155
XU11729 INV1S $PINS O=n9156 I=n9158
XU11730 XNR2HS $PINS O=pConv_1/product_0_w[13] I1=n3757 I2=n9160
XU11731 XNR2HS $PINS O=pConv_1/product_0_w[12] I1=n9170 I2=n9169
XU11732 ND2 $PINS O=n9177 I1=n9172 I2=n9171
XU11733 XOR2HS $PINS O=pConv_1/product_0_w[8] I1=n9177 I2=n9176
XU11734 INV1S $PINS O=n9180 I=n9178
XU11735 OA12 $PINS O=n9186 A1=n9179 B1=n9181 B2=n9180
XU11736 INV1S $PINS O=n9184 I=n9182
XU11737 NR2 $PINS O=n9185 I1=n9184 I2=n9183
XU11738 XNR2HS $PINS O=pConv_1/product_0_w[6] I1=n9186 I2=n9185
XU11739 INV1S $PINS O=n9188 I=n9187
XU11740 NR2 $PINS O=n9190 I1=n9189 I2=n9188
XU11741 XOR2HS $PINS O=pConv_1/product_0_w[4] I1=n9191 I2=n9190
XU11742 INV1S $PINS O=n9193 I=n9192
XU11743 NR2 $PINS O=n9195 I1=n9194 I2=n9193
XU11744 XNR2HS $PINS O=pConv_1/product_0_w[3] I1=n9196 I2=n9195
XU11745 INV1S $PINS O=n9199 I=n9197
XU11746 ND2S $PINS O=n9200 I1=n9199 I2=n9198
XU11747 XOR2HS $PINS O=pConv_1/product_0_w[2] I1=n9203 I2=n9200
XU11748 AN2 $PINS O=n9205 I1=n9202 I2=n9201
XU11749 INV1S $PINS O=n9204 I=n9203
XU11750 NR2 $PINS O=pConv_1/product_0_w[1] I1=n9205 I2=n9204
XU11751 NR2 $PINS O=pConv_1/product_0_w[0] I1=n3102 I2=FE_DBTN49_data_1_r_1
XU11752 ND2 $PINS O=n9209 I1=FE_OFN1317_weight_1_r_15 I2=data_1_r[23]
XU11753 XNR2HS $PINS O=n9213 I1=FE_OFN1319_weight_1_r_15 I2=data_1_r[31]
XU11754 XNR2HS $PINS O=n9215 I1=n9209 I2=n9208
XU11755 ND2S $PINS O=n9237 I1=FE_OFN1317_weight_1_r_15 I2=data_1_r[21]
XU11756 INV1S $PINS O=n9219 I=n9237
XU11757 INV1S $PINS O=n9210 I=data_1_r[22]
XU11758 NR2 $PINS O=n9218 I1=FE_OFN1431_FE_DBTN26_weight_1_r_15 I2=n9210
XU11759 XNR2HS $PINS O=n9223 I1=FE_OFN1319_weight_1_r_15 I2=data_1_r[30]
XU11760 OAI22S $PINS O=n9217 A1=n9223 A2=n3897 B1=FE_DBTN21_n3428 B2=n9213
XU11761 XNR2HS $PINS O=n9228 I1=n9215 I2=n9214
XU11762 OAI22S $PINS O=n9235 A1=n9226 A2=n3897 B1=FE_DBTN21_n3428 B2=n9223
XU11763 OAI12HS $PINS O=n9256 A1=n9263 B1=n9262 B2=n9265
XU11764 INV1S $PINS O=n9264 I=n9262
XU11765 NR2 $PINS O=n9280 I1=n9272 I2=n9271
XU11766 AOI12H $PINS O=n9286 A1=n9284 B1=FE_OFN1692_n4047 B2=n2748
XU11767 XOR2HS $PINS O=pConv_1/product_1_w[15] I1=n9287 I2=n9286
XU11768 INV1S $PINS O=n9290 I=n9288
XU11769 INV1S $PINS O=n9296 I=n9291
XU11770 AOI12H $PINS O=n9293 A1=n9292 B1=FE_OFN1692_n4047 B2=n9296
XU11771 XOR2HS $PINS O=pConv_1/product_1_w[14] I1=n9294 I2=n9293
XU11772 ND2S $PINS O=n9297 I1=n9295 I2=n9296
XU11773 XNR2HS $PINS O=pConv_1/product_1_w[13] I1=FE_OFN1692_n4047 I2=n9297
XU11774 ND3 $PINS O=n9303 I1=n9302 I2=n9304 I3=n9301
XU11775 XOR2HS $PINS O=pConv_1/product_1_w[11] I1=n9308 I2=n9307
XU11776 INV1S $PINS O=n9310 I=n9309
XU11777 NR2 $PINS O=n9317 I1=n9310 I2=n9311
XU11778 INV1S $PINS O=n9313 I=n9312
XU11779 XNR2HS $PINS O=pConv_1/product_1_w[10] I1=n9317 I2=n9316
XU11780 ND2 $PINS O=n9323 I1=n9319 I2=n9318
XU11781 AOI12HS $PINS O=n9322 A1=n9320 B1=n3188 B2=n9321
XU11782 XOR2HS $PINS O=pConv_1/product_1_w[8] I1=n9323 I2=n9322
XU11783 INV1S $PINS O=n9325 I=n9324
XU11784 NR2 $PINS O=n9329 I1=n9327 I2=n9328
XU11785 XNR2HS $PINS O=pConv_1/product_1_w[6] I1=n9330 I2=n9329
XU11786 NR2 $PINS O=n9333 I1=n9331 I2=n9332
XU11787 XOR2HS $PINS O=pConv_1/product_1_w[4] I1=n9334 I2=n9333
XU11788 INV1S $PINS O=n9336 I=n9335
XU11789 NR2 $PINS O=n9338 I1=n9337 I2=n9336
XU11790 XNR2HS $PINS O=pConv_1/product_1_w[3] I1=n9339 I2=n9338
XU11791 INV1S $PINS O=n9342 I=n9340
XU11792 ND2S $PINS O=n9343 I1=n9342 I2=n9341
XU11793 AN2 $PINS O=n9347 I1=n9345 I2=n9344
XU11794 NR2 $PINS O=pConv_1/product_1_w[1] I1=n9347 I2=n9346
XU11795 NR2 $PINS O=pConv_1/product_1_w[0] I1=n9349 I2=n9348
XU11796 NR2P $PINS O=n9358 I1=n9350 I2=n9351
XU11797 ND3P $PINS O=n9357 I1=n9356 I2=n9355 I3=n9354
XU11799 INV1S $PINS O=n9361 I=n9359
XU11800 INV1S $PINS O=n9370 I=n9368
XU11801 ND2S $PINS O=n9374 I1=n9370 I2=n9369
XU11802 XNR2HS $PINS O=pConv_1/product_2_w[16] I1=n9374 I2=n9373
XU11803 INV1S $PINS O=n9378 I=n9377
XU11804 XOR2H $PINS O=pConv_1/product_2_w[15] I1=n9381 I2=n9380
XU11805 INV1S $PINS O=n9386 I=n9384
XU11806 XNR2HS $PINS O=pConv_1/product_2_w[13] I1=n9388 I2=FE_OCPN9760_n6309
XU11807 INV1S $PINS O=n9391 I=n9389
XU11808 ND3 $PINS O=n9395 I1=n9398 I2=n9393 I3=n9394
XU11809 XNR2HS $PINS O=pConv_1/product_2_w[12] I1=n9396 I2=n9395
XU11810 ND2S $PINS O=n9401 I1=n9398 I2=n9397
XU11811 XOR2HS $PINS O=pConv_1/product_2_w[11] I1=n9401 I2=n9400
XU11812 INV1S $PINS O=n9403 I=n9402
XU11813 NR2 $PINS O=n9409 I1=n9404 I2=n9403
XU11814 XNR2HS $PINS O=pConv_1/product_2_w[10] I1=n9409 I2=n9408
XU11815 OA12 $PINS O=n9415 A1=n9410 B1=n9411 B2=n6217
XU11816 NR2 $PINS O=n9414 I1=n3654 I2=n9413
XU11817 XNR2HS $PINS O=pConv_1/product_2_w[6] I1=n9415 I2=n9414
XU11818 INV1S $PINS O=n9417 I=n9416
XU11819 XOR2HS $PINS O=pConv_1/product_2_w[4] I1=n9419 I2=n9420
XU11820 INV1S $PINS O=n9422 I=n9421
XU11821 XNR2HS $PINS O=pConv_1/product_2_w[3] I1=n9424 I2=n9423
XU11822 INV1S $PINS O=n9427 I=n9425
XU11823 ND2S $PINS O=n9428 I1=n9426 I2=n9427
XU11824 XOR2HS $PINS O=pConv_1/product_2_w[2] I1=n9430 I2=n9428
XU11825 INV1S $PINS O=n9431 I=n9430
XU11826 NR2 $PINS O=pConv_1/product_2_w[1] I1=n9432 I2=n9431
XU11827 NR2 $PINS O=pConv_1/product_2_w[0] I1=FE_OFN1316_weight_1_r_16
+ I2=FE_OFN1548_n9433
XU11828 ND2 $PINS O=n9438 I1=FE_OFN1286_weight_0_r_7 I2=data_0_r[7]
XU11829 XNR2HS $PINS O=n9440 I1=FE_OFN1286_weight_0_r_7 I2=data_0_r[15]
XU11830 MOAI1S $PINS O=n9437 A1=FE_OFN1631_n6658 A2=n9440
+ B1=FE_OFN1286_weight_0_r_7 B2=FE_OFN9144_n9457
XU11831 XNR2HS $PINS O=n9442 I1=n9438 I2=n9437
XU11832 INV1S $PINS O=n9439 I=data_0_r[6]
XU11833 NR2 $PINS O=n9445 I1=FE_DBTN0_weight_0_r_7 I2=n9439
XU11834 XNR2HS $PINS O=n9447 I1=FE_OFN1286_weight_0_r_7 I2=data_0_r[14]
XU11835 OAI22S $PINS O=n9444 A1=n9447 A2=FE_OFN1631_n6658 B1=n9435 B2=n9440
XU11836 XNR2HS $PINS O=n9450 I1=n9442 I2=n9441
XU11837 OAI12HS $PINS O=n9453 A1=FE_OFN1289_weight_0_r_5 B1=FE_OFN9121_n2908
+ B2=n9443
XU11838 XNR2HS $PINS O=n9456 I1=FE_OFN1285_weight_0_r_7 I2=data_0_r[13]
XU11839 NR2 $PINS O=n9472 I1=n9455 I2=FE_DBTN0_weight_0_r_7
XU11840 OAI22S $PINS O=n9471 A1=n9459 A2=FE_OFN1631_n6658 B1=n9435 B2=n9456
XU11841 FA1 $PINS S=n9476 CO=n9474 A=n9470 B=n9469 CI=n9468
XU11842 FA1 $PINS S=n9489 CO=n9491 A=n9480 B=n9479 CI=n9478
XU11843 FA1 $PINS S=n7200 CO=n9492 A=n9483 B=n9482 CI=n9481
XU11844 ND2S $PINS O=n9502 I1=n9491 I2=n9490
XU11845 OAI12HS $PINS O=n9496 A1=n9502 B1=n9504 B2=n9501
XU11846 OA12P $PINS O=n9514 A1=n9518 B1=n9523 B2=n9517
XU11847 NR2 $PINS O=n9495 I1=n9494 I2=n9514
XU11848 INV1S $PINS O=n9503 I=n9501
XU11849 INV1S $PINS O=n9509 I=n9504
XU11850 NR2 $PINS O=n9505 I1=n9510 I2=n9514
XU11851 INV2 $PINS O=n9512 I=n9511
XU11852 INV1S $PINS O=n9519 I=n9517
XU11853 INV1S $PINS O=n9528 I=n9526
XU11854 XNR2HS $PINS O=pConv_0/product_0_w[16] I1=n9532 I2=n9531
XU11856 INV1S $PINS O=n9541 I=n9540
XU11857 AOI12H $PINS O=n9543 A1=n9541 B1=n2751 B2=n9542
XU11859 ND2S $PINS O=n9553 I1=n9547 I2=n9548
XU11860 ND3 $PINS O=n9554 I1=n9551 I2=n9553 I3=n9552
XU11861 XNR2HS $PINS O=pConv_0/product_0_w[12] I1=n9555 I2=n9554
XU11862 ND2 $PINS O=n9561 I1=n9557 I2=n9556
XU11863 AOI12HS $PINS O=n9560 A1=n9558 B1=n9559 B2=n2911
XU11864 XOR2HS $PINS O=pConv_0/product_0_w[8] I1=n9561 I2=n9560
XU11865 INV1S $PINS O=n9564 I=n9562
XU11866 OA12 $PINS O=n9569 A1=n9563 B1=n9565 B2=n9564
XU11867 NR2 $PINS O=n9568 I1=n9566 I2=n9567
XU11868 XNR2HS $PINS O=pConv_0/product_0_w[6] I1=n9569 I2=n9568
XU11869 INV1S $PINS O=n9571 I=n9570
XU11870 NR2 $PINS O=n9573 I1=n9571 I2=n9572
XU11871 XOR2HS $PINS O=pConv_0/product_0_w[4] I1=n9574 I2=n9573
XU11872 INV1S $PINS O=n9576 I=n9575
XU11873 NR2 $PINS O=n9578 I1=n9577 I2=n9576
XU11874 XNR2HS $PINS O=pConv_0/product_0_w[3] I1=n9579 I2=n9578
XU11875 INV1S $PINS O=n9581 I=n9580
XU11876 XOR2HS $PINS O=pConv_0/product_0_w[2] I1=n9586 I2=n9583
XU11877 AN2 $PINS O=n9588 I1=n9585 I2=n9584
XU11878 INV1S $PINS O=n9587 I=n9586
XU11879 NR2 $PINS O=pConv_0/product_0_w[1] I1=n9588 I2=n9587
XU11880 MOAI1S $PINS O=n9593 A1=FE_OFN1626_n6531 A2=n9591
+ B1=FE_OFN1268_weight_0_r_15 B2=FE_OFN1628_n6532
XU11881 XNR2HS $PINS O=n9599 I1=n9594 I2=n9593
XU11882 XNR2HS $PINS O=n9604 I1=n9599 I2=n9598
XU11883 OAI12HS $PINS O=n9611 A1=n9606 B1=n9607 B2=n9608
XU11884 NR2 $PINS O=n9623 I1=n9616 I2=n9615
XU11886 ND2S $PINS O=n9638 I1=n2069 I2=n9634
XU11888 INV1S $PINS O=n9646 I=n9645
XU11889 ND2S $PINS O=n9652 I1=n9647 I2=n9646
XU11890 INV1S $PINS O=n9649 I=n9648
XU11891 XOR2HS $PINS O=pConv_0/product_1_w[14] I1=n9652 I2=n9651
XU11892 INV1S $PINS O=n9655 I=n9653
XU11893 ND3 $PINS O=n9661 I1=n9659 I2=n9660 I3=n9658
XU11894 XNR2HS $PINS O=pConv_0/product_1_w[12] I1=n9662 I2=n9661
XU11895 XOR2HS $PINS O=pConv_0/product_1_w[8] I1=n9668 I2=n9667
XU11896 OA12 $PINS O=n9676 A1=n9669 B1=n9671 B2=n9670
XU11897 INV1S $PINS O=n9674 I=n9672
XU11898 NR2 $PINS O=n9675 I1=n9674 I2=n9673
XU11899 XNR2HS $PINS O=pConv_0/product_1_w[6] I1=n9676 I2=n9675
XU11901 NR2 $PINS O=n9681 I1=n3305 I2=n9679
XU11902 XOR2HS $PINS O=pConv_0/product_1_w[4] I1=n9680 I2=n9681
XU11903 INV1S $PINS O=n9683 I=n9682
XU11904 NR2 $PINS O=n9685 I1=n9683 I2=n9684
XU11905 XNR2HS $PINS O=pConv_0/product_1_w[3] I1=n9686 I2=n9685
XU11906 INV1S $PINS O=n9689 I=n9687
XU11907 ND2S $PINS O=n9690 I1=n9689 I2=n9688
XU11908 XOR2HS $PINS O=pConv_0/product_1_w[2] I1=n9693 I2=n9690
XU11909 AN2 $PINS O=n9695 I1=n9692 I2=n9691
XU11910 INV1S $PINS O=n9694 I=n9693
XU11911 NR2 $PINS O=pConv_0/product_1_w[1] I1=n9695 I2=n9694
XU11912 NR2 $PINS O=pConv_0/product_1_w[0] I1=n2771 I2=n9696
XU11913 ND2 $PINS O=n9699 I1=FE_OFN1249_weight_0_r_23 I2=data_0_r[39]
XU11914 XNR2HS $PINS O=n9703 I1=FE_OFN1251_weight_0_r_23 I2=data_0_r[47]
XU11915 MOAI1S $PINS O=n9698 A1=n6448 A2=n9703 B1=FE_OFN1251_weight_0_r_23
+ B2=n9697
XU11916 XNR2HS $PINS O=n9705 I1=n9699 I2=n9698
XU11917 INV1S $PINS O=n9710 I=n9725
XU11918 INV1S $PINS O=n9700 I=data_0_r[38]
XU11919 NR2 $PINS O=n9709 I1=FE_OFN1432_FE_DBTN23_weight_0_r_23 I2=n9700
XU11920 XNR2HS $PINS O=n9712 I1=FE_OFN1251_weight_0_r_23 I2=data_0_r[46]
XU11921 XNR2HS $PINS O=n9717 I1=n9705 I2=n9704
XU11922 XNR2HS $PINS O=n9746 I1=n9717 I2=n9716
XU11923 OAI12HS $PINS O=n9743 A1=n9748 B1=n9751 B2=n9747
XU11924 INV1S $PINS O=n9749 I=n9747
XU11925 NR2 $PINS O=n9763 I1=n9752 I2=n9753
XU11926 ND3 $PINS O=n9760 I1=n2822 I2=n9756 I3=n9757
XU11928 INV1S $PINS O=n9771 I=n9769
XU11929 INV1S $PINS O=n9774 I=n9772
XU11930 ND2S $PINS O=n9777 I1=n9775 I2=n9774
XU11931 XNR2HS $PINS O=pConv_0/product_2_w[13] I1=n9758 I2=n9777
XU11932 INV1S $PINS O=n9780 I=n9778
XU11933 ND3 $PINS O=n9786 I1=n9784 I2=n9785 I3=n9783
XU11934 XNR2HS $PINS O=pConv_0/product_2_w[12] I1=n9787 I2=n9786
XU11935 ND2 $PINS O=n9793 I1=n9789 I2=n9788
XU11936 XOR2HS $PINS O=pConv_0/product_2_w[8] I1=n9793 I2=n9792
XU11937 OA12 $PINS O=n9800 A1=n9795 B1=n3772 B2=n9796
XU11938 NR2 $PINS O=n9799 I1=n9798 I2=n9797
XU11939 XNR2HS $PINS O=pConv_0/product_2_w[6] I1=n9800 I2=n9799
XU11941 NR2 $PINS O=n9804 I1=n2543 I2=n9803
XU11942 XOR2HS $PINS O=pConv_0/product_2_w[4] I1=n9805 I2=n9804
XU11943 INV1S $PINS O=n9807 I=n9806
XU11944 NR2 $PINS O=n9809 I1=n9807 I2=n9808
XU11945 XNR2HS $PINS O=pConv_0/product_2_w[3] I1=n9810 I2=n9809
XU11946 INV1S $PINS O=n9813 I=n9811
XU11947 ND2S $PINS O=n9814 I1=n9812 I2=n9813
XU11948 XOR2HS $PINS O=pConv_0/product_2_w[2] I1=n9817 I2=n9814
XU11949 AN2 $PINS O=n9819 I1=n9816 I2=n9815
XU11950 INV1S $PINS O=n9818 I=n9817
XU11951 NR2 $PINS O=pConv_0/product_2_w[1] I1=n9819 I2=n9818
XU11952 INV1S $PINS O=n9821 I=buffer_pmp[522]
XU11953 INV1S $PINS O=n9820 I=buffer_pmp[1110]
XU11954 MXL2HS $PINS OB=pmp_1_w[18] S=FE_OFN1184_n5413 A=n9821 B=n9820
XU11955 INV1S $PINS O=n9824 I=buffer_pmp[521]
XU11956 INV1S $PINS O=n9823 I=buffer_pmp[1109]
XU11957 MXL2HS $PINS OB=pmp_1_w[17] S=FE_OFN1184_n5413 A=n9824 B=n9823
XU11958 INV1S $PINS O=n9826 I=buffer_pmp[520]
XU11959 INV1S $PINS O=n9825 I=buffer_pmp[1108]
XU11960 MXL2HS $PINS OB=pmp_1_w[16] S=FE_OFN1179_n5413 A=n9826 B=n9825
XU11961 INV1S $PINS O=n9828 I=buffer_pmp[519]
XU11962 INV1S $PINS O=n9827 I=buffer_pmp[1107]
XU11963 MXL2HS $PINS OB=pmp_1_w[15] S=FE_OFN1175_n5413 A=n9828 B=n9827
XU11964 INV1S $PINS O=n9830 I=buffer_pmp[518]
XU11965 INV1S $PINS O=n9829 I=buffer_pmp[1106]
XU11966 MXL2HS $PINS OB=pmp_1_w[14] S=FE_OFN1175_n5413 A=n9830 B=n9829
XU11967 INV1S $PINS O=n9832 I=buffer_pmp[517]
XU11968 INV1S $PINS O=n9831 I=buffer_pmp[1105]
XU11969 MXL2HS $PINS OB=pmp_1_w[13] S=FE_OFN1172_n5413 A=n9832 B=n9831
XU11970 INV1S $PINS O=n9835 I=buffer_pmp[516]
XU11971 INV1S $PINS O=n9834 I=buffer_pmp[1104]
XU11972 MXL2HS $PINS OB=pmp_1_w[12] S=FE_OFN1172_n5413 A=n9835 B=n9834
XU11973 INV1S $PINS O=n9837 I=buffer_pmp[515]
XU11974 INV1S $PINS O=n9836 I=buffer_pmp[1103]
XU11975 MXL2HS $PINS OB=pmp_1_w[11] S=FE_OFN1172_n5413 A=n9837 B=n9836
XU11976 INV1S $PINS O=n9839 I=buffer_pmp[514]
XU11977 INV1S $PINS O=n9838 I=buffer_pmp[1102]
XU11978 MXL2HS $PINS OB=pmp_1_w[10] S=FE_OFN1175_n5413 A=n9839 B=n9838
XU11979 INV1S $PINS O=n9841 I=buffer_pmp[513]
XU11980 INV1S $PINS O=n9840 I=buffer_pmp[1101]
XU11981 MXL2HS $PINS OB=pmp_1_w[9] S=FE_OFN1179_n5413 A=n9841 B=n9840
XU11982 INV1S $PINS O=n9843 I=buffer_pmp[512]
XU11983 INV1S $PINS O=n9842 I=buffer_pmp[1100]
XU11984 MXL2HS $PINS OB=pmp_1_w[8] S=FE_OFN1179_n5413 A=n9843 B=n9842
XU11985 INV1S $PINS O=n9845 I=buffer_pmp[511]
XU11986 INV1S $PINS O=n9844 I=buffer_pmp[1099]
XU11987 MXL2HS $PINS OB=pmp_1_w[7] S=FE_OFN1175_n5413 A=n9845 B=n9844
XU11988 INV1S $PINS O=n9848 I=buffer_pmp[510]
XU11989 INV1S $PINS O=n9847 I=buffer_pmp[1098]
XU11990 MXL2HS $PINS OB=pmp_1_w[6] S=FE_OFN1175_n5413 A=n9848 B=n9847
XU11991 INV1S $PINS O=n9850 I=buffer_pmp[509]
XU11992 INV1S $PINS O=n9849 I=buffer_pmp[1097]
XU11993 MXL2HS $PINS OB=pmp_1_w[5] S=FE_OFN1179_n5413 A=n9850 B=n9849
XU11994 INV1S $PINS O=n9852 I=buffer_pmp[508]
XU11995 INV1S $PINS O=n9851 I=buffer_pmp[1096]
XU11996 MXL2HS $PINS OB=pmp_1_w[4] S=FE_OFN1179_n5413 A=n9852 B=n9851
XU11997 INV1S $PINS O=n9854 I=buffer_pmp[507]
XU11998 INV1S $PINS O=n9853 I=buffer_pmp[1095]
XU11999 MXL2HS $PINS OB=pmp_1_w[3] S=FE_OFN1184_n5413 A=n9854 B=n9853
XU12000 INV1S $PINS O=n9856 I=buffer_pmp[506]
XU12001 INV1S $PINS O=n9855 I=buffer_pmp[1094]
XU12002 MXL2HS $PINS OB=pmp_1_w[2] S=FE_OFN1184_n5413 A=n9856 B=n9855
XU12003 INV1S $PINS O=n9859 I=buffer_pmp[505]
XU12004 INV1S $PINS O=n9858 I=buffer_pmp[1093]
XU12005 MXL2HS $PINS OB=pmp_1_w[1] S=FE_OFN1184_n5413 A=n9859 B=n9858
XU12006 INV1S $PINS O=n9862 I=buffer_pmp[504]
XU12007 INV1S $PINS O=n9861 I=buffer_pmp[1092]
XU12008 MXL2HS $PINS OB=pmp_1_w[0] S=FE_OFN1184_n5413 A=n9862 B=n9861
.ENDS

.SUBCKT CHIP clk rst_n layer_num[1] layer_num[0] i_data[7] i_data[6] i_data[5]
+ i_data[4] i_data[3] i_data[2] i_data[1] i_data[0] o_data[14] o_data[13]
+ o_data[12] o_data[11] o_data[10] o_data[9] o_data[8] o_data[7] o_data[6]
+ o_data[5] o_data[4] o_data[3] o_data[2] o_data[1] o_data[0]
XFE_OFC1155_n_logic1 BUF1 $PINS O=FE_OFN1155_n_logic1 I=FE_OFN1154_n_logic1
XFE_OFC1154_n_logic1 BUF1 $PINS O=FE_OFN1154_n_logic1 I=n_logic1
XFE_OFC1153_n_logic0 BUF1S $PINS O=FE_OFN1153_n_logic0 I=FE_OFN1152_n_logic0
XFE_OFC1152_n_logic0 BUF1S $PINS O=FE_OFN1152_n_logic0 I=FE_OFN1151_n_logic0
XFE_OFC1151_n_logic0 BUF1 $PINS O=FE_OFN1151_n_logic0 I=FE_OFN1150_n_logic0
XFE_OFC1150_n_logic0 BUF1S $PINS O=FE_OFN1150_n_logic0 I=FE_OFN1149_n_logic0
XFE_OFC1149_n_logic0 BUF1S $PINS O=FE_OFN1149_n_logic0 I=FE_OFN1148_n_logic0
XFE_OFC1148_n_logic0 BUF1 $PINS O=FE_OFN1148_n_logic0 I=FE_OFN1146_n_logic0
XFE_OFC1147_n_logic0 BUF1 $PINS O=FE_OFN1147_n_logic0 I=FE_OFN1145_n_logic0
XFE_OFC1146_n_logic0 BUF1 $PINS O=FE_OFN1146_n_logic0 I=FE_OFN1144_n_logic0
XFE_OFC1145_n_logic0 BUF1S $PINS O=FE_OFN1145_n_logic0 I=FE_OFN1143_n_logic0
XFE_OFC1144_n_logic0 BUF1S $PINS O=FE_OFN1144_n_logic0 I=FE_OFN1142_n_logic0
XFE_OFC1143_n_logic0 BUF1S $PINS O=FE_OFN1143_n_logic0 I=FE_OFN1141_n_logic0
XFE_OFC1142_n_logic0 BUF1 $PINS O=FE_OFN1142_n_logic0 I=FE_OFN1140_n_logic0
XFE_OFC1141_n_logic0 BUF1 $PINS O=FE_OFN1141_n_logic0 I=FE_OFN1139_n_logic0
XFE_OFC1140_n_logic0 BUF1S $PINS O=FE_OFN1140_n_logic0 I=FE_OFN1138_n_logic0
XFE_OFC1139_n_logic0 BUF1S $PINS O=FE_OFN1139_n_logic0 I=FE_OFN1137_n_logic0
XFE_OFC1138_n_logic0 BUF1S $PINS O=FE_OFN1138_n_logic0 I=FE_OFN1136_n_logic0
XFE_OFC1137_n_logic0 BUF1 $PINS O=FE_OFN1137_n_logic0 I=FE_OFN1135_n_logic0
XFE_OFC1136_n_logic0 BUF1S $PINS O=FE_OFN1136_n_logic0 I=n_logic0
XFE_OFC1135_n_logic0 BUF1S $PINS O=FE_OFN1135_n_logic0 I=n_logic0
XTop_in Top $PINS clk=i_clk_p_i rst_n=i_reset_n_i layer_num[1]=i_layer_num[1]
+ layer_num[0]=i_layer_num[0] i_data[7]=i_i_data[7] i_data[6]=i_i_data[6]
+ i_data[5]=i_i_data[5] i_data[4]=i_i_data[4] i_data[3]=i_i_data[3]
+ i_data[2]=i_i_data[2] i_data[1]=i_i_data[1] i_data[0]=i_i_data[0]
+ o_data[14]=i_o_data[14] o_data[13]=i_o_data[13] o_data[12]=i_o_data[12]
+ o_data[11]=i_o_data[11] o_data[10]=i_o_data[10] o_data[9]=i_o_data[9]
+ o_data[8]=i_o_data[8] o_data[7]=i_o_data[7] o_data[6]=i_o_data[6]
+ o_data[5]=i_o_data[5] o_data[4]=i_o_data[4] o_data[3]=i_o_data[3]
+ o_data[2]=i_o_data[2] o_data[1]=i_o_data[1] o_data[0]=i_o_data[0]
Xipad_n_logic0 TIE0 $PINS O=n_logic0
Xipad_n_logic1 TIE1 $PINS O=n_logic1
Xipad_clk XMD $PINS O=i_clk_p_i I=clk PU=FE_OFN1143_n_logic0
+ PD=FE_OFN1143_n_logic0 SMT=FE_OFN1143_n_logic0
Xipad_rst_n XMD $PINS O=i_reset_n_i I=rst_n PU=FE_OFN1141_n_logic0
+ PD=FE_OFN1141_n_logic0 SMT=FE_OFN1141_n_logic0
Xipad_layer_num_0 XMD $PINS O=i_layer_num[0] I=layer_num[0]
+ PU=FE_OFN1141_n_logic0 PD=FE_OFN1141_n_logic0 SMT=FE_OFN1139_n_logic0
Xipad_layer_num_1 XMD $PINS O=i_layer_num[1] I=layer_num[1]
+ PU=FE_OFN1139_n_logic0 PD=FE_OFN1139_n_logic0 SMT=FE_OFN1139_n_logic0
Xipad_data_i_0 XMD $PINS O=i_i_data[0] I=i_data[0] PU=FE_OFN1137_n_logic0
+ PD=FE_OFN1139_n_logic0 SMT=FE_OFN1137_n_logic0
Xipad_data_i_1 XMD $PINS O=i_i_data[1] I=i_data[1] PU=FE_OFN1153_n_logic0
+ PD=FE_OFN1153_n_logic0 SMT=FE_OFN1153_n_logic0
Xipad_data_i_2 XMD $PINS O=i_i_data[2] I=i_data[2] PU=FE_OFN1153_n_logic0
+ PD=FE_OFN1153_n_logic0 SMT=FE_OFN1153_n_logic0
Xipad_data_i_3 XMD $PINS O=i_i_data[3] I=i_data[3] PU=FE_OFN1147_n_logic0
+ PD=FE_OFN1147_n_logic0 SMT=FE_OFN1147_n_logic0
Xipad_data_i_4 XMD $PINS O=i_i_data[4] I=i_data[4] PU=FE_OFN1147_n_logic0
+ PD=FE_OFN1147_n_logic0 SMT=FE_OFN1147_n_logic0
Xipad_data_i_5 XMD $PINS O=i_i_data[5] I=i_data[5] PU=FE_OFN1145_n_logic0
+ PD=FE_OFN1145_n_logic0 SMT=FE_OFN1145_n_logic0
Xipad_data_i_6 XMD $PINS O=i_i_data[6] I=i_data[6] PU=FE_OFN1152_n_logic0
+ PD=FE_OFN1152_n_logic0 SMT=FE_OFN1152_n_logic0
Xipad_data_i_7 XMD $PINS O=i_i_data[7] I=i_data[7] PU=FE_OFN1152_n_logic0
+ PD=FE_OFN1151_n_logic0 SMT=FE_OFN1152_n_logic0
Xipad_data_o_0 YA2GSD $PINS O=o_data[0] I=i_o_data[0] E=n_logic1
+ E2=FE_OFN1151_n_logic0 E4=FE_OFN1151_n_logic0 E8=FE_OFN1151_n_logic0
+ SR=FE_OFN1151_n_logic0
Xipad_data_o_1 YA2GSD $PINS O=o_data[1] I=i_o_data[1] E=n_logic1
+ E2=FE_OFN1150_n_logic0 E4=FE_OFN1150_n_logic0 E8=FE_OFN1150_n_logic0
+ SR=FE_OFN1150_n_logic0
Xipad_data_o_2 YA2GSD $PINS O=o_data[2] I=i_o_data[2] E=n_logic1
+ E2=FE_OFN1150_n_logic0 E4=FE_OFN1149_n_logic0 E8=FE_OFN1149_n_logic0
+ SR=FE_OFN1149_n_logic0
Xipad_data_o_3 YA2GSD $PINS O=o_data[3] I=i_o_data[3] E=FE_OFN1154_n_logic1
+ E2=FE_OFN1146_n_logic0 E4=FE_OFN1146_n_logic0 E8=FE_OFN1146_n_logic0
+ SR=FE_OFN1146_n_logic0
Xipad_data_o_4 YA2GSD $PINS O=o_data[4] I=i_o_data[4] E=FE_OFN1154_n_logic1
+ E2=FE_OFN1144_n_logic0 E4=FE_OFN1144_n_logic0 E8=FE_OFN1144_n_logic0
+ SR=FE_OFN1144_n_logic0
Xipad_data_o_5 YA2GSD $PINS O=o_data[5] I=i_o_data[5] E=FE_OFN1154_n_logic1
+ E2=FE_OFN1142_n_logic0 E4=FE_OFN1142_n_logic0 E8=FE_OFN1142_n_logic0
+ SR=FE_OFN1142_n_logic0
Xipad_data_o_6 YA2GSD $PINS O=o_data[6] I=i_o_data[6] E=FE_OFN1155_n_logic1
+ E2=FE_OFN1140_n_logic0 E4=FE_OFN1140_n_logic0 E8=FE_OFN1140_n_logic0
+ SR=FE_OFN1140_n_logic0
Xipad_data_o_7 YA2GSD $PINS O=o_data[7] I=i_o_data[7] E=FE_OFN1155_n_logic1
+ E2=FE_OFN1138_n_logic0 E4=FE_OFN1138_n_logic0 E8=FE_OFN1138_n_logic0
+ SR=FE_OFN1138_n_logic0
Xipad_data_o_8 YA2GSD $PINS O=o_data[8] I=i_o_data[8] E=FE_OFN1154_n_logic1
+ E2=FE_OFN1149_n_logic0 E4=FE_OFN1148_n_logic0 E8=FE_OFN1149_n_logic0
+ SR=FE_OFN1148_n_logic0
Xipad_data_o_9 YA2GSD $PINS O=o_data[9] I=i_o_data[9] E=FE_OFN1154_n_logic1
+ E2=FE_OFN1148_n_logic0 E4=FE_OFN1148_n_logic0 E8=FE_OFN1148_n_logic0
+ SR=FE_OFN1146_n_logic0
Xipad_data_o_10 YA2GSD $PINS O=o_data[10] I=i_o_data[10] E=FE_OFN1155_n_logic1
+ E2=FE_OFN1136_n_logic0 E4=FE_OFN1136_n_logic0 E8=FE_OFN1136_n_logic0
+ SR=FE_OFN1136_n_logic0
Xipad_data_o_11 YA2GSD $PINS O=o_data[11] I=i_o_data[11] E=FE_OFN1155_n_logic1
+ E2=n_logic0 E4=n_logic0 E8=n_logic0 SR=n_logic0
Xipad_data_o_12 YA2GSD $PINS O=o_data[12] I=i_o_data[12] E=FE_OFN1155_n_logic1
+ E2=FE_OFN1135_n_logic0 E4=FE_OFN1137_n_logic0 E8=FE_OFN1137_n_logic0
+ SR=FE_OFN1137_n_logic0
Xipad_data_o_13 YA2GSD $PINS O=o_data[13] I=i_o_data[13] E=FE_OFN1155_n_logic1
+ E2=FE_OFN1135_n_logic0 E4=FE_OFN1135_n_logic0 E8=FE_OFN1135_n_logic0
+ SR=FE_OFN1135_n_logic0
Xipad_data_o_14 YA2GSD $PINS O=o_data[14] I=i_o_data[14] E=n_logic1
+ E2=FE_OFN1143_n_logic0 E4=FE_OFN1145_n_logic0 E8=FE_OFN1143_n_logic0
+ SR=FE_OFN1145_n_logic0
.ENDS
